# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WLAN_WIGIG60GHZ_DIS#_R: length 5.9
  BOTTOM w0.114: DN1.2 197.32,34.93 v3(197.32,32.78) 197.32,32.14 198.06,31.4 JNGFF1.48
XDP_PRDY#: length 179.5
  TOP w0.114: v2(143.49,78.2) v3(142.71,78.2)
  IN1 w0.094: v2(181.85,26.4) 181.83,26.4 181.6,26.63 176.12,26.63 175.96,26.8 172.22,26.8 171.74,26.31 171.34,26.31 171.12,26.53 168.31,26.53 167.25,27.59 165.64,27.59 163.13,30.1 160.75,30.1 159.83,31.03 153.14,31.03 151.18,32.98 151.18,36.11 140.98,46.31 140.98,62.21 143.5,64.73 143.5,66.81 145.21,68.52 145.21,69.96 146.74,71.49 146.74,72.68 146.04,73.38 145.47,73.38 144.37,74.48 144.37,75.05 143.42,76 143.42,78.12 v2(143.49,78.2)
  IN3 w0.127: v2(86.98,92.67) 86.39,93.27 86.39,94.37 88.53,96.51 89.2,96.51 90.27,97.58 90.27,98.2 90.1,98.36 90.1,99.51 89.37,100.24 89.37,101.92 90.36,102.92 130.79,102.92 131.91,101.8 132.69,101.8 138.74,95.75 138.74,81.99 142.38,78.35 143.29,78.35 143.44,78.2 v2(143.49,78.2)
  BOTTOM w0.076: UH2.AT4 177.63,26.46 177.74,26.36 178.54,26.36 178.57,26.38 181.83,26.38 v2(181.85,26.4) ; UH1.BP27 88.69,92.78 88.3,92.4 87.26,92.4 v2(86.98,92.67)
XDP_PREQ#: length 195.2
  IN1 w0.094: v2(144.76,82.02) 143.7,80.95 143.7,80.09 142.82,79.21 142.82,75.98 143.78,75.02 143.78,74.51 144.6,73.7 144.6,68.8 140.2,64.39 140.2,45.99 149.58,36.6 149.58,35.9 150.29,35.18 150.29,30.76 151.34,29.71 153.67,29.71 154.59,28.78 156.82,28.78 156.87,28.72 163.51,28.72 165.13,27.11 166.09,27.11 166.65,26.55 167.95,26.55 168.81,25.69 169.73,25.69 170.02,25.41 171.54,25.41 171.87,25.74 173.97,25.74 174.29,26.06 175.3,26.06 176.12,25.24 177.43,25.24 177.46,25.27 179.09,25.27 v2(179.16,25.2)
  IN3 w0.127: v2(144.76,82.02) 144.34,82.44 143.7,82.44 141.89,84.25 141.89,97.57 132.31,107.15 90.22,107.15 81.62,98.56 81.62,97.27 80.5,96.15 v2(80.5,94.5)
  BOTTOM w0.076: 85.46,93.94 85.99,94.48 87.13,94.48 87.31,94.65 90.45,94.65 UH1.BL30
  BOTTOM w0.089: UH2.AT3 177.96,25.84 178.52,25.84 v2(179.16,25.2)
  BOTTOM w0.102: 85.46,93.94 84.97,93.94
  BOTTOM w0.114: 84.97,93.94 83.86,93.94 83.85,93.93 83.43,93.93 83.02,93.52 RH156.2 83.02,93.26 82.28,92.52 81.01,92.52 80.73,92.8 80.73,94.27 v2(80.5,94.5)
XTAL24_IN: length 10.6
  BOTTOM w0.089: 178.27,44.44 178.14,44.31 177.22,44.31 176.53,43.61 UH2.A6
  BOTTOM w0.127: YH2.1 184.94,44.71 183.54,44.71 183.25,45 CH47.1 182.86,45.02 RH72.1 181.49,44.52 v2(180.9,44.52) 178.35,44.52 178.27,44.44
XTAL24_OUT: length 8
  BOTTOM w0.089: 179.03,43.88 178.78,44.13 177.3,44.13 176.96,43.79 UH2.A5
  BOTTOM w0.127: 179.03,43.88 v2(179.46,43.88) 181.77,43.88 RH72.2 182.03,44.14 CH48.1 183.25,44.14 183.92,43.47 YH2.3
XTAL_OUT: length 9.5
  BOTTOM w0.114: UV1.H2 176.49,76.71 176.49,76.53 177,76.02 177,74.01 RV52.2 176.91,73.13 176.91,72.98 CV71.2 177.04,72.16 177.52,72.16 177.69,72 177.69,70.61 177.56,70.47 177.05,70.47 176.75,70.77 YV1.3
XTALIN: length 9.4
  BOTTOM w0.114: UV1.H3 176.29,77.41 176.74,76.95 176.74,76.65 177.26,76.13 177.26,73.69 RV52.1 177.17,73.27 177.17,72.99 CV70.2 177.95,72.21 177.95,70.59 YV1.1
XTALOUT: length 2.2
  TOP w0.102: RV51.1 175.15,77.86 v2(175.15,78.1) v3(175.52,78.47)
  BOTTOM w0.102: UV1.J4 175.49,78.44 v2(175.15,78.1)
XTALSSIN: length 3.1
  TOP w0.102: v3(177.19,75.58) 177.19,75.17
  TOP w0.114: v2(175.95,75.6) 175.95,75.5 176.78,74.67 RV49.1 177.19,75.02 177.19,75.17
  BOTTOM w0.114: UV1.H1 176.17,76.11 175.95,75.89 v2(175.95,75.6)
XTLI: length 3.8
  BOTTOM w0.127: YL2.1 280.98,45.67 281.65,45 CL36.1 281.93,44.89 UL1.29
XTLO: length 6.3
  BOTTOM w0.127: UL1.28 282.18,44.49 CL37.1 281.69,44.14 281.26,44.57 279.28,44.57 278.81,44.1 YL2.3
N06177: length 5.2
  TOP w0.114: UM1.36 265.31,39.37 265.17,39.51 263.79,39.51 263.06,40.24 263.06,40.78 RM517.1 v3(261.58,41.19)
N10178: length 3
  TOP w0.114: RM600.1 262.33,37.96 263.26,37.03 263.69,37.03 263.79,36.93 UM1.40
N16840: length 5.3
  TOP w0.114: RM1.1 272.17,30.06 v4(270.95,31.29) 270.51,31.72 269.27,31.72 268.51,32.48 UM1.9
N48197: length 5.3
  BOTTOM w0.203: PU1100.2 68.26,87.77 67.79,87.3 67.79,87.16
  BOTTOM w0.254: PR1105.2 PC1104.2 65.8,85.92 v3(66.72,85.92) 67.37,85.92 67.79,86.34 67.79,87.16
N48329: length 4.1
  TOP w0.114: v2(67.27,88.15) v3(68.02,88.15)
  TOP w0.254: PC1106.2 PR1118.2 66.84,87.75 67.24,88.15 v2(67.27,88.15)
  BOTTOM w0.203: v2(67.27,88.15) 67.65,88.15 68.06,88.57 PU1100.4
N48371: length 1.9
  TOP w0.114: PC1107.2 v3(64.78,88.71)
  TOP w0.254: PR1118.1 64.79,87.75 PC1107.2
N48789: length 4.7
  BOTTOM w0.114: PR1135.1 76.74,93.06 v3(76.13,93.67)
  BOTTOM w0.203: 76.24,91.48 75.32,90.57 PU1100.28
  BOTTOM w0.254: PR1135.1 PC1120.1 76.46,91.71 76.24,91.48
N48933: length 2
  BOTTOM w0.114: PC1123.1 79.46,94.19 v3(79.16,94.49)
  BOTTOM w0.254: PR1133.2 PC1123.1
N48941: length 7.2
  BOTTOM w0.114: v3(77.61,94.06) 77.61,93.51 PR1133.1
  BOTTOM w0.203: 77.73,91.18 76.44,91.18 75.43,90.17 PU1100.29
  BOTTOM w0.254: PR1133.1 PC1121.1 78.04,91.18 77.73,91.18
N48965: length 0.9
  BOTTOM w0.254: PC1122.1 PR1134.2
N48979: length 7.6
  BOTTOM w0.203: PU1100.30 75.61,89.77 v3(75.89,90.05) 76.26,90.41
  BOTTOM w0.254: PR1128.1 80.72,90.17 PR1129.1 80.6,90.06 77.38,90.06 PR1134.1 76.51,90.67 76.26,90.41
N49205: length 4
  TOP w0.114: v2(67.83,90.19) v3(68.5,90.19)
  TOP w0.254: v2(67.83,90.19) 67.83,90.13 67.47,89.78 66.82,89.78 PR1136.2 66.62,88.65 PC1119.2
  BOTTOM w0.203: v2(67.83,90.19) 67.85,90.17 PU1100.8
N49217: length 2.3
  TOP w0.114: v3(64.55,90.07) 65.24,90.07 PR1132.2
  TOP w0.254: PC1119.1 65.72,89.56 PR1132.2
N49289: length 5.1
  TOP w0.114: v2(67.31,86.59) v3(67.99,86.59)
  TOP w0.203: v2(67.31,86.59) 67.26,86.59 PC1105.2 66.62,85.96 PR1111.2
  BOTTOM w0.203: PU1100.3 68.15,88.17 67.31,87.33 v2(67.31,86.59)
N49471: length 2.7
  BOTTOM w0.114: PR1124.1 78.84,86.63 78.84,86.16 v3(78.41,85.73)
  BOTTOM w0.254: PC1110.2 77.44,87.1 PR1124.1
N49551: length 2.9
  BOTTOM w0.203: PU1100.33 75.3,88.57 75.37,88.64 75.82,88.64 76.33,88.13 76.39,88.13
  BOTTOM w0.254: PC1110.1 PR1121.1 76.39,88.13
N49667: length 4.3
  TOP w0.114: v2(68.69,84.72) v3(69.2,85.23)
  TOP w0.203: v2(68.69,84.72) 68.69,84.24 PR1109.2
  BOTTOM w0.203: v2(68.69,84.72) 69.4,85.44 69.89,85.44 70.34,85.89 PU1100.46
N49815: length 2.2
  BOTTOM w0.203: 75.52,86.99 75.14,87.37 PU1100.36
  BOTTOM w0.254: 75.52,86.99 75.75,86.99 PR1123.1
N50153: length 4.9
  BOTTOM w0.114: v3(72.31,79.67) 72.31,81.08 PR1101.2
  BOTTOM w0.508: PR1101.2 72.55,81.78 72.55,83.48 72.02,84.01
N50385: length 4.7
  BOTTOM w0.203: PU1100.14 69.94,93.18 69.64,93.47 68.34,93.47 v3(67.98,93.83) 67.95,93.86 PC1136.1 PR1143.1
N50425: length 86.3
  IN4 w0.254: v2(128.27,123.43) 127.21,122.37 127.21,109.97 125.59,108.35 85.27,108.35 82.04,105.12 78.52,105.12 v2(76.21,107.43)
  BOTTOM w0.254: v2(76.21,107.43) 75.77,106.99 73.9,106.99 72.18,105.27 70.18,105.27 69.42,104.51 69.42,102.33 68.18,101.09 v3(68.18,99.69) 68.18,97.35 PR1144.1 PR1141.1 ; PH1104.1 128.03,123.19 v2(128.27,123.43)
N50433: length 3.1
  BOTTOM w0.203: PU1100.15 70.34,93.28 69.76,93.87 v3(69.35,93.87) 68.84,94.38 PR1141.2
N50477: length 3.7
  BOTTOM w0.114: PU1100.40 72.74,86.14 73.49,85.39 v3(74.14,85.39) 74.94,84.59 PR1116.1
N50505: length 3.9
  BOTTOM w0.114: PU1100.39 73.14,86.18 73.62,85.7 74.27,85.7 PR1115.1
N50517: length 4.4
  BOTTOM w0.114: PU1100.38 73.54,86.17 73.8,85.91 74.95,85.91 v3(75.53,85.33) PR1114.1
N50567: length 5.4
  BOTTOM w0.114: PU1100.37 75.31,86.54 PR1113.1 76.98,84.86 77.96,84.86 v3(78.45,84.38)
N50631: length 1
  BOTTOM w0.254: PR1147.2 PC1139.1
N50639: length 5.6
  TOP w0.114: v3(68.7,96.23) 69.14,95.8 PC1137.1
  TOP w0.203: PC1137.1 69.73,94.55 v2(70.14,94.15)
  BOTTOM w0.203: PR1147.1 69.73,94.63 70.14,94.22 v2(70.14,94.15) 70.74,93.55 PU1100.16
N50651: length 1
  BOTTOM w0.254: PR1145.2 PC1138.1
N50739: length 6.6
  TOP w0.114: v3(69.63,97.75) 70.44,96.94 PR1142.1
  TOP w0.203: v2(70.8,94.15) 70.61,94.34 PR1146.1
  TOP w0.254: PR1146.1 70.62,95.63 PR1142.1
  BOTTOM w0.203: PR1145.1 70.62,94.4 70.8,94.22 v2(70.8,94.15) 70.8,93.97 71.08,93.69 71.08,93.16 71.14,93.09 PU1100.17
N51003: length 9.6
  TOP w0.254: v2(72.27,93.59) v4(72.67,93.19) 73.09,92.78 74.51,92.78 74.97,93.23 76.04,93.23 v2(77.03,94.23)
  BOTTOM w0.203: PU1100.20 72.34,93.52 v2(72.27,93.59)
  BOTTOM w0.254: v2(77.03,94.23) 76.6,94.66 PR1137.1 77.23,96.37 PC1133.1
N51011: length 1.9
  BOTTOM w0.114: v3(78.22,97.6) PC1133.2
  BOTTOM w0.254: PC1133.2 PR1139.1
N57527: length 45.6
  IN1 w0.254: v2(74.81,104.38) 74.81,104.2 74.94,104.08 76.38,104.08 76.56,104.26 81.82,104.26 87.63,110.07 101.68,110.07 102.4,110.8 102.4,117.62 102.88,118.1 103.77,118.1 v2(104.02,118.35)
  BOTTOM w0.254: PR1437.1 73.59,105.53 73.61,105.53 PR1438.1 74.47,105.68 v3(74.47,104.79) v2(74.81,104.38) ; v2(104.02,118.35) 104.18,118.19 104.98,118.19 105.23,118.45 PR1435.2
N3514407: length 3
  BOTTOM w0.203: PR405.2 55.38,19.55 v3(55.1,19.83) 55.1,19.88 54.23,20.76 PU400.5
N3514423: length 3.3
  BOTTOM w0.203: PU400.3 54.62,21.55 v2(54.73,21.44)
  BOTTOM w0.254: PC400.1 55.69,22.1 PR400.2 55.1,21.07 v2(54.73,21.44)
N3514453: length 2.3
  BOTTOM w0.203: v3(49.68,21.49) 49.74,21.55 PU400.13
  BOTTOM w0.254: PC421.1 49.58,21.39 v3(49.68,21.49)
N13347359: length 5.3
  TOP w0.114: v3(67.73,85.26) 68.08,84.9 v2(68.08,84.7)
  TOP w0.254: v2(68.08,84.7) 67.57,84.19 PR1117.2
  BOTTOM w0.203: PU1100.47 69.94,86.02 69.74,85.82 69.12,85.82 68.08,84.78 v2(68.08,84.7) 68.18,84.6 68.18,84.04 PR1112.2
N13351923: length 3.4
  BOTTOM w0.508: PR1102.2 74.24,82.17 74.24,83.56 PC1103.1
  vias: v3(72.69,85.4)
N13352071: length 3.6
  BOTTOM w0.203: PR1120.2 67.32,84.58 v3(68.13,85.39) 69.28,86.54 PU1100.48
N13353452: length 4.2
  BOTTOM w0.254: PU1100.5 67.83,88.97 v3(67.55,88.69) 67.52,88.66 66.74,88.66 PR1119.2 66.63,87.9 PR1122.2 65.63,87.82 PR1127.2
N17034077: length 3
  BOTTOM w0.203: PR406.1 v2(54.49,24.34) 54.49,23.97 53.82,23.3 PU400.1
N17034092: length 3.8
  BOTTOM w0.114: PR416.2 49.4,19.5 49.93,18.98 v3(50.04,18.98)
  BOTTOM w0.203: PU400.12 49.95,21.16 49.74,20.95
  BOTTOM w0.254: PR416.2 49.16,20.36 PC420.1 49.74,20.95
N18094620: length 19.5
  TOP w0.508: v2(290.74,96.31) 290.74,91.58 v4(292.62,89.7) RL40.2 RL39.2 RL20.2 RL19.2
  BOTTOM w0.508: CL33.1 289.97,97.08 v2(290.74,96.31)
N18094850: length 3.3
  BOTTOM w0.203: UL1.31 283.5,45.69 283.31,45.89
  BOTTOM w0.254: 283.31,45.89 v3(282.84,45.89) 282.72,45.89 282.42,46.19 282.42,46.79 RL31.2
N18095026: length 1.2
  BOTTOM w0.114: T944.1 282.87,44.09 UL1.27
N18095028: length 1.9
  BOTTOM w0.114: UL1.25 283.67,43.29 282.57,42.19 T95.1
N18358621: length 9.1
  BOTTOM w0.114: UV14.4 143.3,77.6 142.9,78.01 142.9,79.07 143.37,79.54 RV587.1 145.49,79.54 145.56,79.62 146.39,79.62 v3(147.37,78.64) 147.81,78.64 148.07,78.89 RV208.1
N19473413: length 5.4
  BOTTOM w0.127: PR1804.1 148.46,27.05 v3(149.37,27.05)
  BOTTOM w0.381: PU1800.7 146.23,24.76 147.05,25.58 PC1802.2 PR1803.2 148.14,26.74 PR1804.1
N19473597: length 5.6
  BOTTOM w0.254: PU1800.1 147.5,21.19 147.94,21.63 v3(149.17,21.63) 149.55,21.63 149.87,21.31 PR1800.2
N19473637: length 1
  TOP w0.114: v4(144,28.51) 144,27.52
  vias: v2(144.79,27.49) v2(144.79,26.9)
N19901660: length 1.8
  TOP w0.114: RE10.1 CE78.2 v3(227.15,12.11)
N20173493: length 6.9
  TOP w0.114: UE1.120 225.05,30.54 v2(224.9,30.39)
  BOTTOM w0.114: v3(225.38,30.92) 224.9,30.44 v2(224.9,30.39) 224.59,30.08 224.59,29.55 RE22.1 224.27,28.74 224.34,28.67 224.34,27.68 224.77,27.24 RE20.1
N20335974: length 2.4
  BOTTOM w0.114: v3(277.45,47.26) RL41.1
  BOTTOM w0.254: UL2.3 278.26,48.25 RL41.1
N20440449: length 6.4
  TOP w0.254: UE1.54 230.25,15.26 229.84,14.84 v2(229.63,14.84)
  BOTTOM w0.254: RE15.2 226.91,15.56 CE71.1 227.25,15.28 227.51,15.03 228.08,15.03 228.44,14.66 228.44,14.4 228.7,14.15 v3(228.98,14.15) 229.63,14.81 v2(229.63,14.84)
N21876819: length 7.8
  BOTTOM w0.508: RV141.1 201.41,73.6 v4(196.19,73.6) 195.26,73.6 194.74,74.12 QV21.1
N25791938: length 3.5
  BOTTOM w0.114: QV20.1 192.53,119.15 v3(192.88,118.8)
  BOTTOM w0.406: QV20.1 191.02,120.31 RV126.1
N32834652: length 2.2
  TOP w0.203: RA19.1 279.84,20.13 v3(280.3,20.59) 280.31,20.61 HDA1.16
N34662854: length 4.1
  TOP w0.203: HDA1.20 281.91,20.45 282.05,20.31
  TOP w0.508: RA17.1 RA18.1 282.46,18.86 v3(282.46,19.9) 282.05,20.31
N35924928: length 2
  TOP w0.102: v3(176.41,97.75) 176.41,97.69 176.09,97.37 v2(176.06,97.37)
  TOP w0.114: v2(176.06,97.37) 175.63,97.37 RV77.2
  BOTTOM w0.305: UV1.J27 175.93,97.37 v2(176.06,97.37)
N35928308: length 4.3
  TOP w0.102: RV78.2 175.45,100.55 175.2,100.31 v3(174.77,100.31)
  TOP w0.114: RV78.2 175.74,100.28 175.5,100.04 175.5,98.6 v2(175.89,98.21)
  BOTTOM w0.3: v2(175.89,98.21) 175.99,98.21 UV1.H27
N35950826: length 4.1
  TOP w0.114: RV79.2 179.7,96.89 179.47,96.89 179.46,96.9 179.12,96.9 179.11,96.89 v3(178.89,96.89) 177.2,96.89 v2(176.79,96.48)
  BOTTOM w0.305: UV1.H25 176.79,96.46 v2(176.79,96.48)
N48676721: length 3.9
  TOP w0.114: RE3.2 120.65,14.82 v2(120.78,14.7) 120.78,14.17 120.32,13.71 v4(119.77,13.71)
  BOTTOM w0.114: JBL1.2 120.59,14.89 v2(120.78,14.7)
N48680518: length 9
  TOP w0.114: v3(215.1,35.11) 214.32,34.33 RE1.1 CE1.1 213.24,33.54 213.44,33.34 QE3.1 212.14,31.21 210.17,31.21 209.86,31.51 QE4.2
N48680573: length 3.3
  TOP w0.114: QE4.1 210.83,35.22 RE2.1 v3(208.87,36.19)
N52997531: length 3.2
  TOP w0.114: PR114.2 15.24,33.86 PD100.1 15.24,32.45 PL106.1 v3(15.81,32.12)
N52999984: length 3.4
  TOP w0.114: v3(17.84,28.39) PR102.1 ; PR102.1 16.67,28.29 PQ100.3 ; PR102.1 PR100.2
N52999986: length 12.5
  TOP w0.114: PL106.2 14.06,30.67 PQ100.1 16.57,30.37 PR100.1 ; PR100.1 15.94,29.33 13.09,29.33 12.53,28.77 PR103.1 ; PR100.1 v3(16.77,31.28)
N101473516: length 10.9
  TOP w0.114: v2(170.95,131.69) 171.08,131.56 RV116.1
  BOTTOM w0.114: UV6.J1 175.18,125.71 172.13,125.71 171.36,126.48 171.36,130.94 v4(171.17,131.12) 170.95,131.35 v2(170.95,131.69)
N101473793: length 4.9
  TOP w0.102: v2(186.6,124.49) v3(186.19,124.08) 186.19,123.43 186.32,123.31 187.79,123.31
  TOP w0.114: RV120.1 187.79,123.31
  BOTTOM w0.114: v2(186.6,124.49) 186.18,124.91 185.73,124.91 185.35,125.29 UV6.J13
N101484120: length 10.8
  TOP w0.102: v2(167.3,125.27) 165.37,125.27 165.11,125.53 165.11,125.85 165.85,126.58 v4(166.13,126.58) 166.75,127.21 166.75,129.29 167.14,129.68 168.7,129.68 168.74,129.63
  TOP w0.114: RV117.1 169.22,129.45 169.04,129.63 168.74,129.63
  BOTTOM w0.114: v2(167.3,125.27) 166.71,125.27 UV7.J1
N101484397: length 3.9
  TOP w0.102: v2(155.74,124.49) 156.07,124.49 v3(156.25,124.31)
  TOP w0.114: v2(155.74,124.49) 155.37,124.12 154.44,124.12 RV121.1
  BOTTOM w0.114: v2(155.74,124.49) 156.14,124.89 156.7,124.89 UV7.J13
N101908901: length 9
  TOP w0.114: RV131.1 v3(207.25,93.51) v2(207.78,94.05)
  BOTTOM w0.114: UV9.J1 203.86,97.01 203.58,96.74 203.58,94.81 204.27,94.12 207.71,94.12 v2(207.78,94.05)
N101909174: length 5.6
  TOP w0.102: v3(202.66,108.02) v2(203.06,108.42) 203.06,108.43 203.72,109.08
  TOP w0.114: 203.72,109.08 203.92,109.29 203.92,109.41 205.17,110.66 RV135.1
  BOTTOM w0.114: UV9.J13 203.76,107.06 203.46,107.36 203.46,108.17 203.21,108.42 v2(203.06,108.42)
N101910032: length 6.2
  TOP w0.114: v2(204.99,91.94) 205.17,91.76 RV132.1
  BOTTOM w0.114: UV8.J1 203.86,87.48 203.46,87.87 203.46,87.91 203.46,87.92 203.46,88.24 203.46,88.25 203.46,88.48 203.43,88.51 203.43,88.85 203.59,89.01 203.59,90.67 v4(204.34,91.42) 204.86,91.94 v2(204.99,91.94)
N101910312: length 4.9
  TOP w0.102: v2(203.06,76.48) v3(202.7,76.84) 202.59,76.95 202.07,76.95 201.86,76.75 201.86,76.19
  TOP w0.114: RV136.1 201.86,76.19
  BOTTOM w0.114: v2(203.06,76.48) 203.24,76.48 203.46,76.7 203.46,77.33 203.86,77.73 UV8.J13
N108873638: length 2.2
  BOTTOM w0.203: PU400.20 53.07,23.72 v3(53.5,24.15) 53.6,24.25 PR409.1
N109801960: length 4.4
  TOP w0.114: QZ6.2 205,70.33 205.22,70.11 205.39,70.11 205.65,70.38 QZ6.3 206,70.6 206.77,71.36 v3(206.77,71.8) RZ12.2
N109970739: length 2
  BOTTOM w0.203: PU400.19 52.67,23.49 52.74,23.56 v2(52.74,24.44) 52.74,25.04 PR411.1
N111798152: length 2.1
  TOP w0.114: UZ1.12 212.92,12.54 212.85,12.47 212.02,12.47 211.88,12.61 CZ4.1
N111798158: length 3.6
  TOP w0.114: UZ1.10 212.31,13.34 v2(212.24,13.41) 211.92,13.41 CZ6.1
  BOTTOM w0.114: v2(212.24,13.41) 212.13,13.41 v3(211.22,14.32)
N120139517: length 1.9
  TOP w0.114: v3(178.85,42.42) 178.91,42.42 v2(179.28,42.05) 179.25,42.01 RH71.2
  BOTTOM w0.102: v2(179.28,42.05) 178.99,41.76 UH2.E1
N120174690: length 2.4
  TOP w0.114: v2(172.6,25.09) 173.09,25.57 T20.1
  BOTTOM w0.089: UH2.AV15 172.28,25.41 v2(172.6,25.09)
N120176772: length 9.9
  BOTTOM w0.114: UH2.V44 157.46,35.46 157.41,35.51 157.07,35.51 156.65,35.93 156.35,35.93 155.83,36.45 154.94,36.45 154.67,36.72 152.37,36.72 151.52,35.87 151.52,34.58 152.7,33.4 T2.1
N120176782: length 3.9
  BOTTOM w0.102: UH2.L43 157.86,39.26 157.19,39.26 156.6,39.84
  BOTTOM w0.114: 156.6,39.84 155.94,40.5 T4.1
N120176822: length 7.8
  BOTTOM w0.076: UH2.BD36 161.28,22.47 160.78,21.98
  BOTTOM w0.102: 155.66,19.09 156.11,19.54 159.16,19.54 160.44,20.81 160.44,21.63 160.78,21.98
  BOTTOM w0.114: T8.1 155.66,19.09
N120177456: length 3.6
  BOTTOM w0.076: T17.1 170.89,19.7 170.4,19.7 170.18,19.91 170.18,20.81 170.66,21.29 170.66,22.18 UH2.BD17
N120361004: length 4.6
  BOTTOM w0.114: JNGFF2.38 217.13,27.58 RD7.2 217.36,27.26 217.43,27.18 RD59.1 217.17,26.52 217.17,25.91 v3(217.01,25.76)
N120361079: length 4.8
  BOTTOM w0.114: JNGFF2.68 215.99,20.08 216.44,20.53 217.47,20.53 RD9.1 217.44,21.9 v3(217.44,22.18)
N120970730: length 1.2
  TOP w0.114: PC1409.1 v3(126.16,122.86)
N120976432:
  vias: v2(104.09,122.5) v4(103.77,123.08)
N121033408: length 7.5
  BOTTOM w0.203: 52.97,19.28 52.67,19.58 PU400.7
  BOTTOM w0.254: PR410.2 PR408.2 55.59,16.53 54.14,16.53 53.93,16.73 53.93,18.32 v3(53.55,18.7) 52.97,19.28
N121163993: length 7.4
  BOTTOM w0.305: RH150.2 124.2,69.54 v3(124.49,69.82) 125.69,71.02 125.69,72.1 124.19,73.6 124.19,73.87 123.88,74.18 123.66,74.18 UH1.J2
N121163994: length 7.7
  BOTTOM w0.254: 124.6,72.63 123.77,73.46 UH1.H1
  BOTTOM w0.305: 124.6,72.63 125.1,72.14 125.1,71.37 124.35,70.63 122.49,70.63 v3(122.13,70.27) RH149.2
N121163995: length 6.2
  BOTTOM w0.305: UH1.G1 126.32,72.04 126.32,70.07 v3(125.89,69.64) 125.56,69.31 RH148.2
N121388945: length 10.1
  BOTTOM w0.076: 181.82,31.49 181.67,31.33 181.24,31.33 180.63,30.72 180.63,30.37 179.97,29.71 178.53,29.71 178.43,29.81 177.63,29.81 UH2.AJ4
  BOTTOM w0.102: 181.82,31.49 182.13,31.79 182.13,32.43 182.46,32.76 182.81,32.76
  BOTTOM w0.114: 182.81,32.76 183.17,33.11 v3(183.17,33.93) 183.24,34 183.24,34.05 RH189.1
N121479122: length 8.3
  BOTTOM w0.254: UH1.AG38 109.07,100.66 109.1,100.69 109.1,103.83 108.76,104.17 v3(108.76,104.9) 108.13,105.54 108.13,105.61 107.98,105.76 107.91,105.76 107.89,105.77 107.26,105.77 107.25,105.78 RH29.1 RH28.1
N121480352: length 6.2
  BOTTOM w0.254: RH41.1 RH31.1 117.52,102.92 118.02,102.43 118.74,102.43 v3(118.92,102.25) 118.92,102.11 120.48,100.55 120.48,100.11 UH1.M37
N121480355: length 7.1
  BOTTOM w0.114: v3(118.53,105.55) 118.88,105.2 118.88,103.62 118.48,103.22
  BOTTOM w0.254: UH1.M38 120.84,100.41 120.84,100.93 119.43,102.34 RH201.1 RH202.1
N121480375: length 2.2
  TOP w0.114: v2(115.03,80.61) 115.11,80.61 v3(115.46,80.25)
  TOP w0.305: RH34.2 114.89,80.61 v2(115.03,80.61)
  BOTTOM w0.203: v2(115.03,80.61) 114.89,80.61 114.61,80.9 UH1.Y12
N121507165: length 4.7
  BOTTOM w0.114: RH57.2 85.51,88.84 86.62,88.84 87.13,89.35 87.13,90.54 87.39,90.8 87.82,90.8 UH1.BR25
N121507167: length 4.2
  BOTTOM w0.114: RH58.2 86.45,91.56 88.53,91.56 UH1.BP25
N121507169: length 2.7
  BOTTOM w0.203: RH166.2 86.15,94.19 87.41,94.19 UH1.BT29
N121673930: length 0.9
  BOTTOM w0.254: PR1122.1 66.55,86.92 PC1109.2
N121674134: length 1.9
  TOP w0.114: PR1142.2 v3(70.62,98.88)
  TOP w0.254: PC1134.1 PR1142.2
N121674335: length 2
  BOTTOM w0.114: v3(80.38,93.02) 80.38,92.36 PR1128.2
  BOTTOM w0.254: PC1115.1 PR1128.2
N121710332: length 11
  BOTTOM w0.254: UH1.AG37 109.22,99.71 109.45,99.94 109.45,102.27 109.79,102.61 109.79,105.48 v3(108.87,106.39) 108.34,106.92 107.32,106.92 RH197.2 RH198.1
N121712022: length 5.9
  BOTTOM w0.254: RH204.1 RH203.2 106.7,103.2 106.89,103.38 108.06,103.38 108.38,103.06 108.38,101.35 108.28,101.25 UH1.AH38
N121795600:
  vias: v2(124.72,122.65) v4(124.2,123.01)
N121981266: length 71.9
  TOP w0.254: v2(71,104.13) v4(63.76,96.89) 63.76,88.51 63.13,87.87 63.13,85.21 63.69,84.65 65.19,84.65 65.72,84.11 PR1110.2 PR1111.1
  IN4 w0.254: v2(97.8,123.31) 92.26,123.31 91.96,123.61 89.67,123.61 86.52,120.46 71.94,120.46 71.56,120.09 71.56,114.65 69.93,113.02 69.93,107.87 70.11,107.69 70.11,104.92 70.91,104.13 v2(71,104.13)
  BOTTOM w0.254: PH1100.2 98.33,123.64 98,123.31 v2(97.8,123.31)
N121981305: length 2
  BOTTOM w0.114: PR1130.2 86.24,120.44 v3(85.94,120.74)
  BOTTOM w0.254: PR1130.2 PH1102.1
N121981509: length 2.6
  BOTTOM w0.114: PR1125.1 129.7,117.57 v3(129.7,117.24)
  BOTTOM w0.254: PH1101.2 130.62,118.1 PR1125.1
N121981539: length 0.9
  BOTTOM w0.254: PR1140.1 PH1103.2
N122017994:
  vias: v2(113.99,122.67) v4(113.71,123.23)
N122314333: length 7.1
  BOTTOM w0.254: RH32.1 RH33.1 107.24,103.74 108.27,103.74 v3(108.6,103.41) 108.73,103.28 108.73,100.92 108.66,100.85 108.66,100.09 UH1.AH37
N122397475: length 13
  TOP w0.102: v2(124.61,94.19) 124.95,93.85 124.95,93.15 125.4,92.7
  TOP w0.114: 125.4,92.7 125.91,92.19 127.66,92.19 127.76,92.09 131.73,92.09 132.98,93.34 v3(132.98,93.69) 132.98,94.4 RH145.1
  BOTTOM w0.102: v2(124.61,94.19) 124.61,94.28 124.31,94.58 UH1.G29
N122449909: length 3.7
  TOP w0.254: RH514.1 121.57,84.19 122.4,83.37 v2(122.4,83.28) 122.54,83.28 123.07,83.81 RH515.1
  BOTTOM w0.203: v2(122.4,83.28) 122.51,83.16 123.22,83.16 UH1.H14
N122449918: length 2.6
  TOP w0.254: RH513.1 121.7,83.3 122.31,82.69 v2(122.38,82.69) 122.89,82.69 RH516.1
  BOTTOM w0.254: UH1.J14 122.93,82.75 122.44,82.75 v2(122.38,82.69)
N122476680: length 58
  IN1 w0.254: v2(122.56,118.48) 122.37,118.29 120.77,118.29 118.88,116.41 118.88,114.83 118.12,114.07 118.12,111.59 118.58,111.13 118.58,108.58 117.97,107.97 109.18,107.97 108.98,107.76 87.94,107.76 82.27,102.1 80.71,102.1 v2(80.6,102.2)
  BOTTOM w0.254: v2(80.6,102.2) 80.45,102.35 PR1410.1 79.7,101.7 PR1409.1 ; v2(122.56,118.48) 122.76,118.29 123.52,118.29 123.77,118.54 PR1407.2
N122477585: length 49.8
  IN1 w0.254: v2(77.99,103.24) 78.11,103.11 81.98,103.11 87.54,108.68 108.03,108.68 110.5,111.15 110.5,117.12 111.61,118.23 113.29,118.23 v2(113.55,118.48)
  BOTTOM w0.254: PR1424.1 77.04,103.25 PR1423.1 77.81,103.06 v2(77.99,103.24) ; v2(113.55,118.48) 113.67,118.35 114.63,118.35 114.88,118.61 PR1421.2
N122559938: length 70.8
  TOP w0.114: QV10.1 177.66,62.69 RH517.2 v3(177.66,60.15) 177.66,60.05 177.77,59.94 179.68,59.94 180.15,59.47 180.41,59.47 180.98,58.91 187.79,58.91 188.72,57.98 188.72,55.97 185.62,52.87 v2(185.62,52.45)
  IN3 w0.127: v2(185.62,52.45) 187.79,50.28 187.79,40.1 186.65,38.96 186.65,38.17 186.95,37.87 186.95,34.65 186.02,33.72 184.69,33.72 184.19,33.21 184.19,31.97 v2(183,30.79)
  IN4 w0.094: v2(183,30.79) 181.91,29.7 180.62,29.7 179.71,28.79 176.59,28.79 176.46,28.67 174.33,28.67 174.33,28.66 174.02,28.66 174.01,28.67 171.61,28.67 171.36,28.41 168.39,28.41 167.65,27.68 166.3,27.68 165.16,26.53 165.16,26.08 164.78,25.69 v2(164.4,25.69)
  BOTTOM w0.102: v2(164.4,25.69) 164.93,25.16 165.69,25.16 UH2.AW27
N122563835: length 138.9
  TOP w0.114: RH89.2 v4(150.9,35.21) 150.27,35.21 149.02,36.47 146.39,36.47 145.88,35.96 145.18,35.96 141.76,39.38 v2(141.76,39.39)
  IN3 w0.127: v2(141.59,80.71) 139.66,82.64 139.66,96.15 131.96,103.85 90,103.85 87.41,101.25 87.41,98.06 86.5,97.15 v2(86.5,97.02)
  IN4 w0.094: v2(141.59,80.71) 140.7,79.82 140.7,75.76 143.6,72.86 143.6,65.93 139.99,62.32 139.99,43.37 141.76,41.61 v2(141.76,39.39)
  BOTTOM w0.076: v2(86.5,97.02) 87.15,96.37 87.88,96.37 UH1.BR33
N122712620: length 4.8
  BOTTOM w0.114: JNGFF2.69 v3(206.28,19.83) 206,19.83 205.14,18.96 RD10.2 RD58.2
N122754354: length 3.1
  TOP w0.114: UZ16.6 70.63,48.28 CZ57.1 v3(69.45,49.46)
N122763041: length 2.5
  BOTTOM w0.114: UZ17.6 151.26,110.37 CZ95.1 152.08,110.38 v3(152.24,110.54)
N123052806: length 4.3
  TOP w0.114: v3(191.56,26.83) 191.56,26.32 191.16,25.92 RH106.2 190.72,25.56 190.28,26 189.68,26 189.42,26.27 UH14.2
N123983992:
  vias: v2(76.59,110.99) v4(76.1,113.77)
N123984002: length 24
  IN1 w0.254: v2(67.19,106.54) 68.34,107.69 74.18,107.69 79.51,113.02 81.67,113.02 v2(81.8,113.15)
  BOTTOM w0.254: v2(67.19,106.54) PR1521.1 66.49,105.39 PR1522.1 ; PR1519.2 81.67,116.96 81.92,116.7 81.92,113.27 v2(81.8,113.15)
N123984041:
  vias: v2(136.13,128.11) v2(136.41,127.42) v2(136.59,128.82) v2(136.94,128.08) v2(137.58,128.79) v2(137.88,128.08) v4(138.45,128.45)
N123984081: length 41.6
  IN1 w0.254: v2(66.68,102.71) 66.86,102.89 68.32,102.89 70.32,104.89 81.72,104.89 87.51,110.68 88.81,110.68 89.29,111.17 89.29,113.19 90.66,114.55 90.66,117.68 90.1,118.23 89.04,118.23 v2(88.91,118.35)
  BOTTOM w0.254: v2(88.91,118.35) 89.04,118.23 91.2,118.23 91.83,118.86 PR1506.2 ; PR1510.1 64.86,101.73 PR1509.1 65.83,102.71 v2(66.68,102.71)
N123984213: length 26.5
  TOP w0.254: PR1526.1 v2(66.84,104.38)
  IN1 w0.254: v2(82.56,113.15) 82.05,112.64 79.67,112.64 74.34,107.31 68.82,107.31 66.84,105.32 v2(66.84,104.38)
  BOTTOM w0.254: PR1526.1 v2(66.84,104.38) ; v2(82.56,113.15) 82.43,113.27 82.43,116.7 82.69,116.96 PR1520.2
N123984271:
  vias: v2(132.09,120.64) v2(132.09,119.62) v2(132.09,118.48) v2(133.23,121.91) v2(134.25,120.64) v2(135.01,120.51) v2(136.03,118.23) v4(132.69,122.42)
N123984459: length 1.3
  TOP w0.114: PC1507.1 v3(95.22,122.74)
N123984461:
  vias: v2(93.8,122.42) v4(90.23,123.28)
N123985122: length 40.1
  TOP w0.127: v2(66.68,103.42) v3(67.36,103.42)
  TOP w0.254: v2(66.68,103.42) 66.63,103.37 PR1525.1
  IN1 w0.254: v2(66.68,103.42) 66.84,103.27 68.16,103.27 70.16,105.27 81.56,105.27 87.35,111.06 88.65,111.06 88.91,111.32 88.91,113.35 90.27,114.71 90.27,117.52 89.95,117.85 89.16,117.85 v2(88.91,117.59)
  BOTTOM w0.254: v2(88.91,117.59) 89.16,117.85 91.2,117.85 91.83,117.21 PR1507.2 ; PR1525.1 66.63,103.37 v2(66.68,103.42)
N124752685: length 2.1
  TOP w0.114: v3(71.1,44.72) RH211.1
  TOP w0.508: CH101.2 69.94,44.8 RH211.1
N124753277: length 2.7
  TOP w0.114: RH212.1 110.32,17.31 v3(110.55,17.08)
  TOP w0.508: CH100.2 110.25,19.47 110.25,18.1 RH212.1
N125233563: length 2.6
  BOTTOM w0.114: v3(63.45,87.86) 63.87,88.28 64.37,88.28 PC1108.2
  BOTTOM w0.254: PC1108.2 PR1119.1
N125374216: length 49.1
  TOP w0.114: v2(143.93,98.83) 143.93,99.94 145.82,101.84 145.82,105.74 147.13,107.04 148.61,107.04 149.16,107.6 150.2,107.6 151.42,106.38 QZ8.5 QZ8.6 152.84,107.03 CV920.1 153.74,106.12 153.74,105.22 152.8,104.28 RZ103.2 ; QZ11.2 149.77,78.36 148.12,78.36 147.91,78.57 146.71,78.57 v2(146.11,79.17)
  IN1 w0.094: v2(146.11,79.17) 146.33,79.39 146.33,80.69 147.13,81.5 147.13,82.6 146.75,82.98 145.78,82.98 143.93,84.83 v2(143.93,98.83)
  BOTTOM w0.114: v2(146.11,79.17) v3(145.3,79.17)
N125749803: length 2.5
  TOP w0.114: QZ6.6 204.63,72.78 RZ8.2 v3(205.6,73.9)
N128659288: length 4.1
  BOTTOM w0.254: PR210.2 47.05,39.64 47.05,38.46 v2(47.43,38.08) PQ203.6
N128659296: length 4.3
  BOTTOM w0.114: PR212.2 49.59,37.87 50.42,37.05 v3(50.42,36.88)
  BOTTOM w0.254: PC204.1 PR212.2 48.63,38.73 PQ203.5
N128706078: length 4.5
  BOTTOM w0.114: v3(44.72,48.26) 44.03,47.57 PR215.1 44.56,46.7 44.56,46.07 45.13,45.5 PQ201.1
N128706262: length 4.6
  TOP w0.114: PR206.2 PC202.1 45.39,44.87 44.96,45.3 v4(44.96,45.65) 44.96,46.32 v2(45.09,46.45)
  BOTTOM w0.114: v2(45.09,46.45) 45.45,46.81 PQ201.2
N128723044: length 12.4
  TOP w0.114: v2(48.85,39.87) 48.32,40.4 48.32,43.35 48.8,43.83 v4(48.8,45.84) 50.3,47.34 v2(50.3,47.79)
  BOTTOM w0.114: PC203.2 v2(48.85,39.87) ; v2(50.3,47.79) PR211.1 49.64,47.18 49.29,46.84 PQ202.2
N128723211: length 2.2
  BOTTOM w0.114: PQ202.1 48.64,48.84 PR217.1 v3(49.51,48.89)
N128731318: length 20.9
  BOTTOM w0.508: QZ9.1 212.15,47.79 213.29,48.94 216.49,48.94 v4(217.18,49.62) 218.7,51.15 220.96,51.15 221.9,50.21 227.67,50.21 228.8,49.08 RZ37.1
N128782144: length 4.8
  TOP w0.114: v3(65.25,61.7) 65.44,61.51 PR703.2
  TOP w0.254: PR706.1 67.7,63.24 67.19,62.73 67.19,61.89 66.81,61.51 PR703.2 66.43,61.01 66.63,60.81 PR705.1
N128782226: length 3.2
  TOP w0.254: PR708.2 PR711.1 67.75,60.61 v3(67.62,60.47) 66.82,59.68 PR710.1
N128802462: length 2.1
  BOTTOM w0.114: v3(109.48,7.13) 109.28,7.33 PC504.1
  BOTTOM w0.635: PR502.2 108.62,8.02 PC504.1
N128802488: length 6.3
  BOTTOM w0.254: PU500.16 100.7,9.44 99.65,8.4 PC508.2 PR503.2 99.65,7.31 100.5,6.46 v3(101.23,6.46) 101.48,6.71 PR505.1
N128802974: length 2.6
  BOTTOM w0.508: PC505.1 104.48,8.47 102.91,10.05
N128803011: length 1.5
  BOTTOM w0.114: v4(93.15,11.42) 93.86,10.71 PC502.1
N128803052: length 2.1
  BOTTOM w0.254: PC507.1 102.37,8.42 101.94,8.86 101.94,9.29 101.6,9.63 PU500.14
N128803144: length 1.6
  BOTTOM w0.254: PC514.1 99.7,13.99 100.25,13.44 PU500.3
N128828208: length 1.2
  TOP w0.114: v3(115.38,122.8) 115.44,122.74 PC1417.1
N128828374: length 1.2
  TOP w0.114: PC1425.1 v3(105.51,122.74)
N128835022: length 2
  TOP w0.127: v3(80.05,117.59) 79.6,117.15 PR1518.2
N128835130: length 1.7
  TOP w0.114: PR1524.2 135.96,119.19 v3(136.32,118.84)
N128845288: length 4.3
  BOTTOM w0.114: PR216.1 44.03,45.89 v3(44.93,44.99) 45.71,44.2 PQ200.6
N128845311: length 4.5
  BOTTOM w0.114: v3(45.23,43.5) PR213.1
  BOTTOM w0.254: PR213.1 46.29,43.55 PQ200.5 47.69,43.55 48.17,43.07 PR203.2
N128845336: length 3.3
  BOTTOM w0.114: PR204.2 52.05,43.45 v3(52.3,43.69)
  BOTTOM w0.254: PR204.2 51.13,43.63 PC200.2 50.23,43.55 PQ200.2
N128845350: length 2.1
  BOTTOM w0.254: PR202.2 50.38,42.64 PC200.1 50.11,42.9 PQ200.3
N128884096:
  vias: v2(22.79,34.61) v2(22.79,34.03) v3(23.3,34.47)
N128884102: length 4.2
  TOP w0.508: PR301.1 PR300.2 20.63,31.18 v3(19.63,31.18) 19.38,31.18 18.87,31.69 PQ300.2
N128884110: length 1.6
  BOTTOM w0.127: 23.63,37.65 23.63,38.7 v3(24.04,39.11)
  vias: v2(18.53,35.26) v2(19.11,35.26) v2(19.62,37.32) v2(19.69,35.26) v2(20.17,33.3) v2(20.28,37.32) v2(20.28,35.26) v2(20.86,37.32) v2(20.86,35.26) v2(21.5,37.32) v2(21.45,35.26) v2(22.08,37.34)
N128884118:
  vias: v3(23.72,31.16)
N128884914: length 5.9
  BOTTOM w0.203: PU300.15 32.25,38.54 32.54,38.83 32.54,39.26 32.84,39.55 33.77,39.55 34.24,40.02 35.48,40.02 v3(35.72,40.26) 35.95,40.49 PR321.1
N128884971: length 4.1
  TOP w0.114: PR306.1 40.51,17.21 v3(40.66,17.06)
  TOP w0.635: PQ303.4 39.38,19.29 39.82,18.85 PC302.1 39.82,17.4 PR306.1
N128884983: length 1.5
  BOTTOM w0.203: PR322.1 32.95,35.93 32.34,36.54 PU300.20
N128884987: length 1.3
  BOTTOM w0.203: PR324.1 32.52,36.82 32.4,36.94 PU300.19
N128884993: length 3
  BOTTOM w0.203: PR312.2 PR313.1 32.95,34.99 32.65,35.3 32.65,35.73 32.24,36.14 PU300.21
N128885024: length 1.5
  TOP w0.508: PR310.2 26.81,31.51 v2(26.81,32.12)
  vias: v3(27.65,34.05)
N128885051: length 3.1
  BOTTOM w0.114: PU300.10 29.47,39.85 30.38,40.76 30.95,40.76 PR326.1
N128885101: length 2.6
  BOTTOM w0.114: PR311.1 30.5,30.9 v3(30.5,30.53)
  BOTTOM w0.508: PC304.2 29.21,31.55 PR311.1
N128885126: length 5.2
  BOTTOM w0.114: PR319.2 28.27,41.32 v3(28.71,41.76)
  BOTTOM w0.203: PU300.7 27.6,38.54 27.47,38.67 27.47,38.98
  BOTTOM w0.254: 27.47,38.98 27.47,40.48 26.93,41.01 PC321.1 PR319.2
N128885130: length 2.3
  BOTTOM w0.102: PC322.2 v3(28.77,40.48) 28.67,40.39 PU300.8
N128889202: length 2.6
  BOTTOM w0.114: v3(142.72,118.38) 143.11,117.99 PR901.2
  BOTTOM w0.635: PR901.2 142.78,116.88 PC904.1
N128889227: length 5.7
  TOP w0.254: v2(138.08,108.88) v3(138.9,109.7) 140.12,110.91 PR912.1 PR911.2
  BOTTOM w0.254: PR906.2 138.29,109.08 v2(138.08,108.88)
N128889244: length 2.5
  TOP w0.114: v3(143.95,133.48) PC909.1
  TOP w0.508: PC909.1 145.27,132.55 PR904.2
N129020146: length 3
  TOP w0.114: RA33.1 281.01,16.07 v3(281.42,16.07)
  TOP w0.254: RA33.1 RA30.2 279.61,17.24 CA29.1
N129088154: length 2.7
  BOTTOM w0.114: UA2.3 262.78,21.86 262.68,21.96 v2(262.68,22.35) 262.77,22.44 RA67.1 RA65.2
N129088268: length 1.7
  BOTTOM w0.114: CD94.1 263.78,22.9 UA2.5
N129088271: length 1.8
  BOTTOM w0.114: UA2.6 264.28,22.27 v2(264.4,22.38) 264.55,22.53 CD95.1
N129088477: length 2.9
  BOTTOM w0.114: RA63.2 RA66.1 265.44,22.65 v2(265.71,22.38) 265.71,22.16 265.28,21.74 UA2.8
N129088540: length 5.3
  BOTTOM w0.114: UA2.9 266.38,20.54 266.48,20.64 266.48,22.38 v3(267.31,23.21) 267.59,23.49 RA61.2 RA64.1
N129088559: length 4.9
  BOTTOM w0.114: UA2.10 266.56,20.04 266.74,20.21 266.74,21.63 267.01,21.91 v3(267.33,21.91) 267.83,21.91 RA62.1 RA60.2
N129089294: length 3.5
  BOTTOM w0.114: UA2.32 260.57,20.54 260.45,20.65 260.45,21.49 v2(259.56,22.38) 259.22,22.72 CD92.1
N129089311: length 3.5
  BOTTOM w0.114: UA2.31 260.52,20.04 260.22,20.34 260.22,21.21 259.89,21.54 v3(259.76,21.54) 259.52,21.78 CD91.1
N129089914: length 2.2
  BOTTOM w0.254: UA2.26 259.54,17.54 CA48.1
N129089927:
  vias: v3(260.21,14.77)
N129090458: length 1.7
  BOTTOM w0.254: CA49.2 262.65,15.32 v2(262.78,15.46) UA2.22
N129090491: length 1.7
  BOTTOM w0.254: CA50.1 264.42,15.32 v2(264.28,15.46) UA2.19
N129090627:
  vias: v4(267.1,14.65)
N129090703: length 4.2
  BOTTOM w0.114: v3(270.15,17.12) 268.75,17.12 268.32,17.54 CA51.2
  BOTTOM w0.254: CA51.2 268.08,17.54 UA2.15
N129091037: length 2.5
  BOTTOM w0.114: CA47.2 v3(270.16,15.2)
  BOTTOM w0.254: CA47.2 269.12,15.26 RA58.1
N129091040: length 2.3
  BOTTOM w0.114: CA46.1 v3(256.87,14.67)
  BOTTOM w0.254: RA57.2 257.95,14.7 CA46.1
N129091624: length 1.9
  TOP w0.203: HDA1.24 283.51,21.39 283.99,20.92
  TOP w0.508: 283.99,20.92 283.99,20.63 283.73,20.37 CA21.1
N129161519: length 3.3
  TOP w0.114: v2(61.69,28.81) 61.59,28.71 61.59,28.06 v3(61.66,27.99) 61.72,27.93 DI1.2
  BOTTOM w0.114: JEDP1.12 61.99,29.51 61.69,29.21 v2(61.69,28.81)
N129169183: length 6.6
  TOP w0.508: UA1.3 286.99,37.56 CA10.2 286.01,38.53 286.01,39.23 v3(286.16,39.37) 286.48,39.69 287.72,39.69 288.1,40.07 RA2.2
N129172883: length 3.5
  BOTTOM w0.114: RE118.2 255.24,33.99 v3(254.98,33.99) 254.49,33.99 254.28,33.78 253.37,33.78 253.22,33.93 JDEG1.9
N129203755: length 2
  BOTTOM w0.114: v3(271.73,24.3) 272.42,24.3 CA33.1 272.73,23.99 RA35.1
N129347215: length 3.8
  TOP w0.114: v3(189.99,21.86) 190.31,22.18 RH499.1 190.3,22.91 RH180.2 RH103.2 RH105.1
N129677522: length 2.2
  BOTTOM w0.114: PQ403.3 56.03,31.14 PR419.2 v3(56.99,31.16)
N129680759: length 27.6
  BOTTOM w0.114: RE129.1 183.55,8.5 v3(183.55,7.75) 183.55,7.6 183,7.05 180.62,7.05 177.44,10.23 176.16,10.23 175.42,10.96 173.07,10.96 172.69,11.34 171.59,11.34 169.88,13.05 168.16,13.05 167.95,13.26 166.44,13.26 165.67,14.03 165.67,14.57 165.34,14.9 165.34,16.47 165.11,16.7 165.11,17.19 RH510.2
N129681032: length 22.9
  TOP w0.114: v2(163.1,17.21) 163.1,16.78 162.93,16.6 162,16.6 161.88,16.49 161.88,15.51 161.77,15.4 160.95,15.4 160.84,15.28 160.84,13.86 160.95,13.74 161.25,13.74 161.36,13.86 161.36,14.85 161.47,14.96 161.77,14.96 161.88,14.85 161.88,13.83 162,13.72 162.29,13.72 162.4,13.83 162.4,15.28 162.52,15.4 163.54,15.4 165.35,13.59 167.64,13.59 v4(169.65,11.58) v2(171.08,10.15)
  BOTTOM w0.114: RE71.1 171.13,10.2 v2(171.08,10.15) ; v2(163.1,17.21) 163.2,17.31 RH104.2
N129707905: length 1.6
  BOTTOM w0.254: 121.69,128.82 122.08,128.43 PU1400.26
  BOTTOM w0.305: 121.69,128.82 PR1403.2
N129708017: length 1.8
  BOTTOM w0.305: PU1400.7 126.16,129.9
  BOTTOM w0.508: 126.16,129.9 126.16,130.53 PR1405.2
N129708019: length 2.4
  BOTTOM w0.114: PR1405.1 v3(126.5,133.37)
  BOTTOM w0.508: PC1402.1 PR1405.1
N129708021: length 1.9
  BOTTOM w0.305: 125.41,129.96 125.16,129.72 PU1400.5
  BOTTOM w0.508: PC1402.2 125.41,130.69 125.41,129.96
N129708031: length 2.7
  BOTTOM w0.254: PU1400.1 123.16,129.44 122.31,130.29 121.85,130.29 121.45,130.7 121.45,130.93
N129708035: length 2.3
  BOTTOM w0.254: PU1400.2 123.66,129.57 122.34,130.9 122.34,130.93
N129708047: length 4.8
  TOP w0.114: v3(123.68,128.54) PR1400.2
  TOP w0.508: PR1400.2 122.03,128.01 v2(121.55,128.01)
  BOTTOM w0.305: PU1400.24 121.83,127.43 121.82,127.43 121.4,127.43 121.4,127.43 120.99,127.43 PC1400.1
  BOTTOM w0.508: v2(121.55,128.01) 121.22,128.01 120.98,127.76 PC1400.1
N129708951: length 2.7
  BOTTOM w0.305: PU1400.3 124.16,129.84 124.04,129.96
  BOTTOM w0.508: 123.23,130.93 124.11,130.93 124.11,130.44 124.04,130.37 124.04,129.96
N129713259: length 1.6
  BOTTOM w0.254: PU1401.26 111.6,128.43 111.21,128.82
  BOTTOM w0.305: 111.21,128.82 PR1418.2
N129713349: length 1.6
  BOTTOM w0.305: PU1401.7 116,129.9
  BOTTOM w0.508: PR1419.2 116,130.7 116,129.9
N129713351: length 2.6
  BOTTOM w0.114: v3(114.27,133.2) 114.27,132.6 114.69,132.18 PC1412.1
  BOTTOM w0.508: PC1412.1 PR1419.1
N129713353: length 1.9
  BOTTOM w0.305: 115.25,129.96 115,129.72 PU1401.5
  BOTTOM w0.508: 115.25,129.96 115.25,130.36 PC1412.2
N129713363: length 4.1
  BOTTOM w0.114: v3(110.04,131.27) 110.21,131.1 PR1415.2
  BOTTOM w0.254: PU1401.1 113,129.44 112.4,130.04 111.9,130.04 111.01,130.93 PR1415.2
N129713367: length 2.8
  BOTTOM w0.254: PR1417.2 111.9,130.8 112.28,130.42 112.66,130.42 113.5,129.57 PU1401.2
N129713379: length 3.5
  TOP w0.114: v2(110.82,128.13) v3(110.82,127.43)
  TOP w0.508: v2(110.82,128.13) 110.88,128.2 PR1414.2
  BOTTOM w0.305: PU1401.24 111.67,127.43 111.66,127.43 110.83,127.43 PC1410.1
  BOTTOM w0.508: v2(110.82,128.13) PC1410.1
N129714262: length 2.9
  BOTTOM w0.305: PU1401.3 114,129.84 113.8,130.04
  BOTTOM w0.508: 113.8,130.04 113.67,130.17 PC1411.2 PR1416.2
N129715037: length 2.6
  BOTTOM w0.114: v3(99.98,128.88) 100.16,128.69 PR1432.2
  BOTTOM w0.254: 101.71,128.3 PU1402.26
  BOTTOM w0.305: PR1432.2 101.32,128.69 101.71,128.3
N129715137: length 1.8
  BOTTOM w0.305: PU1402.7 106.1,129.78
  BOTTOM w0.508: 106.1,129.78 106.1,130.4 PR1433.2
N129715139: length 2.4
  BOTTOM w0.114: PC1419.1 v3(105.17,133.28)
  BOTTOM w0.508: PC1419.1 PR1433.1
N129715141: length 1.9
  BOTTOM w0.305: 105.34,129.83 105.1,129.59 PU1402.5
  BOTTOM w0.508: 105.34,129.83 105.34,130.56 PC1419.2
N129715151: length 3.9
  BOTTOM w0.114: PR1429.2 v3(100.16,130.98)
  BOTTOM w0.254: PR1429.2 102.17,130.04 102.37,130.04 103.1,129.31 PU1402.1
N129715155: length 4.9
  BOTTOM w0.114: v3(102.64,133.04) 102.64,131.23 102.38,130.98 PR1431.2
  BOTTOM w0.254: PU1402.2 103.6,129.45 102.17,130.88 PR1431.2
N129715167: length 3.4
  TOP w0.114: v2(100.91,127.93) v3(100.91,127.32)
  TOP w0.508: v2(100.91,127.93) 100.91,128.68 PR1428.2
  BOTTOM w0.305: PU1402.24 101.76,127.3 101.76,127.31 101.34,127.31 101.33,127.3 100.93,127.3 v3(100.91,127.32)
  BOTTOM w0.508: v2(100.91,127.93) v3(100.91,127.32)
N129715635: length 2.9
  BOTTOM w0.305: PU1402.3 104.1,129.71 103.97,129.83
  BOTTOM w0.508: 103.97,129.83 103.97,130.24 104.02,130.29 PC1420.2 PR1430.2
N129716454: length 3.6
  BOTTOM w0.114: PR1504.2 90.74,128.69 90.26,129.18 90.26,130.5 v3(90.15,130.6)
  BOTTOM w0.254: PU1500.26 91.41,128.3
  BOTTOM w0.305: PR1504.2 91.14,128.3 91.41,128.3
N129716544: length 1.8
  BOTTOM w0.305: PU1500.7 95.81,129.78
  BOTTOM w0.508: 95.81,129.78 95.81,130.4 PR1505.2
N129716546: length 2.7
  BOTTOM w0.114: PR1505.1 v3(97.61,132.13)
  BOTTOM w0.508: PC1502.1 PR1505.1
N129716548: length 1.9
  BOTTOM w0.305: PU1500.5 94.81,129.59 95.06,129.83
  BOTTOM w0.508: PC1502.2 95.06,130.56 95.06,129.83
N129716558: length 4.2
  BOTTOM w0.114: v3(90.1,131.94) 90.1,131.73 90.85,130.98 PR1501.2
  BOTTOM w0.254: PR1501.2 91.07,130.88 91.63,130.32 91.81,130.32 92.81,129.31 PU1500.1
N129716562: length 2.5
  BOTTOM w0.254: PR1503.2 91.96,130.8 93.31,129.45 PU1500.2
N129716574: length 3.7
  TOP w0.114: v2(90.51,128.03) v3(90.51,127.29)
  TOP w0.508: v2(90.51,128.03) 90.69,128.21 PR1500.2
  BOTTOM w0.305: PC1500.1 90.64,127.3 91.05,127.3 91.05,127.31 91.47,127.31 91.47,127.3 PU1500.24
  BOTTOM w0.508: PC1500.1 90.62,127.92 v2(90.51,128.03)
N129717674: length 2.9
  BOTTOM w0.305: 93.69,129.83 93.81,129.71 PU1500.3
  BOTTOM w0.508: 93.69,129.83 93.69,130.24 93.74,130.29 PC1501.2 PR1502.2
N129718561: length 2.8
  BOTTOM w0.114: v3(69.58,107.89) PR1516.2
  BOTTOM w0.254: PR1516.2 70.62,108.65 70.86,108.89 PU1501.26
N129718659: length 1.7
  BOTTOM w0.305: PU1501.7 69.31,113.32
  BOTTOM w0.508: 69.31,113.32 68.97,113.66 PR1517.2
N129718661: length 2.4
  BOTTOM w0.114: v3(66.02,113.66) PR1517.1
  BOTTOM w0.508: PR1517.1 PC1510.1
N129718663: length 1.8
  BOTTOM w0.305: PU1501.5 69.52,112.32 69.28,112.56
  BOTTOM w0.508: 69.28,112.56 68.7,112.56 PC1510.2
N129718673: length 3.7
  BOTTOM w0.114: v3(68.29,107.64) PR1513.2
  BOTTOM w0.254: PU1501.1 69.65,110.32 69,109.67 69,109.28 68.29,108.58 PR1513.2
N129718677: length 2.4
  BOTTOM w0.254: PR1515.2 68.29,109.46 69.64,110.82 PU1501.2
N129718689: length 3.9
  BOTTOM w0.114: PC1508.1 73.01,107.89 v3(73.42,107.48)
  BOTTOM w0.254: 71.76,108.7 71.76,108.89 71.86,108.99 PU1501.24
  BOTTOM w0.508: PC1508.1 PR1512.2 71.51,108.45 71.76,108.7
N129719256: length 2.7
  BOTTOM w0.305: PU1501.3 69.05,111.32 68.97,111.24
  BOTTOM w0.508: PR1514.2 PC1509.2 68.97,111.24
N129830333: length 2.7
  BOTTOM w0.203: PU400.6 53.07,19.69 53.28,19.48 53.96,19.48 v2(54.09,19.61) 54.26,19.61 54.49,19.38 PR407.2
N129937820: length 3.6
  TOP w0.114: v2(133.61,116.32) v3(133.61,115.69)
  TOP w0.254: PR1529.1 133.23,116.07 133.49,116.32 v2(133.61,116.32)
  BOTTOM w0.254: v2(133.61,116.32) 133.87,116.32 134.12,116.07 PL1505.3
N129937845: length 3.7
  TOP w0.114: v2(133.61,116.96) v3(134.34,116.96)
  TOP w0.254: PR1528.1 133.36,117.21 v2(133.61,116.96)
  BOTTOM w0.254: PL1505.2 134.12,117.21 133.87,116.96 v2(133.61,116.96)
N130381075: length 2.7
  BOTTOM w0.114: v3(209.59,116.6) 209.97,116.98 PR1000.1
  BOTTOM w0.203: 209.22,117.74 209.01,117.95 PU1000.9
  BOTTOM w0.254: 209.22,117.74 209.74,117.74 PR1000.1
N130402506: length 7
  TOP w0.114: v3(246.01,33.14) 244.89,32.02 Q13.1
  TOP w0.254: Q13.1 244.36,33.65 244.48,33.77 RE101.2 244.51,34.43 JFAN2.1
N130402546: length 7.2
  TOP w0.114: JFAN1.3 54.01,32.08 DE7.1 53.98,31.36 54.49,30.86 54.49,30.23 54.85,29.87 RE82.2 55.64,28.81 v3(55.64,28.13)
N130402633: length 4.7
  TOP w0.114: DE9.1 v3(244.55,39.19)
  TOP w0.254: JFAN2.3 244.5,36.93 RE84.2 244.48,38.02 DE9.1
N130584913: length 1.5
  TOP w0.114: v2(170.24,27.19) 169.81,27.63 T92.1
  BOTTOM w0.102: UH2.AR17 170.52,26.91 v2(170.24,27.19)
N130791078: length 15.5
  TOP w0.114: RV571.2 157.18,74.1 156.33,74.1 156.15,74.28 154.83,74.28 154.63,74.48 152.8,74.48 152.35,74.02 152.35,73.68 152.09,73.42 151.12,73.42 v2(150.5,72.8)
  BOTTOM w0.114: v2(150.5,72.8) 150.28,73.03 149.67,73.03 149.45,72.81 ; 149.45,72.81 149.66,72.6 149.66,71.99 149.39,71.73 147.95,71.73 147.76,71.92 147.76,72.65 147.6,72.81 QV1.5 146.72,72.81 RV572.2 ; 149.45,72.81 QV1.2
N130949507: length 3.6
  BOTTOM w0.076: T1.1 169.66,20.52 170.49,21.36 170.49,22.34 170.6,22.45 170.6,22.85 UH2.BC18
N130955932: length 0.9
  TOP w0.356: RA72.1 CA21.2
N130956130: length 1.9
  BOTTOM w0.114: v3(258.84,24.62) CD92.2 RA73.1
N130959682: length 3.8
  BOTTOM w0.305: JDEG1.1 v4(248.03,34.41) 245.58,34.41 RE60.1
N130960109: length 1.1
  BOTTOM w0.114: RE111.2 252.1,30.33 T3.1
N130982801: length 4.5
  BOTTOM w0.203: UL1.26 283.49,43.69 283.09,43.3
  BOTTOM w0.254: RL43.2 280.93,41.13 v3(281.41,41.6) 282.97,43.16 282.97,43.17 283.09,43.3
N131307421: length 5.3
  TOP w0.114: RV570.1 RV535.2 65.97,20.93 CV578.2 65.42,21 QV11.3 v3(64.38,19.29)
N131307439: length 2.3
  TOP w0.114: QV2.1 66.81,22.8 RV570.2 67.13,22.48 v3(67.83,22.48)
N131311358: length 3.3
  BOTTOM w0.127: RC11.1 155.15,16.97 v3(155.52,17.34)
  BOTTOM w0.508: RC11.1 154.35,16.97 153.85,17.48 153.85,18.14 DC2.2
N131431549: length 2.8
  TOP w0.114: QE20.2 QE20.3 251.76,29.01 v3(250.66,29.01) 250.58,28.93 RH504.2
N131431604: length 4
  TOP w0.114: v3(247.15,29.92) QE23.6 QE23.5 247.8,28.51 248.23,28.08 RH505.2
N131431963: length 2.3
  BOTTOM w0.114: RW3.1 286.9,60.24 LED3.2 285.81,61.22 v3(285.81,61.21)
N131431980: length 2.3
  TOP w0.114: RW4.1 LED4.2 202.94,31.24 v3(203.29,30.9)
N131432059: length 4.5
  BOTTOM w0.114: QE24.5 286.27,57.39 286.01,57.65 285.76,57.65 285.62,57.51 QE24.6 285.62,56.62 285.38,56.38 v3(284.52,56.38) 284.11,56.78 RH506.2
N131436195: length 5.7
  TOP w0.508: Q12.1 57.97,32.07 v3(57.36,32.07) 57.07,32.07 56.99,31.99 RE100.2 56.39,33.09 56.51,33.21 JFAN1.1
N131680753: length 3.3
  TOP w0.127: v4(159.93,58.26) PC1630.1
  TOP w0.508: PR1611.2 162.28,57.7 161.72,58.26 PC1630.1
N131681151: length 1.3
  TOP w0.127: v3(142.3,59.11) 142.66,58.75 PC1678.1
N131712060: length 2.3
  BOTTOM w0.203: PU1600.9 177.65,54.53 178.09,54.09 178.09,53.84 178.6,53.33 PR1615.2
N131712748: length 1.8
  TOP w0.114: PC1644.1 v3(171.71,53.27)
  TOP w0.508: v2(172.02,54.98) 171.71,54.68 PC1644.1
N131741378: length 5.4
  BOTTOM w0.127: PR1620.2 v3(178.68,49.46)
  BOTTOM w0.203: 177.02,52.82 176.96,52.89 176.64,52.89 176.44,53.09 PU1600.11
  BOTTOM w0.406: 177.02,52.82 177.66,52.19 PR1623.2 177.8,51.76 178.2,51.35 PC1676.2 178.67,51.34 178.67,50.47 PR1620.2
N131741387: length 7.1
  TOP w0.406: PR1617.2 178.85,52.01 v3(179.64,51.22) v2(180.25,51.22)
  BOTTOM w0.203: 177.68,53.33 177.68,53.97 177.52,54.13 PU1600.10
  BOTTOM w0.406: 177.68,53.33 177.68,53.1 178.33,52.45 PR1618.2 178.86,52.18 179.6,51.44 PC1676.1 179.73,51.22 v2(180.25,51.22)
N131741412: length 5.5
  TOP w0.114: v4(177.53,58.49) 177.75,58.7 v2(178.11,58.7) 178.64,58.18 PR1601.1
  BOTTOM w0.114: v2(178.11,58.7) 178.06,58.7 177.85,58.49 PR1600.2
  BOTTOM w0.203: PR1600.2 PR1602.1 176.51,57.75 176.04,57.27 PU1600.4
N131741423: length 4
  TOP w0.114: v2(180.45,53.05) 180.74,53.05 181,53.3 v4(181,53.72)
  TOP w0.203: v2(180.45,53.05) 180.05,53.05 PR1614.2 179.71,53.33 PC1645.1
  BOTTOM w0.203: v2(180.45,53.05) 180.17,53.33 PR1614.2
N131748830: length 1.2
  TOP w0.127: PC1711.1 v3(192.81,72.18)
N131748958: length 1.2
  TOP w0.114: PR1713.1 v3(207.77,55.98)
N131748960: length 3.1
  TOP w0.114: PC1713.1 v3(209.28,46.33)
  TOP w0.203: PR1715.1 PR1714.2 209.08,47.36 PC1713.1
N131749104: length 7
  TOP w0.114: PC1723.1 207.78,50.08 v3(207.55,50.08)
  TOP w0.203: PU1700.10 205.99,50.95 206.21,50.74 208.39,50.74 PC1723.1
  TOP w0.254: PR1716.2 PR1717.2 209.28,50.05 208.62,50.71 PC1723.1
N131749108: length 5.1
  TOP w0.114: PR1720.2 210.47,51.25 v3(210.47,51.98)
  TOP w0.203: PC1723.2 208.39,51.6 207.83,52.16 PU1700.11
  TOP w0.254: PR1720.2 PR1721.2 208.65,51.63 PC1723.2
N131749147: length 4.9
  TOP w0.114: v3(210.39,54.35) 208.9,54.35 PR1719.1
  TOP w0.203: PR1719.1 208.44,53.84 PC1731.1 208.03,52.56 PU1700.12
N131807894: length 21.9
  BOTTOM w0.114: RV591.1 154.9,73.85 v3(157.82,73.85) 159.24,73.85 159.73,74.34 163.21,74.34 163.81,74.95 163.81,75.53 163.36,75.98 163.36,82.12 162.56,82.92 161.49,82.92 161.29,82.72 UV1.AF8
N131836548: length 12.3
  TOP w0.114: v3(171.42,65.53) 171.86,65.97 UV22.4 172.47,67.43 QV89.2 172.08,68.21 172.43,68.56 173.7,68.56 175.52,66.73 175.52,65.5 175.99,65.03 175.99,64.26 RV610.1 RV582.1
N131855116: length 3.2
  TOP w0.114: v3(146.82,110.45) 146.45,110.45 146.24,110.67 PQ901.2
  TOP w0.254: PQ901.2 145.68,110.14 145.86,109.96 PR909.2 PR908.2
N131866512: length 4.2
  TOP w0.114: 180.48,56.14 v4(181.14,56.14)
  TOP w0.254: PR1606.2 PR1608.1 ; PR1608.1 179.78,56.41 180.19,56.41 180.48,56.12 180.48,56.14 v2(180.47,56.14) ; PR1608.1 PC1625.1
  BOTTOM w0.254: v2(180.47,56.14) 180.48,56.14 180.48,56.12 180.19,56.41 PR1607.2
N131868325: length 2.4
  BOTTOM w0.114: v3(182.1,57.39) PR1612.1
  BOTTOM w0.203: PR1609.2 181.09,57.37 PR1612.1
N131873134: length 3.4
  TOP w0.114: v3(177.26,52.8) 176.9,52.8 v2(176.51,52.42)
  TOP w0.254: v2(176.51,52.42) 176.57,52.36 PR1621.1
  BOTTOM w0.203: PU1600.12 176.04,52.92 176.51,52.44 v2(176.51,52.42)
  BOTTOM w0.254: PC1677.1 176.55,52.38 v2(176.51,52.42)
N131901413: length 4.5
  TOP w0.203: v2(203.95,47.34) 203.67,47.34 203.46,47.54 PR1707.2 203.51,48 204.3,48 PC1709.1
  BOTTOM w0.114: v2(203.95,47.34) v4(203.95,46.62)
  BOTTOM w0.203: v2(203.95,47.34) 203.77,47.34 203.46,47.64 PR1708.1 PR1706.2
N131901439: length 1.8
  TOP w0.114: v3(202.57,47.01) PR1709.2
  TOP w0.203: PR1709.2 PR1712.1
N131902783: length 3.3
  TOP w0.203: PR1715.2 207.53,48.99 v3(206.26,50.25) 205.59,50.92 PU1700.9
N131912612: length 2.7
  BOTTOM w0.114: v4(170.79,59.34) PC1626.1
  BOTTOM w0.508: PC1626.1 173.31,59.34 PR1610.2
N131912705: length 2.5
  BOTTOM w0.114: v4(172.24,49.23) PC1646.2
  BOTTOM w0.635: PC1646.2 PR1616.2
N131913656: length 1.2
  TOP w0.114: PR1711.2 v3(202.32,58.56)
N131943637: length 3
  TOP w0.114: v3(143.91,109.54) 144.08,109.71 PQ901.1
  TOP w0.254: PR910.2 143.98,111.42 PQ901.1
N131973567: length 2.2
  TOP w0.114: v3(149.31,80.98) 149.49,81.16 RZ73.2 150.62,80.71 QZ11.1
N131973815: length 4.1
  TOP w0.114: RZ100.2 154.33,81.12 156.84,81.12 157.14,80.82 157.14,80.32 QZ10.3
N132121209: length 3
  BOTTOM w0.114: CV903.1 185.28,114.82 RV594.2 RV595.2 v3(183.27,115.82)
N132122697: length 3.4
  BOTTOM w0.114: RV596.2 RV597.2 156.98,115.94 CV904.1 v3(156.73,117.24)
N132123770: length 3
  BOTTOM w0.114: RV598.2 RV599.2 192.19,76.67 CV905.1 v4(190.99,76.7)
N132124417: length 3.2
  BOTTOM w0.114: RV601.2 RV600.2 192.57,105.27 CV906.1 193.68,104.5 v3(193.84,104.35)
N132421462: length 16.8
  TOP w0.102: 172.6,106.1 v2(172.49,106.21)
  TOP w0.114: 172.6,106.1 173.36,105.34 173.36,102.85 173.63,102.58 174.5,102.58 174.88,102.96 174.88,104.74 175.11,104.97 v3(176.29,104.97) 176.92,105.6 RV602.1
  BOTTOM w0.185: UV1.R32 170.09,102.31 170.09,105.31 170.99,106.21 v2(172.49,106.21)
N132421465: length 1.4
  TOP w0.406: v2(164.22,102.31) 163.79,102.73 RV603.1
  BOTTOM w0.114: UV1.AC32 164.19,102.31 v2(164.22,102.31)
N132541936: length 6.4
  BOTTOM w0.114: v3(260.14,24.78) 260.06,24.87 RA80.2 260.3,26.01 CA66.2 RA79.1 262.06,27.42 262.06,28.41 261.89,28.58 QA2.3
N132541970: length 3.5
  BOTTOM w0.114: v4(264.55,25.97) QA1.1 264.23,27.04 RA79.2
N132584446: length 11.1
  BOTTOM w0.114: TV107.1 153.21,80.01 153.68,79.54 153.68,78.49 154.09,78.08 155.62,78.08 155.92,78.37 155.92,79.59 156.14,79.82 157.24,79.82 157.46,80.05 157.46,80.38 157.67,80.58 158.81,80.58 159.17,80.94 159.17,81.48 UV1.AH8
