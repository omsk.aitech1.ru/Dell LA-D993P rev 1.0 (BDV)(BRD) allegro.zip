# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDS_SENSE_VGA: length 61.8
  TOP w0.254: v2(211.13,49.2) 211.1,49.16 PR1717.1
  IN4 w0.254: v2(211.13,49.2) 210.33,49.2 210.04,48.91 210.04,48.58 210.65,47.97 210.65,47.75 210.49,47.59 209.94,47.59 209.46,48.07 209.13,48.07 208.65,47.59 205.37,47.59 202.93,50.03 199.65,50.03 191.68,58 191.55,58 191.27,58.29 191.27,58.41 189.62,60.06 182.7,60.06 176.36,66.4 176.36,67.72 175.55,68.54 175.55,72.65 175.42,72.78 175.42,72.97 173.26,75.13 173.26,75.57 172.69,76.14 171.6,76.14 171.06,76.68 169.33,76.68 v2(169.16,76.51)
  BOTTOM w0.254: UV1.U2 168.79,76.88 v2(169.16,76.51)
V1N: length 63.6
  IN1 w0.254: v2(76.46,102.1) 76.92,101.64 82.36,101.64 88.1,107.38 109.13,107.38 109.34,107.58 118.13,107.58 118.96,108.42 118.96,111.29 118.5,111.75 118.5,113.91 119.26,114.67 119.26,116.25 120.92,117.91 122.25,117.91 v2(122.56,117.59)
  BOTTOM w0.254: PR1413.1 PR1412.1 PR1411.1 v2(76.46,102.1) ; v2(122.56,117.59) 122.76,117.78 123.52,117.78 123.77,117.53 PR1408.2
V2N: length 54.9
  IN1 w0.254: v2(73.29,102.73) 82.13,102.73 87.7,108.3 108.19,108.3 110.88,110.99 110.88,116.96 111.77,117.85 113.42,117.85 v2(113.55,117.72)
  BOTTOM w0.254: v2(73.29,102.73) 73.37,102.17 PR1425.1 PR1426.1 PR1427.1 ; PR1422.2 114.88,117.59 114.63,117.85 113.67,117.85 v2(113.55,117.72)
V3N: length 47.7
  IN1 w0.254: v2(104.02,117.59) 103.9,117.72 103.04,117.72 102.79,117.47 102.79,110.64 101.84,109.69 87.79,109.69 81.98,103.88 76.72,103.88 76.54,103.7 72.38,103.7 v2(71.72,103.04)
  BOTTOM w0.254: v2(71.72,103.04) 70.95,102.27 PR1439.1 PR1441.1 PR1440.1 ; v2(104.02,117.59) 104.12,117.69 104.98,117.69 105.23,117.43 PR1436.2
VBATT: length 48.3
  TOP w0.508: PD300.2 25.05,33.05 v2(24.29,32.29)
  IN1 w0.508: v2(41.28,15.99) 41.28,15.1 40.9,14.72 36.97,14.72 36.52,15.17 25.09,15.17 22.39,17.87 18.32,17.87 16.65,19.55 16.65,23.99 18.14,25.49 18.14,27.47 19,28.34 23.4,28.34 24.29,29.23 v2(24.29,32.29)
  vias: v2(41.92,16.12) v2(42.55,15.99) v4(41.75,15.06)
VCC_CHG: length 22.7
  TOP w0.114: PR310.1 v3(23.53,29.38)
  TOP w0.508: v2(23.37,42.67) 23.67,42.67 24.29,42.05 26.36,42.05 26.55,42.24 28.74,42.24 R3.1 ; PD300.1 23.53,33.06 v2(23.53,32.2) PR310.1
  IN4 w0.508: v2(23.53,32.2) 23.53,32.69 24.34,33.51 24.34,36.01 22.17,38.18 22.17,41.48 v2(23.37,42.67)
VCC_CORE_PT1: length 2.3
  BOTTOM w0.114: PU1400.22 121.84,126.43 121.04,125.63 PT1400.1
VCC_CORE_PT2: length 2.2
  BOTTOM w0.114: PU1401.22 111.72,126.43 110.88,125.59 PT1401.1
VCC_CORE_PT3: length 2.1
  BOTTOM w0.114: PT1402.1 100.97,125.49 101.79,126.3 PU1402.22
VCC_GT_PT1: length 2.9
  BOTTOM w0.114: PU1500.22 91.5,126.3 90.28,125.09 PT1500.1
VCC_GT_PT2: length 3.4
  BOTTOM w0.114: PU1501.22 72.86,109.05 72.9,109.02 72.9,108.59 73.95,107.53 PT1501.1
VCC_SA_PT1: length 1.6
  BOTTOM w0.114: PT1503.1 131.06,124.75 131.61,124.75 131.85,124.99 PU1503.9
VCC_SENSE: length 40.1
  TOP w0.254: PR1146.2 71.97,96.07 v2(71.97,96.33) 71.97,96.48 PC1134.2
  IN1 w0.254: v2(71.97,96.33) 72.2,96.33 73.19,95.34 76.26,95.34 79.44,98.52 82.78,98.52 89.13,104.87 102.96,104.87 103.54,105.45 v2(103.54,105.93)
  BOTTOM w0.254: v2(103.54,105.93) 103.54,106.19 103.82,106.47 104.7,106.47 RH198.2
VCCGT_B+:
  vias: v2(64.68,116.42) v2(64.7,115.84) v2(64.68,115.1) v2(65.31,116.42) v2(65.31,115.79) v2(65.31,115.13) v2(65.95,116.42) v2(65.95,115.79) v2(66.1,117.8) v2(66.08,117.13) v2(66.58,116.42) v2(66.58,115.79) v2(67.22,116.42) v2(67.22,115.79) v2(71.09,113.18) v2(71.76,113.99) v2(71.76,113.18) v2(96.48,128.08) v2(96.48,127.4) v2(97.57,129.25) v2(98.18,129.91) v2(98.21,129.25) v2(98.82,129.91) v2(98.84,129.25) v2(99.45,129.91) v2(99.48,129.25) v4(69.49,116.4)
VCCGT_SENSE: length 58.4
  IN1 w0.254: v2(64.04,87.81) 65.54,89.31 65.54,91.22 64.73,92.03 64.73,97.05 67.39,99.71 71.14,99.71 72.51,98.34 77.19,98.34 78.41,99.56 82.32,99.56 88.65,105.88 102.22,105.88 v2(102.27,105.93)
  BOTTOM w0.254: v2(102.27,105.93) 102.35,105.86 102.35,105.22 v3(103.81,103.76) 104.76,102.81 RH204.2 ; v2(64.04,87.81) PR1127.1 PC1109.1
VCCIO_EN: length 8.8
  TOP w0.254: PU700.11 66.6,65.61 66.35,65.37 65.23,65.37 v3(64.23,64.36) 64.07,64.2 62.69,64.2 DZ2.2 61.95,62.67 RZ107.2 CZ108.1 62.18,60.66 PR704.1
VCCIO_PG: length 210.1
  TOP w0.114: v2(63.69,42.64) 63.66,42.66 56.84,42.66 50.88,48.62 v4(50.88,49.47) 51.95,50.54 57.08,50.54 61.57,55.02 61.57,60.4 61.41,60.56 61.41,63.89 62.26,64.73 64.2,64.73 65.3,65.84 65.3,66.82 65.53,67.04 PU700.9 ; PR712.1 191.17,21.99 190.61,21.43 189.89,21.43 189.5,21.04 189.5,19.55 188.44,18.49 188.44,17 188.12,16.68 187.03,16.68 v2(186.57,17.14)
  IN1 w0.094: v2(186.57,17.14) 186.57,17.43 186.28,17.72 183.72,17.72 182.28,16.28 182.25,16.28 180.19,14.21 173.3,14.21 170.5,17.02 170.5,17.24 169.2,18.53 161.14,18.53 159.64,17.04 146.78,17.04 144.85,18.97 138.13,18.97 137.81,19.29 103.2,19.29 101.9,17.99 74.74,17.99 73.96,17.21 65.98,17.21 61.83,21.37 61.83,23.74 60.18,25.39 60.18,33.93 62.59,36.34 62.59,41.54 v2(63.69,42.64)
VCCIO_SENSE: length 72.2
  TOP w0.127: v2(64.78,60.44) 64.27,60.44 v3(64.02,60.7)
  TOP w0.254: v2(64.78,60.44) 65.59,60.44 PR705.2 ; v2(119.97,83.89) 119.97,83.94 120.23,84.19 RH514.2
  IN4 w0.254: v2(119.97,83.89) 119.9,83.81 110.25,83.81 109.23,82.79 107.07,82.79 106.35,83.51 104.83,83.51 104.66,83.68 102.72,83.68 102.71,83.68 102.31,83.68 102.31,83.68 100.3,83.68 100.3,83.68 99.9,83.68 99.9,83.68 97.89,83.68 97.89,83.68 97.49,83.68 97.48,83.68 95.48,83.68 95.47,83.68 95.07,83.68 95.07,83.68 93,83.68 92.5,84.19 87.1,84.19 83.42,80.51 82.33,80.51 79.35,77.53 79.2,77.53 74.99,73.32 74.99,70.42 72.76,68.19 72.76,65.21 72.3,64.76 71.99,64.76 70.82,63.59 68.66,63.59 65.38,60.32 64.91,60.32 v2(64.78,60.44)
VCCSA_SENSE: length 55
  IN1 w0.254: v2(82.56,89.55) 82.38,89.73 82.38,90.18 82.49,90.29 83.96,90.29 84.97,91.3 84.97,93.4 88.09,96.51 88.09,99.5 89.06,100.47 89.06,101.31 90.05,102.3 105.05,102.3 105.83,103.09 117.48,103.09 118.28,103.89 118.28,104.65 v2(118.41,104.78)
  BOTTOM w0.254: v2(82.56,89.55) 82.48,89.47 82.48,88.36 v4(82.69,88.15) 83.22,88.15 83.65,88.59 83.65,90.39 83.45,90.59 82.53,90.59 82.1,90.16 PR1129.2 81.61,90.17 PC1115.2 ; RH202.2 v2(118.41,104.78)
VCCSENSE_VGA: length 39.5
  IN1 w0.406: v2(185.6,56.42) 184.8,56.42 175.47,65.75 175.47,67.78 174.58,68.67 174.58,72.1 173.96,72.72 173.96,73.24 172.99,74.21 172.99,76.62 173.75,77.38 173.75,77.71 173.95,77.92 173.95,78.32 173.4,78.87 v2(173.4,78.91)
  BOTTOM w0.305: UV1.L4 173.79,78.53 173.44,78.88 173.43,78.88 v2(173.4,78.91)
  BOTTOM w0.406: v2(185.6,56.42) 185.6,53.63 v4(185.15,53.18) 182.44,50.47 PR1620.1
VCCST:
  vias: v3(132.39,95.29)
VCCST_PWRGD_CPU: length 9.5
  TOP w0.114: v2(130.03,77.69) 130.4,77.32 RH154.2
  IN1 w0.094: v2(130.03,77.69) 130.03,78.1 129.3,78.83 128.94,78.83 127.77,80 127.77,80.06 127.42,80.41 124.9,80.41 124.52,80.79 124.52,81.04 v2(123.96,81.6)
  BOTTOM w0.076: v2(123.96,81.6) 123.61,81.96 UH1.H13
VCCSTG:
  vias: v4(137.03,99.24)
VDDS_SENSE_VGA: length 62.2
  TOP w0.254: PR1720.1 211.02,50.05 v2(211.16,49.91)
  IN4 w0.254: v2(211.16,49.91) 211.66,49.42 211.66,48.03 210.7,47.08 205.15,47.08 202.72,49.52 199.86,49.52 199.44,49.52 191.47,57.5 191.34,57.5 190.76,58.08 190.76,58.2 189.41,59.55 182.49,59.55 175.85,66.19 175.85,67.51 175.04,68.33 175.04,72.44 174.91,72.57 174.91,72.76 172.75,74.92 172.75,75.36 172.48,75.63 171.39,75.63 170.85,76.17 169.68,76.17 169.47,75.96 v2(169.38,75.96)
  BOTTOM w0.254: v2(169.38,75.96) 168.94,75.96 UV1.U1
VIN: length 43
  TOP w0.508: PD300.3 26.45,34.35 v4(27.54,35.43) 27.63,35.52 27.63,37.95 27.25,38.33 v4(27.25,38.66) 27.25,40.39 26.24,41.4 v4(25.28,41.4) 23.91,41.4 23.64,41.67 22.58,41.67
  IN4 w0.508: v2(22.9,39.59) 24.83,41.52 35.37,41.52 38.41,38.47 43.57,38.47 45.17,40.07 v2(46.38,40.07)
  BOTTOM w0.254: v2(46.38,40.07) PR209.1 PR210.1 PR203.1
  BOTTOM w0.508: PR317.1 23.12,41.52
  vias: v2(17.23,38.04) v2(17.23,37.42) v2(17.74,38.34) v2(17.74,37.71) v2(18.27,38.65) v2(18.27,38.05) v2(18.29,37.47) v2(22.9,38.9) v2(22.9,38.32)
VSS_SENSE: length 43.3
  IN1 w0.254: v2(71.38,94.15) 71.59,94.35 71.59,94.88 71.23,95.24 71.23,95.49 71.56,95.82 71.97,95.82 72.96,94.83 76.47,94.83 79.65,98.01 82.99,98.01 89.34,104.36 103.17,104.36 104.18,105.37 v2(104.18,105.93)
  BOTTOM w0.203: v2(71.38,94.15) 71.38,93.34 71.54,93.18 PU1100.18
  BOTTOM w0.254: RH28.2 104.86,105.25 v2(104.18,105.93) ; v2(71.38,94.15) 71.51,94.27 PC1135.1
VSSGT_SENSE: length 57.6
  IN1 w0.254: v2(102.96,105.92) 102.97,105.91 102.97,105.63 102.72,105.37 88.86,105.37 82.53,99.05 78.62,99.05 77.4,97.83 72.3,97.83 70.93,99.2 67.6,99.2 65.24,96.84 65.24,92.24 66.05,91.43 66.05,89.37 66.3,89.12 v2(67.29,89.12)
  BOTTOM w0.203: v2(67.29,89.12) 67.47,89.3 68.13,89.3 68.2,89.37 PU1100.6
  BOTTOM w0.254: PC1114.1 67.17,89.12 v2(67.29,89.12) ; RH32.2 104.62,104.03 104.26,104.03 103.17,105.12 v3(103.17,105.13) 103.16,105.13 102.85,105.43 102.85,105.82 v2(102.96,105.92)
VSSIO_SENSE: length 71.8
  TOP w0.254: PR710.2 65.47,59.93 64.91,59.93 64.78,59.81 v2(64.78,59.45) ; RH513.2 v2(119.95,83.3)
  IN4 w0.254: v2(119.95,83.3) 110.5,83.3 109.48,82.29 106.82,82.29 106.1,83.01 104.62,83.01 104.45,83.18 102.93,83.18 102.92,83.17 102.1,83.17 102.1,83.18 100.51,83.18 100.51,83.17 99.69,83.17 99.69,83.18 98.1,83.18 98.1,83.17 97.28,83.17 97.27,83.18 95.69,83.18 95.69,83.17 94.86,83.17 94.86,83.18 92.79,83.18 92.29,83.68 87.31,83.68 83.63,80 82.54,80 79.56,77.02 79.41,77.02 75.49,73.1 75.49,70.21 73.26,67.98 73.26,65 72.51,64.25 72.2,64.25 71.03,63.08 68.87,63.08 65.59,59.81 65.03,59.81 64.81,59.58 64.81,59.48 v2(64.78,59.45)
VSSSA_SENSE: length 55.2
  IN1 w0.254: v2(81.87,89.42) 81.87,90.39 82.28,90.8 83.75,90.8 84.46,91.51 84.46,93.61 87.58,96.72 87.58,99.71 88.55,100.68 88.55,101.52 89.84,102.81 104.84,102.81 105.62,103.6 117.27,103.6 117.77,104.1 117.77,104.56 117.56,104.78 v2(117.56,104.77)
  BOTTOM w0.254: v2(117.56,104.77) 117.52,104.73 RH31.2 ; PU1100.31 75.73,89.37 75.73,89.37 76.19,89.37 76.42,89.14 PC1116.1 77.2,89.7 80.17,89.7 80.66,89.21 v3(81.07,89.21) 81.66,89.21 v2(81.87,89.42)
VSSSENSE_VGA: length 39.1
  IN1 w0.406: v2(173.36,79.75) 173.64,79.75 174,79.39 174,79.21 174.61,78.6 174.61,77.59 174.41,77.38 174.41,77.1 173.65,76.35 173.65,74.48 174.62,73.52 174.62,73 175.24,72.37 175.24,68.95 176.13,68.06 176.13,66.02 184.85,57.31 v2(184.9,57.31)
  BOTTOM w0.305: UV1.L5 173.79,79.32 v2(173.36,79.75)
  BOTTOM w0.406: v2(184.9,57.31) 184.9,56.54 v4(184.9,56.54) 184.9,53.86 182.16,51.13 181.22,51.13 179.9,52.45 PR1618.1
+AMP:
  vias: v2(259.52,20.08) v2(259.45,18.86) v2(259.55,19.47) v2(260.06,18.99) v2(267.45,19.17) v2(267.45,18.53) v2(269.58,19.52) v2(270.16,19.52) v4(268.17,18.81)
+CHGRTC: length 2.7
  BOTTOM w0.127: DC2.3 152.22,18.65 152.22,20.67 v3(151.85,21.03)
+DC_IN: length 7.4
  TOP w0.102: 11.58,41.01 10.84,41.75 v4(10.84,42.41) ; 11.58,41.01 11.06,40.49 v4(10.87,40.49) ; 11.58,41.01 PC100.1 12.85,41.01 13.47,41.63 v4(13.47,42.66)
  TOP w0.508: PC101.1 13.22,40 v2(13.22,40.25) ; PC100.1 v2(12.33,40.25)
+DCPRTC: length 2.6
  TOP w0.102: v2(165.95,24.22) 166.08,24.22 v3(166.61,23.69) 166.61,23.45 166.21,23.05 CH70.1
  BOTTOM w0.102: v2(165.95,24.22) 165.97,24.22 UH2.BA26
+EDPVDD:
  vias: v2(61.1,34.15) v2(61.6,34.53) v2(61.6,33.77) v4(60.97,35.35) v4(62.35,37.71) v4(63.48,39.72)
+FB_PLLAVDD: length 5.3
  TOP w0.381: v2(173.9,97.09) 173.91,97.11 173.91,97.72 173.34,98.29 CV154.1
  TOP w0.508: CV152.1 v2(169.19,98.21) ; CV153.1 176.94,88.86 v2(176.79,89.01)
  BOTTOM w0.305: UV1.U27 v2(169.19,98.21) ; UV1.H17 v2(176.79,89.01) ; UV1.K27 174.61,97.81 v2(173.9,97.09)
  vias: v2(148.35,100.32) v4(147.52,101.44)
+FBA_VREFC0: length 68.9
  IN3 w0.406: v2(152.66,132.45) 152.66,132.96 153.17,133.47 188.48,133.47 189.87,132.07 189.87,125.47 191.27,124.07 191.27,123.82 192.03,123.05 v2(192.41,123.05)
  BOTTOM w0.406: UV7.J14 154.04,125.29 CV200.1 153.48,125.85 153.04,125.85 v4(152.05,126.84) 152.05,131.84 v2(152.66,132.45) ; RV125.2 191.55,122.42 192.19,123.05 v2(192.41,123.05) ; RV125.2 190.97,121.68 RV126.2 ; RV125.2 190.97,123.19 CV158.1 RV127.1 188.28,124.98 187.97,125.29 UV6.J14
+FBC_VREFC1: length 63.3
  BOTTOM w0.406: UV8.J14 203.86,76.51 204.28,76.09 204.28,75.45 203.8,74.98 RV142.1 CV177.1 ; UV9.J14 203.86,109.1 204.68,109.92 CV199.1 204.68,111.14 v4(205.29,111.75) 211.46,111.75 212.35,110.86 212.35,74.41 211.19,73.24 210.22,73.24 209.66,72.68 RV140.2 204.41,72.68 203.8,73.3 CV177.1 ; CV177.1 203.31,73.67 RV141.2
+GPCPLL_AVDD: length 75.8
  TOP w0.508: v2(157.55,76.51) 157.55,76.3 RV583.1
  IN1 w0.508: v2(153.07,79.29) 153.07,79.72 151.5,81.29 151.5,82.06 148.61,84.94 148.61,86.01 146.97,87.65 v2(146.97,98.67)
  IN2 w0.508: v2(175.95,96.38) 175.38,96.38 174.98,95.98 168.62,95.98 168.08,96.51 164.83,96.51 164.63,96.71 162.35,96.71 160.74,98.32 160.74,104.17 159.94,104.97 159.94,105.48 159.41,106.01 151.37,106.01 148.09,102.73 146.72,102.73 145.78,101.79 145.78,100.78 146.97,99.58 v2(146.97,98.67)
  BOTTOM w0.127: v2(146.97,98.67) v4(146.97,99.39)
  BOTTOM w0.305: UV1.H26 175.95,96.47 v2(175.95,96.38)
  BOTTOM w0.508: v2(157.55,76.51) 156.55,75.5 154.11,75.5 153.46,76.15 153.46,77.9 153.07,78.3 v2(153.07,79.29)
+GPU_CORE: length 20.4
  TOP w0.508: PC1637.1 154.1,74.89 v2(154.96,74.89) 155.12,74.74 RZ10.1
  IN3 w0.508: 170.88,65.1 170.88,62.82 175.92,57.78 175.92,56.47 177.43,54.96 177.43,52.01 177.66,51.78 v2(177.66,50.21)
  BOTTOM w0.356: 168.9,90.31 UV1.U18
  BOTTOM w0.508: PR1623.1 v2(177.66,50.21)
  vias: v2(145.78,66.65) v2(145.78,66.02) v2(145.78,65.36) v2(145.78,64.76) v2(146.07,67.16) v2(146.36,66.65) v2(146.36,66.02) v2(146.36,65.36) v2(146.39,64.76) v2(146.99,66.5) v2(146.99,65.86) v2(146.99,65.2) v2(147.62,66.5) v2(147.62,65.86) v2(147.62,65.2) v2(148.26,66.5) v2(148.26,65.86) v2(148.26,65.2) v2(148.9,66.49) v2(148.9,65.85) v2(148.9,65.22) v2(149.62,66.46) v2(149.62,65.83) v2(149.62,65.17) v2(149.96,66.97) v2(150.2,71.19) v2(150.16,70.48) v2(150.16,69.84) v2(150.16,69.26) v2(150.17,68.67) v2(150.17,68.06) v2(150.25,66.46) v2(150.25,65.83) v2(150.25,65.17) v2(150.78,71.19) v2(150.89,66.46) v2(150.89,65.83) v2(150.89,65.17) v2(151.39,71.19) v2(151.52,66.46) v2(151.52,65.83) v2(151.52,65.17) v2(151.98,71.16) v2(152.16,66.46) v2(152.16,65.83) v2(152.16,65.17) v2(152.61,71.16) v2(152.89,66.44) v2(152.89,65.8) v2(152.89,65.17) v2(153.25,71.16) v2(153.6,66.41) v2(153.6,65.78) v2(153.6,65.12) v2(153.93,71.16) v2(154.24,66.41) v2(154.24,65.78) v2(154.24,65.12) v2(154.54,71.14) v2(154.87,66.41) v2(154.87,65.78) v2(154.87,65.12) v2(154.98,70.4) v2(155.15,71.11) v2(155.51,66.41) v2(155.51,65.78) v2(155.51,65.12) v2(155.64,70.42) v2(155.74,71.11) v2(156.22,69.51) v2(156.22,68.9) v2(156.19,68.32) v2(156.22,67.71) v2(156.14,66.41) v2(156.14,65.78) v2(156.14,65.12) v2(156.25,70.14) v2(156.25,67.1) v2(156.88,69.76) v2(156.88,69.13) v2(156.88,68.49) v2(156.88,67.83) v2(156.88,67.2) v2(156.88,66.56) v2(156.88,65.93) v2(157.03,65.19) v2(157.21,70.27) v2(157.52,69.76) v2(157.52,69.13) v2(157.52,68.49) v2(157.52,67.83) v2(157.52,67.2) v2(157.52,66.56) v2(157.52,65.93) v2(157.67,65.19) v2(157.95,70.25) v2(158.28,69.74) v2(158.28,69.1) v2(158.28,68.47) v2(158.28,67.81) v2(158.28,67.17) v2(158.28,66.54) v2(158.28,65.9) v2(158.3,65.19) v2(158.58,70.27) v2(158.91,69.74) v2(158.91,69.1) v2(158.91,68.47) v2(158.91,67.81) v2(158.91,67.17) v2(158.91,66.54) v2(158.91,65.9) v2(158.94,65.19) v2(159.27,70.27) v2(159.55,69.74) v2(159.55,69.1) v2(159.55,68.47) v2(159.55,67.83) v2(159.55,67.17) v2(159.55,66.54) v2(159.55,65.9) v2(159.57,65.19) v2(160,70.58) v2(160.15,66.99) v2(160.33,66.44) v2(160.33,65.8) v2(160.33,65.17) v2(160.61,70.58) v2(160.97,66.44) v2(160.97,65.8) v2(160.97,65.17) v2(161.1,70.96) v2(161.6,66.44) v2(161.6,65.8) v2(161.6,65.17) v2(161.68,71.11) v2(162.24,66.44) v2(162.24,65.8) v2(162.24,65.17) v2(162.32,71.11) v2(162.9,66.44) v2(162.9,65.8) v2(162.9,65.17) v2(162.95,71.11) v2(163.43,94.86) v2(163.39,84.81) v2(163.38,84.1) v2(163.54,66.44) v2(163.54,65.8) v2(163.54,65.17) v2(163.56,90.82) v2(163.59,71.11) v2(164.22,71.11) v2(164.17,66.44) v2(164.17,65.8) v2(164.17,65.17) v2(164.39,90.81) v2(164.5,88.79) v2(164.5,83.02) v2(164.58,93.82) v2(164.55,92.85) v2(164.86,71.11) v2(164.88,66.41) v2(164.88,65.78) v2(164.88,65.12) v2(165.03,83.26) v2(165.39,88.81) v2(165.52,66.41) v2(165.52,65.78) v2(165.52,65.12) v2(165.81,70.5) v2(165.81,69.92) v2(165.81,69.33) v2(165.82,68.72) v2(165.82,68.11) v2(165.83,67.53) v2(165.9,81.42) v2(165.9,80.58) v2(165.87,79.72) v2(165.85,66.94) v2(166.15,66.41) v2(166.15,65.78) v2(166.15,65.12) v2(166.39,91.81) v2(166.39,90.81) v2(166.39,88.81) v2(166.39,87.81) v2(166.41,83.91) v2(166.46,66.94) v2(166.84,83.4) v2(166.79,66.41) v2(166.79,65.78) v2(166.79,65.12) v2(167.09,66.94) v2(167.39,93.81) v2(167.35,90.77) v2(167.39,89.81) v2(167.39,88.81) v2(167.4,86.6) v2(167.39,84.81) v2(167.39,83.81) v2(167.4,66.39) v2(167.4,65.75) v2(167.4,65.12) v2(167.52,80.53) v2(167.57,78.93) v2(167.55,77.31) v2(167.7,66.92) v2(167.8,83.35) v2(168.06,66.36) v2(168.06,65.73) v2(168.06,65.12) v2(168.28,66.92) v2(168.39,93.81) v2(168.39,91.81) v2(168.39,87.81) v2(168.39,85.81) v2(168.41,80.58) v2(168.39,78.92) v2(168.67,66.33) v2(168.67,65.74) v2(168.67,65.12) v2(168.89,83.33) v2(169.39,93.81) v2(169.43,90.77) v2(169.4,89.8) v2(169.39,86.81) v2(169.39,84.81) v2(169.39,83.81) v2(170.36,91.78) v2(170.39,90.81) v2(170.39,88.81) v2(170.39,87.81) v2(171.18,83.4) v2(171.43,88.92) v2(172.22,92.8) v2(172.22,86.81) v2(172.25,93.84) v2(172.39,90.81) v2(172.37,88.99) v2(172.39,85.81) v2(172.6,83.78) v2(173.39,90.81) v2(173.39,83.81) v2(173.49,94.71) v2(174,83.75) v4(168.4,72.55)
+GPU_CORE_VDDS: length 66.8
  TOP w0.508: RZ9.1 147.36,106.31 146.57,105.53 v2(146.57,101.08) ; v2(209.94,52.19) 209.64,51.88 PR1721.1
  IN2 w0.508: v2(146.57,101.08) 149.9,101.08 151.27,99.71 153.07,99.71 154.82,97.96 157.66,97.96 158.25,97.37 159.22,97.37 159.22,97.37
  IN4 w0.508: v2(209.94,52.19) 209.88,52.12 209.88,49.81 208.42,48.35 207.65,48.35 205.22,50.79 203.59,50.79 200.02,54.36 197.66,54.36 189.61,62.41 186.27,62.41 v2(185.93,62.75)
  BOTTOM w0.305: v2(173.52,92.78) 173.52,92.94 UV1.M21 173.9,93.31 v2(174.3,93.72)
  BOTTOM w0.381: v2(164.6,91.81) 164.6,91.6 UV1.AA19 ; UV1.AC14 162.93,86.31 v2(163.37,86.75) ; UV1.M14 173.62,86.58 v2(173.62,86.81) ; UV1.AA23 v2(165.39,94.81) ; UV1.W21 v2(166.39,93.81) ; UV1.T14 v2(170.39,85.81) ; UV1.P12 v2(171.39,84.81) ; UV1.P16 172.25,87.95 172.25,87.82 172.3,87.77 v2(172.3,87.72) ; v2(172.22,91.79) 172.22,91.64 UV1.P19 ; UV1.AA16 v2(164.36,87.78) ; UV1.AA12 v2(165.39,84.81) ; v2(170.41,93.83) 170.38,93.83 169.89,93.34 UV1.T21 ; UV1.U17 168.57,89.63 v2(168.41,89.63) 168.41,89.79 UV1.V18 ; v2(171.41,94.88) 171.63,95.11 171.69,95.11 UV1.P23 ; UV1.W14 v2(166.39,85.81) ; v2(163.41,92.8) 163.38,92.83 163.37,92.83 UV1.AC21
  vias: v2(174.61,94.27) v2(178.95,67.48) v2(178.95,66.84) v2(178.95,66.23) v2(179.44,65.27) v2(179.49,67.15) v2(179.49,66.54) v2(179.46,65.93) v2(180.06,67.57) v2(180.07,66.94) v2(180.1,66.36) v2(180.1,65.78) v2(180.1,65.09) v2(180.12,64.48) v2(180.65,68.01) v2(180.67,67.43) v2(180.67,66.84) v2(180.67,66.16) v2(180.67,65.57) v2(180.73,64.89) v2(180.73,64.25) v2(180.66,63.66) v2(181.19,71.9) v2(181.24,63.49) v2(181.37,64.76) v2(181.49,64.13) v2(181.65,62.73) v2(181.77,71.87) v2(181.92,63.54) v2(182.05,64.46) v2(182.25,62.73) v2(182.38,71.87) v2(182.53,63.54) v2(182.66,64.46) v2(182.93,62.78) v2(182.99,71.69) v2(183.02,71.08) v2(183.04,70.42) v2(183.04,69.79) v2(183.11,63.54) v2(183.24,64.46) v2(183.58,71.72) v2(183.62,71.08) v2(183.62,70.42) v2(183.62,69.79) v2(183.54,62.78) v2(183.72,63.52) v2(183.85,64.43) v2(184.13,62.78) v2(184.19,71.69) v2(184.2,71.08) v2(184.2,70.42) v2(184.2,69.79) v2(184.31,63.52) v2(184.43,64.43) v2(184.84,71.06) v2(184.84,70.4) v2(184.84,69.76) v2(184.76,62.75) v2(184.85,71.69) v2(184.89,63.52) v2(185.02,64.43) v2(185.07,65.04) v2(185.42,71.06) v2(185.42,70.4) v2(185.42,69.76) v2(185.42,69.13) v2(185.42,68.54) v2(185.35,62.75) v2(185.46,71.69) v2(185.45,67.96) v2(185.47,67.38) v2(185.47,66.79) v2(185.47,66.21) v2(185.47,65.62) v2(185.47,63.57) v2(185.6,64.4) v2(185.68,65.01) v2(186.01,71.06) v2(186.01,70.4) v2(186.01,69.76) v2(186.01,69.18) v2(186.01,68.6) v2(186.03,68.01) v2(186.06,71.69) v2(186.06,67.43) v2(186.06,66.84) v2(186.06,66.16) v2(186.06,65.57) v2(186.09,63.57) v2(186.19,64.4) v4(179.25,63.44)
+IFP_PLLVDD: length 0.7
  BOTTOM w0.305: v2(161.73,80.53) 161.29,80.97 UV1.AF7
+INV_PWR_SRC: length 3.9
  TOP w0.102: v4(60.69,21) QV11.1 62.38,20.08 v4(61.47,19.17)
  vias: v2(61.2,24.96) v2(61.76,25.14) v2(61.77,24.53) v4(61.06,24.35)
+LAN_IO:
  vias: v2(281.62,48.83) v2(281.82,48.25) v2(282.46,48.25) v2(283.22,46.6) v2(284.9,41.85) v2(284.9,41.27) v2(289.7,47.72) v2(290.28,47.69) v4(289.53,45.98)
+LAN_VDD: length 6.1
  TOP w0.127: v2(282.59,41.52) v3(281.89,41.52)
  TOP w0.508: v2(287.92,47.49) 287.92,47.36 287.42,46.87 CL22.1 ; CL32.1 283.35,45.53 v2(283.17,45.35) ; v2(285.4,47.59) 285.58,47.41 CL20.1
  BOTTOM w0.203: UL1.3 285.41,47.58 v2(285.4,47.59) ; UL1.8 287.41,47.08 287.82,47.49 v2(287.92,47.49) ; UL1.30 283.44,45.29
  BOTTOM w0.381: 283.44,45.29 283.23,45.29 v2(283.17,45.35)
  vias: v2(283.18,41.49) v2(283.81,41.52)
+NVVDDS_B+: length 14
  TOP w0.381: v2(207.96,49.57) 208.42,49.11 PR1714.1
  IN4 w0.381: v2(207.96,49.57) 208.42,50.03 208.42,56.51 204.56,60.37 v2(204.56,61)
  vias: v3(204.45,62.08)
+PEX_PLL_HVDD: length 7
  TOP w0.508: RV590.1 155.88,83.09 156.48,83.69 156.48,84.15 156.78,84.45 157.11,84.45 157.18,84.51 158.26,84.51 v3(158.34,84.43) 158.95,84.43 159.32,84.8 v2(159.98,84.8) 160.32,84.8 160.47,84.65 CV114.1
  BOTTOM w0.305: v2(159.98,84.8) 159.59,85.19 UV1.AH12
+RTCBATT: length 1.6
  BOTTOM w0.127: RC11.2 155.51,16.06 v4(155.94,15.62)
+RTCVCC: length 177.2
  TOP w0.127: v2(221.27,33.14) v4(220.35,33.14)
  TOP w0.508: CH173.1 CH80.1 168.6,24.88 169.1,24.37 v2(169.1,24.35) ; v2(281.47,16.6) 282.33,17.47 RA18.2 ; v2(179.08,20.2) 178.72,20.2 177.35,18.84 RH83.1 RH143.2 RH84.1
  IN1 w0.508: v2(154.19,19.67) 155.57,19.67 155.86,19.97 159.2,19.97 159.9,20.67 v2(159.9,21.48)
  IN2 w0.508: v2(281.47,16.6) 279.46,16.6 278.24,15.38 269.96,15.38 268.87,14.29 262.6,14.29 262.24,14.65 258.63,14.65 258.12,15.15 258.12,19.12 257.52,19.73 252.23,19.73 251.95,19.45 v2(246.14,19.45)
  IN3 w0.508: v2(221.27,33.14) 220.42,32.28 220.37,32.28 220.32,32.24 217.09,32.24 217.03,32.18 215.44,30.59 215.44,29.8 214.71,29.06 213.33,29.06 213.12,29.28 207.91,29.28 207.76,29.12 204.69,29.12 201.97,31.84 199.28,31.84 196.62,29.19 189.98,29.19 188.08,27.3 188.08,23.38 186.62,21.92 180.95,21.92 179.23,20.2 v2(179.08,20.2) 178.59,20.69 176.14,20.69 175.68,21.15 175.68,21.71 174.95,22.43 171.02,22.43 170.47,22.98 170.11,22.98 169.86,23.23 169.68,23.41 169.68,23.41 169.1,23.99 v2(169.1,24.35)
  IN4 w0.508: v2(159.9,21.48) 160.82,22.4 162.56,22.4 163.76,23.6 164.97,23.6 165.52,23.05 166.14,23.05 166.72,23.63 166.92,23.63 167.72,24.42 169.02,24.42 v2(169.1,24.35)
  BOTTOM w0.305: UH2.BA22 168.67,23.92 v2(169.1,24.35)
  BOTTOM w0.508: v2(246.14,19.45) 245.3,20.28 245.3,22.52 243.21,24.6 243.21,25.95 242.03,27.13 241.31,27.86 241.31,31.26 240.13,32.44 240.13,33.73 238.95,34.92 227.19,34.92 224.62,32.35 223.97,32.35 223.7,32.07 RE52.2 RE31.1 222.51,32.64 222.62,32.74 222.62,33.47 221.94,34.14 RE16.1 221.27,33.99 v2(221.27,33.14) ; DC2.1 153.4,20.46 v2(154.19,19.67) 154.52,19.34 CC27.1
+RTCVCC_VBAT: length 5
  TOP w0.203: UE1.122 224.25,32.97 v2(224.32,33.04)
  BOTTOM w0.127: CE73.1 225.12,34.46 v3(225.38,34.72)
  BOTTOM w0.508: RE16.2 223.54,34.46 CE73.1 224.34,34.41 224.34,33.06 v2(224.32,33.04)
+SP_PLLVDD: length 0.6
  BOTTOM w0.305: v2(161.81,82.29) 162.14,81.95 UV1.AE8
  vias: v3(161.63,81.8)
+V_DAC: length 16.1
  TOP w0.508: v2(303.4,84.88) 303.4,84.81 303.03,84.45 300.86,84.45 v2(300.43,84.88) 299.99,84.45 297.95,84.45 v2(297.46,84.94) v4(296.53,84.01) CL41.1 294.49,84.05 v2(294.49,84.95)
  BOTTOM w0.508: TL2.1 v2(303.4,84.88) ; TL2.4 v2(300.43,84.88) ; TL2.10 v2(294.49,84.95) ; TL2.7 v2(297.46,84.94)
+V_DDR_REFA: length 60.3
  TOP w0.127: v2(113.62,31.41) 114.11,30.93 v3(114.27,30.93)
  TOP w0.508: CD96.1 113.92,31.7 v2(113.62,31.41) ; RH45.2 RH209.1 69.08,42.51 v2(69.56,42.03) 70.02,42.49 RH206.2
  IN3 w0.508: v2(113.62,31.41) 112.79,32.25 108.34,32.25 107.32,33.27 70.79,33.27 68.31,35.75 68.31,41.26 69.08,42.03 v2(69.56,42.03)
  BOTTOM w0.305: v2(113.62,31.41) 113.4,31.63 JDIMM1.164
+V_DDR_REFA_R: length 55.3
  TOP w0.508: v2(89.85,82.16) 88.86,82.16 87.26,80.56 87.26,79.31 87.72,78.86 87.72,74.94 88.66,74 88.66,70.73 86.94,69.01 86.94,64.95 76.34,54.35 68.07,54.35 66.53,52.81 66.53,50.41 67.22,49.72 67.22,46.38 v3(67.73,45.88) 68.16,45.44 CH101.1 RH45.1
+V_DDR_REFB: length 5.7
  TOP w0.127: v3(113.85,18.33) 113.49,18.69 v2(113.42,18.69)
  TOP w0.508: CD29.1 RH210.1 112.28,19.6 RH46.2 ; CD29.1 113.35,19.6 RH207.2 ; CD29.1 113.41,19.49 113.41,18.74 113.42,18.72 v2(113.42,18.69)
  BOTTOM w0.305: JDIMM2.164 113.41,18.71 v2(113.42,18.69)
+V_DDR_REFB_R: length 124.8
  TOP w0.508: v2(87.92,82.16) 85.35,82.16 83.25,80.05 83.25,77.68 86.28,74.64 86.28,65.19 76.05,54.96 67.78,54.96 65.92,53.1 65.92,50.16 66.61,49.47 66.61,42.94 67.11,42.43 67.42,42.43 v4(69.77,40.08) 70.93,38.93 70.93,37.06 70.94,37 70.94,30.15 v2(68.46,27.68) ; RH46.1 CH100.1 110.37,20.95 v2(110.88,21.45)
  IN3 w0.508: v2(68.46,27.68) 107.86,27.68 109.92,25.62 109.92,22.42 v2(110.88,21.45)
+VDISPLAY_VCC: length 48
  TOP w0.127: v2(270.07,28.11) 270.07,27.57 v4(269.82,27.32)
  IN2 w1.016: 296.41,65.3 295.86,64.76 291.81,64.76 280,52.96 279.19,52.96 272.42,46.19 272.42,42.31 272.68,42.05 272.68,33.75 271.16,32.23 271.16,31.7
  vias: v2(270.88,28.08) v2(297.01,65.64) v2(296.99,65.02)
+VGA_B+: length 9.8
  TOP w0.381: PR1614.1 174.76,53.33 173.34,51.91 v4(170.94,51.91) 170.47,51.91 v2(169.86,52.52)
  vias: v2(151.17,54.75) v2(151.19,53.81) v2(151.19,52.87) v2(151.19,51.88) v2(153.04,50.92) v2(153.5,54.88) v2(153.48,53.05) v2(153.55,55.92) v2(153.55,53.86) v2(168.18,50.84) v2(169.17,53.71) v2(169.17,53.1) v2(169.17,52.44) v2(169.17,51.83) v2(169.83,53.71) v2(169.83,53.13)
+VID_PLLVDD: length 0.6
  BOTTOM w0.305: UV1.AD7 162.96,81.01 v2(162.57,81.4)
+XS_PLLVDD: length 0.7
  BOTTOM w0.305: UV1.AD8 162.98,81.82 162.98,81.95 v2(162.6,82.34)
-DC_IN: length 4.9
  TOP w0.102: v2(11.57,29.62) v4(11.57,30.83) ; v2(11.57,29.62) 12.05,30.1 12.05,30.97 12.61,31.52 v4(12.61,32.3) ; v2(11.57,29.62) v4(11.57,29.02)
AC_PRESENT: length 11.6
  TOP w0.114: v2(172.3,18.58) 172.34,18.54 172.34,15.54 v3(172.66,15.22) RH125.1 173.82,14.06 DV1.2
  BOTTOM w0.076: UH2.BB15 172.05,23.38 172.39,23.04 172.39,22.23 172.27,22.11 172.27,21.67 172.23,21.63 172.23,21.08 172.36,20.96 172.36,20.4 172.51,20.25 172.51,19.63 172.3,19.41 v2(172.3,18.58)
ACAV_IN: length 241.3
  TOP w0.114: v2(177,12.62) 177,13.85 176.79,14.06 DV1.1 ; v2(221.8,30.52) 221.85,30.57 UE1.128 221.85,32.6 221.74,32.72 221.44,32.72 219.17,30.44 216.65,30.44 212.9,26.7 212.57,26.7 210.57,24.7 210.57,22.17 211.34,21.4 v2(211.34,19.65)
  IN1 w0.094: v2(211.34,19.65) 210.4,18.71 199.64,18.71 197.85,16.92 188.64,16.92 188.19,16.48 183.76,16.48 180.35,13.07 177.45,13.07 v2(177,12.62) 177,12.31 176.82,12.13 174.15,12.13 173.8,11.78 170.41,11.78 167.9,14.29 160.11,14.29 159.33,15.07 159.33,16.33 159.01,16.65 151,16.65 150.33,15.98 147.29,15.98 144.74,18.53 139.94,18.53 138.96,17.56 132.76,17.56 132.35,17.97 115.76,17.97 114.48,16.68 110.75,16.68 110.31,17.12 104.79,17.12 104.63,16.96 99.62,16.96 99.26,17.33 74.76,17.33 74.25,16.82 65.82,16.82 61.4,21.25 61.4,23.49 58.36,26.52 57.13,26.52 v2(54.85,28.8)
  IN4 w0.094: v2(50.82,32.88) 49.26,34.45 49.26,37.4 48.04,38.62 44.35,38.62 43.76,38.03 38.23,38.03 37.91,38.34 34.93,38.34 34.15,39.13 v2(26.6,39.13)
  BOTTOM w0.114: PR212.1 50.94,37.33 50.94,33 v2(50.82,32.88) 50.82,31.85 v4(51.96,30.72) 53.88,28.8 v2(54.85,28.8) ; CE84.2 221.62,30.67 221.78,30.52 v2(221.8,30.52)
  BOTTOM w0.203: PU300.5 27.38,37.74 26.67,38.45 26.6,38.45
  BOTTOM w0.254: 26.6,38.45 26.58,38.47 PR318.1 PR316.2 26.17,39.36 26.4,39.13 v2(26.6,39.13)
ACDET_CHG: length 5.6
  BOTTOM w0.203: 27.09,38.5 27.45,38.14 PU300.6
  BOTTOM w0.254: PR323.1 PR317.2 PC323.1 26.68,40.63 v3(26.92,40.39) 27.09,40.22 27.09,38.5
ACDRV_CHG:
  vias: v2(26.31,37.71) v2(26.9,37.56) v3(26.24,37.1)
ALL_GPWRGD: length 16
  TOP w0.114: v2(146.7,81.78) 147.14,82.22 RV56.2 147.96,81.73 147.96,81.32 CV54.1 ; v2(147.2,74.07) 147.68,74.07 147.84,73.9 UV19.4
  IN1 w0.094: v2(147.2,74.07) 147.2,74.73 145.65,76.28 145.65,79.29 146.13,79.76 146.13,80.77 146.7,81.34 v2(146.7,81.78)
  BOTTOM w0.114: v2(147.2,74.07) 147.2,74.07 146.99,73.86 145.63,73.86 145.22,73.45 RV572.1 145.13,73.31 v3(145.13,72.19)
ALL_SYS_PWRGD: length 207.7
  TOP w0.114: v2(192.08,27.63) RH106.1 RH105.2
  IN3 w0.127: v2(61.17,28.29) 61.45,28.01 67.65,28.01 68.04,28.4 108.45,28.4 109.13,27.71 141.4,27.71 142.02,28.34 145.09,28.34 145.62,27.82 150.05,27.82 151.51,29.28 152.78,29.28 153.46,29.96 153.46,30.91 155.94,33.39 162.09,33.39 164.54,30.94 164.54,28.93 165.03,28.44 165.03,23.8 166.41,22.42 169.6,22.42 170.34,22.42 170.78,21.99 173.72,21.99 175.43,20.27 178.3,20.27 178.9,19.68 180.38,19.68 180.67,19.97 180.67,21.05 181.02,21.4 186.82,21.4 192.08,26.65 v2(192.08,27.63) 192.98,27.63 194.3,26.3 v2(197.04,26.3)
  BOTTOM w0.114: v2(197.04,26.3) 198.49,24.86 204.91,24.86 205.55,24.22 205.55,23.25 206.71,22.09 208.16,22.09 209.58,20.67 209.58,18.89 210.41,18.06 210.41,14.23 212.49,12.14 218.11,12.14 219.24,11.01 219.24,10.71 219.87,10.07 224.11,10.07 v4(225.12,11.08) 226.1,12.06 RE62.1 ; PQ403.2 54.73,29.85 56.04,28.54 57.21,28.54 57.36,28.69 57.36,29.43 57.74,29.81 60.39,29.81 61.17,29.02 v2(61.17,28.29)
ALW_PWRGD_3V_5V: length 219.7
  IN3 w0.127: v2(255.03,17.19) 255.63,17.19 255.76,17.32 255.76,19.42 254.52,20.67 245.12,20.67 244.82,20.36 239.87,20.36 238.08,18.57 234.6,18.57 v2(233.66,19.51)
  IN4 w0.094: v2(60.21,17.69) 61.1,17.69 61.37,17.97 109.06,17.97 110.54,16.49 115.15,16.49 115.99,17.33 143.06,17.33 143.98,18.26 149.75,18.26 150.86,17.16 161.4,17.16 161.95,16.61 162.91,16.61 163.34,16.18 165.83,16.18 170.85,11.16 179.57,11.16 184.21,15.8 185.19,15.8 187.98,15.8 188.35,16.17 194.66,16.17 200.25,21.75 213.26,21.75 214.38,20.63 217.21,20.63 217.88,19.96 220.79,19.96 221.13,19.63 223.44,19.63 223.87,19.19 226.03,19.19 226.46,18.76 228.79,18.76 229.54,19.51 v2(233.66,19.51)
  BOTTOM w0.114: PR408.1 57.67,17.69 v3(59.7,17.69) v2(60.21,17.69) ; PR603.1 255.09,13.2 256.04,14.15 256.04,16.83 255.69,17.19 v2(255.03,17.19)
ALWON: length 198.7
  TOP w0.114: v2(224.09,19.61) 223.4,20.3 223.4,25.17 224.34,26.1 224.34,28.3 224.34,28.31 224.34,30.5 224.65,30.81 UE1.121
  IN4 w0.094: v2(60.97,18.33) 61.07,18.23 109.15,18.23 110.7,16.68 115.07,16.68 115.91,17.53 142.97,17.53 143.9,18.46 149.84,18.46 150.94,17.35 161.54,17.35 162.09,16.8 162.99,16.8 163.42,16.37 165.92,16.37 170.93,11.36 179.49,11.36 184.13,15.99 185.11,15.99 187.9,15.99 188.26,16.36 194.58,16.36 200.17,21.95 213.34,21.95 214.46,20.82 219.25,20.82 219.79,20.27 220.75,20.27 221.21,19.82 223.88,19.82 v2(224.09,19.61)
  BOTTOM w0.114: v2(60.97,18.33) 60.94,18.35 60.94,19.34 v3(61.13,19.52) 62.38,20.77 62.38,22.53 60.49,24.42 60.49,25.53 59.74,26.28 56.86,26.28 PR418.1
AUD_AGND: length 158.1
  TOP w0.102: CA16.1 287.74,24.02 v4(288.77,25.05)
  TOP w0.203: v2(283.46,28.83) 283.11,28.49 HDA1.38
  TOP w0.254: v2(284.13,22.04) 284.36,22.27 HDA1.25 ; v2(285.3,18.33) 285.38,18.25 285.38,17.29 284.95,16.86 283.87,16.86 280.71,13.69 280.71,12.51 278.27,10.07 256.37,10.07 255.64,10.81 255.64,21.15 256.14,21.66 v2(256.32,21.66) 256.35,21.63 256.6,21.63 256.78,21.45 256.78,20.82 256.42,20.47 256.42,11.37 256.96,10.84 277.76,10.84 279.87,12.94 279.87,13.86 283.02,17.01 v2(283.02,18.3)
  TOP w0.508: v2(285.3,18.33) 285.28,18.35 RA71.2 CA17.2 ; RA55.2 CA41.2 297.39,17.19 297.32,17.26 v2(297.32,19.68) ; v2(295.77,11.06) 295.03,11.8 RA15.1 ; v2(285.18,29.9) 284.92,29.64 CA63.1 ; CA2.2 v2(289.33,29.31) ; CA1.2 v2(289.57,26.66) ; CA24.2 v2(276.93,20.06) ; RA13.1 v2(291.15,21.21)
  GND1 w0.203: 300.29,8.45 JHP1.5 ; JHP1.5 301.27,8.45 ; JHP1.5 299.31,9.12 ; JHP1.5 301.27,9.12 ; JHP1.5 299.31,8.45 ; 302.41,9.12 JHP1.7 ; JHP1.7 304.47,8.45 ; JHP1.7 303.44,8.45 ; JHP1.7 302.41,8.45 ; JHP1.7 304.47,9.12
  VCC w0.203: 303.44,8.45 JHP1.7 ; JHP1.7 302.41,8.45 ; JHP1.7 304.47,8.45 ; JHP1.7 302.41,9.12 ; JHP1.7 304.47,9.12 ; JHP1.5 301.27,9.12 ; JHP1.5 299.31,9.12 ; JHP1.5 299.31,8.45 ; JHP1.5 301.27,8.45 ; JHP1.5 300.29,8.45
  GND2 w0.203: JHP1.5 301.27,9.12 ; JHP1.5 300.29,8.45 ; JHP1.5 301.27,8.45 ; JHP1.5 299.31,8.45 ; JHP1.5 299.31,9.12 ; JHP1.7 304.47,8.45 ; JHP1.7 302.41,9.12 ; JHP1.7 304.47,9.12 ; JHP1.7 303.44,8.45 ; JHP1.7 302.41,8.45
  GND3 w0.203: JHP1.5 301.27,8.45 ; JHP1.5 299.31,8.45 ; JHP1.5 299.31,9.12 ; JHP1.5 301.27,9.12 ; JHP1.5 300.29,8.45 ; JHP1.7 304.47,8.45 ; JHP1.7 303.44,8.45 ; JHP1.7 304.47,9.12 ; JHP1.7 302.41,8.45 ; JHP1.7 302.41,9.12
  BOTTOM w0.254: RA73.2 257.79,22.72 256.73,21.66 v2(256.32,21.66)
  BOTTOM w0.508: RA14.1 284.19,22.09 v2(284.13,22.04) ; RA9.1 279.01,21.35 v2(279.54,20.82) 279.66,20.82 280.24,21.39 CA23.2 ; v2(276.93,19.36) 276.93,18.87 277.44,18.37 278.37,18.37 RA16.1 ; v2(285.18,29.9) 284.92,29.64 CA63.1 ; v2(290.84,18.02) 290.84,17.64 291.09,17.39 293.18,17.39 CA43.2 ; RA12.1 291.47,14.72 v2(290.97,15.23) ; CA42.2 v2(297.9,11.39)
  vias: v2(288.53,20.72) v2(288.55,21.33)
AUD_AZA_CPU_SCLK: length 108.3
  TOP w0.114: v2(180.5,47.41) 181.15,47.41 181.57,47.84 183.89,47.84 v3(183.93,47.87) 183.93,47.88 184.2,48.15 188.65,48.15 190.74,46.06 190.74,40.31 189.95,39.51 189.95,37.89 189.38,37.32 189.38,36.68 v2(189.26,36.57)
  IN4 w0.094: v2(180.5,47.41) 180.5,50.04 175.23,55.31 175.23,55.73 175.51,56.01 175.51,57.68 174.89,58.3 174,58.3 169.11,63.2 169.11,67.38 168.62,67.87 168.62,69.94 168.36,70.21 166.94,70.21 166.56,70.59 166.56,71.18 166.31,71.42 165.23,71.42 165.14,71.51 165.08,71.51 165.08,71.51 160.97,71.51 160.76,71.3 156.41,71.3 156.07,71.64 152.09,71.64 150.91,72.82 150.91,72.97 150.4,73.47 149.62,73.47 146.74,76.35 146.74,77.29 143.62,80.4 143.62,82.31 132.31,93.63 130.73,93.63 129.25,92.14 125.69,92.14 124.57,93.26 v2(124.57,93.41)
  BOTTOM w0.076: UH1.G27 124.31,93.15 v2(124.57,93.41)
  BOTTOM w0.114: v2(189.26,36.57) 189.24,36.54 RH147.1
AUD_AZA_CPU_SCLK_R: length 14.2
  BOTTOM w0.076: UH2.AM2 178.33,28.35 178.66,28.02 178.99,28.02 179.22,28.25 180.49,28.25 180.67,28.43 181.35,28.43 182.32,29.4
  BOTTOM w0.102: 184.26,31 182.66,29.4 182.32,29.4
  BOTTOM w0.114: 184.26,31 185.51,32.25 v3(185.66,32.25) 186.22,32.25 188.39,34.42 188.99,34.42 189.24,34.67 RH147.2
AUD_AZA_CPU_SDI_R: length 114.8
  TOP w0.114: v2(142.05,99.02) 140.29,99.02 136.07,94.8 135.33,94.8 RH145.2
  IN4 w0.094: v2(191.99,37.76) 192.26,38.02 192.26,46.75 192.26,47.27 172.98,66.54 172.98,68.32 172.98,71.02 169.82,74.19 168.98,74.19 167.5,75.67 166.09,75.67 165.05,76.71 159.75,76.71 155.74,80.71 155.74,81.53 154.06,83.22 154.06,87.35 142.39,99.02 v2(142.05,99.02)
  BOTTOM w0.076: UH2.AN2 178.56,27.87 178.57,27.85 179.06,27.85 179.29,28.08 180.56,28.08 180.74,28.26 181.42,28.26 182.31,29.15 182.59,29.15
  BOTTOM w0.102: 182.59,29.15 182.71,29.15 184.2,30.64
  BOTTOM w0.114: 184.2,30.64 185.46,31.89 186.17,31.89 188.48,34.2 189.27,34.2 189.79,34.73 189.79,36.61 190.35,37.17 v4(190.99,37.17) 191.41,37.17 v2(191.99,37.76)
AUD_AZA_CPU_SDO: length 135.8
  IN1 w0.094: v2(193.02,49.24) 190.79,51.48 180.66,51.48 175.41,56.72 175.41,57.44 173.25,59.6 171.45,59.6 169.33,61.72 169.33,67.33 168.81,67.86 168.81,69.92 168.55,70.17 166.9,70.17 166.51,70.56 166.51,71.22 166.21,71.52 160.69,71.52 160.59,71.41 158.03,71.41 157.85,71.6 148.37,71.6 147.76,72.2 147.76,74.74 146.52,75.98 146.52,80.61 147.33,81.42 147.33,82.68 146.83,83.18 145.9,83.18 144.34,84.75 144.34,99.16 144.83,99.65 144.83,100.32 144.56,100.59 141.94,100.59 136.09,94.73 134.35,94.73 132.09,92.47 132.09,90.67 131.7,90.27 126.74,90.27 126.38,90.64 124.92,90.64 124.47,91.09 124.47,91.38 v2(124.01,91.84)
  BOTTOM w0.076: UH1.G25 124.01,91.73 v2(124.01,91.84)
  BOTTOM w0.114: v2(193.02,49.24) 193.93,48.34 v4(193.93,46.13) 193.93,43.22 193.93,41.76 193.8,41.63 193.8,39.93 192.61,38.74 192.38,38.74 191.23,37.59 190.3,37.59 189.69,36.98 189.08,36.98 188.35,36.25 RH146.1
AUD_AZA_CPU_SDO_R: length 12.4
  BOTTOM w0.076: UH2.AM1 178.81,28.3 178.93,28.41 180.42,28.41 180.6,28.59 181.26,28.59 181.78,29.12
  BOTTOM w0.102: 181.78,29.12 181.78,29.13 182.46,29.81 182.61,29.81 184.26,31.46
  BOTTOM w0.114: 184.26,31.46 v3(186.54,33.74) 187.77,34.97 RH146.2
AUD_HP1_JACK_L: length 17.8
  TOP w0.203: v2(286.52,25.4) 286.15,25.4 286.01,25.26 284.88,25.26 284.79,25.36 HDA1.32
  IN3 w1.016: 287.49,24.37 287.49,19.93 290.54,16.88 290.92,16.88 292.03,15.76 292.03,15.17 293.16,14.04 295.13,14.04
  BOTTOM w0.114: v2(287.16,25.39) v3(287.83,25.39)
  vias: v2(295.44,12.87) v2(295.84,13.3)
AUD_HP1_JACK_L1: length 1.2
  TOP w0.114: LA20.1 v3(298.51,15.1)
AUD_HP1_JACK_R: length 16.4
  TOP w0.203: HDA1.33 284.8,25.76 284.88,25.67 285.66,25.67 v2(286.39,26.41)
  IN3 w1.016: 288.41,26.27 289.54,25.14 289.54,21.55 292.06,19.04 292.47,19.04 294.75,16.75 294.75,15.79
  BOTTOM w0.114: v2(287.03,26.41) v3(287.03,27.09)
  vias: v2(293.25,15.48)
AUD_HP1_JACK_R1: length 0.6
  TOP w0.114: 291.28,17.1 v3(290.69,17.1)
AUD_PC_BEEP: length 1
  TOP w0.254: CA29.2 279.83,18.8 RA19.2
AUD_PC_BEEP_C: length 9.4
  TOP w0.254: RA30.1 279.61,15.59 v2(278.98,14.95)
  BOTTOM w0.254: D1.1 274.71,19.9 274.71,17.64 v3(276.06,16.29) 277.4,14.95 v2(278.98,14.95)
AUD_PORTA_L_R_B: length 14.8
  TOP w0.102: CA41.1 296.48,18.66 v4(296.57,18.75)
  BOTTOM w1.016: JHP1.1 300.05,18.91 298.46,18.91 297.47,17.92 297.47,15.76 295.95,14.24 DA5.3 294.98,15.69 295.84,16.55 v2(295.84,17.41)
AUD_PORTA_R_R_B: length 13.7
  TOP w1.016: JHP1.2 305.84,19.34 304.49,20.69 294.6,20.69 294.15,20.25
  vias: v2(293.28,20.54) v2(293.3,19.95) v3(292.48,20.36)
AUD_SENSE: length 14.4
  TOP w0.254: v2(279.12,18.6) 278.79,18.27 RA22.2
  BOTTOM w0.254: v2(279.12,18.6) 279.31,18.41 v4(280.45,18.41) 282.31,18.41 282.71,18.81 287.89,18.81 290,16.7 RA56.2
AUD_SENSE_A: length 4.8
  TOP w0.203: HDA1.13 279.11,21.02 278.47,20.37 CA24.1 278.47,19.19 RA22.1
  TOP w0.254: RA24.2 277.68,18.41 RA22.1
AUD_SPK_L+: length 11.6
  IN4 w1.016: 280.98,27.65 280.4,27.07 280.4,24.45 279.66,23.71 278.62,23.71 275.6,20.69 275.6,18.91
  vias: v2(275.6,17.52) v2(276.23,17.52) v2(281.52,30.17) v2(281.52,29.59) v3(281.48,29.03)
AUD_SPK_L+_C: length 29.5
  IN4 w1.016: 301.89,5.78 298.49,5.78 288.31,15.97 283.93,15.97 283.47,15.51 280.65,15.51 280.2,15.97 278.65,15.97 278.04,15.36 277.95,15.36 277.82,15.23 277.82,15.19 277.5,14.87
  vias: v2(276.62,14.09) v2(276.62,13.5) v2(302.42,4.6) v2(302.42,4.02) v3(274.47,15.69)
AUD_SPK_L-: length 19.2
  TOP w0.203: HDA1.43 281.11,28.31 280.93,28.49 280.93,29.12 280.76,29.29 280.76,29.58 v2(280.78,29.61)
  IN4 w1.016: 276.28,16.47 275.19,16.47 274.33,17.34 274.33,21.66 275.55,22.88 275.55,25.49 278.58,28.52 279.81,28.52
  BOTTOM w0.127: v2(280.78,29.61) v3(280.78,28.88)
  vias: v2(277,17.52) v2(277.63,17.52) v2(280.78,30.22)
AUD_SPK_L-_C: length 28.9
  IN4 w1.016: 279.77,13.58 283.35,13.58 284.46,14.7 287.58,14.7 299.69,2.58 302.47,2.58 302.94,3.05
  vias: v2(278.77,14.21) v2(278.77,13.58) v2(303.41,4.6) v2(303.41,4.02) v3(279.18,13.91)
AUD_SPK_R+: length 16.4
  TOP w0.203: HDA1.45 280.31,28.52 v3(279.94,28.9) 279.59,29.25 v2(279.59,29.53) 279.56,29.56 v2(279.56,30.14)
  IN1 w1.016: 278.42,29.07 277.63,29.07 275.83,27.27 275.83,23.71 273.42,21.3 272.65,21.3 271.03,19.68 271.03,19.27
  vias: v2(271.01,17.78) v2(271.42,17.34)
AUD_SPK_R+_C: length 33.5
  IN1 w1.016: 271.97,11.8 273.24,10.53 280.25,10.53 284.44,14.72 287.66,14.72 298.03,4.36 298.94,4.36
  vias: v2(271.82,13.35) v2(271.84,13.96) v2(299.84,4.59) v2(300.3,4.17) v3(269.44,15.67)
AUD_SPK_R-: length 15.5
  TOP w0.203: HDA1.44 280.71,28.18 280.63,28.27 280.63,28.76 280.17,29.22 v2(280.17,29.58) v2(280.17,30.22)
  IN1 w1.016: 279.54,27.87 279.14,27.87 278.27,26.99 278.27,23.36 274.2,19.29 272.9,19.29 272.53,18.93
  vias: v2(272.42,18.15) v2(272.42,17.52) v3(272.02,17.82)
AUD_SPK_R-_C: length 31.7
  IN1 w1.016: 300.26,5.91 298.38,5.91 288.3,15.99 283.78,15.99 279.66,11.88 274.43,11.88
  vias: v2(273.75,13.81) v2(273.75,13.2) v2(301.42,4.6) v2(301.42,4.02) v3(274.29,17.43)
B+: length 73.3
  IN1 w0.508: v2(138.85,133.29) 138.9,133.34 188.38,133.34 189.32,132.4 189.32,127.17 192.41,124.07 195.49,124.07 195.89,124.48 204.63,124.48 204.91,124.2
  vias: v2(29.22,29.96) v2(29.22,29.33) v2(29.22,28.69) v2(29.85,29.96) v2(29.85,29.33) v2(29.85,28.69) v2(30.49,29.96) v2(30.49,29.33) v2(30.49,28.69) v2(31.12,29.96) v2(31.12,29.33) v2(31.12,28.69) v2(31.76,29.33) v2(31.76,28.69) v2(41.41,27.42) v2(41.41,26.79) v2(41.41,26.15) v2(41.41,25.52) v2(41.41,24.88) v2(41.92,24.25) v2(42.05,27.42) v2(42.05,26.79) v2(42.05,26.15) v2(42.05,25.52) v2(42.05,24.88) v2(42.55,24.25) v2(42.68,27.42) v2(42.68,26.79) v2(42.68,26.15) v2(42.68,25.52) v2(42.68,24.88) v2(43.19,24.25) v2(43.19,23.61) v2(43.57,22.98) v2(43.57,22.34) v2(43.57,21.71) v2(43.57,21.07) v2(43.57,20.44) v2(43.82,24.25) v2(43.82,23.61) v2(64.45,22.34) v2(64.91,123.05) v2(64.91,122.42) v2(64.91,121.78) v2(64.91,121.15) v2(64.99,22.98) v2(65.19,23.54) v2(65.54,123.05) v2(65.54,122.42) v2(65.54,121.78) v2(65.62,121.15) v2(66.18,123.05) v2(66.18,122.42) v2(66.18,121.78) v2(66.81,123.05) v2(66.81,122.42) v2(67.45,123.05) v2(67.45,122.42) v2(68.01,20.84) v2(68.08,123.05) v2(68.08,21.44) v2(68.64,21.07) v2(71.98,76.19) v2(72.49,76.49) v2(72.51,75.76) v2(72.55,73.93) v2(72.78,74.54) v2(73.12,76.49) v2(73.15,75.73) v2(73.16,73.95) v2(73.54,74.54) v2(73.75,73.95) v2(74.3,77.08) v2(74.3,76.44) v2(74.3,75.81) v2(74.3,75.17) v2(74.33,74.59) v2(74.33,73.95) v2(74.94,77.08) v2(74.94,76.44) v2(74.94,75.81) v2(74.94,75.17) v2(74.94,74.54) v2(75.57,77.08) v2(75.57,76.44) v2(75.57,75.81) v2(82.3,11.45) v2(82.56,12.06) v2(82.56,10.79) v2(82.94,11.42) v2(83.19,12.06) v2(83.19,10.79) v2(83.58,11.42) v2(83.83,12.06) v2(83.83,10.79) v2(84.21,11.42) v2(94.4,8.5) v2(94.35,6.72) v2(95.06,8.45) v2(95.08,6.7) v2(114.97,133.47) v2(115.3,132.93) v2(115.55,133.47) v2(115.88,132.93) v2(116.14,133.47) v2(116.47,132.93) v2(116.72,133.47) v2(118.48,133.47) v2(118.48,132.73) v2(119.29,133.47) v2(119.29,132.73) v2(121,133.37) v2(121,132.78) v2(121.59,132.87) v2(121.68,133.47) v2(122.31,133.47) v2(135.09,133.29) v2(135.82,133.29) v2(136.46,133.29) v2(137.04,133.29) v2(137.53,119.85) v2(137.53,119.22) v2(137.63,133.29) v2(137.55,118.61) v2(137.58,118.02) v2(138.11,119.85) v2(138.11,119.27) v2(138.14,118.66) v2(138.21,133.29) v2(138.19,118.02) v2(140.19,14.37) v2(140.18,13.76) v2(140.18,13.17) v2(140.5,14.87) v2(140.79,14.37) v2(140.78,13.76) v2(140.78,13.17) v2(141.42,14.64) v2(141.42,14.05) v2(142.01,14.65) v2(142.01,14.07) v2(142.59,14.65) v2(142.59,14.07) v2(143.18,14.65) v2(143.18,14.07) v2(143.76,14.65) v2(143.76,14.07) v2(144.37,14.46) v2(144.37,13.87) v2(144.37,13.29) v2(149.06,40.29) v2(149.36,39.73) v2(149.68,40.3) v2(149.67,39.23) v2(150,39.73) v2(150.31,40.24) v2(150.31,39.17) v2(150.63,39.73) v2(150.95,40.24) v2(150.95,39.17) v2(151.33,39.61) v2(151.71,39.17) v2(152.09,39.61) v2(152.54,39.23) v2(152.98,39.61) v2(153.43,39.23) v2(153.93,39.55) v2(154.44,39.87) v2(154.44,39.23) v2(155.08,39.87) v2(155.08,39.23) v2(197.9,58.16) v2(198.51,58.79) v2(198.51,58.16) v2(198.51,57.57) v2(199.1,58.16) v2(199.1,57.57) v2(201.05,58.16) v2(201.11,57.56) v2(205.19,123.46) v2(205.5,123.97) v2(205.83,123.46) v2(207.65,58.13) v2(208.29,58.11) v2(218.67,49.77) v2(218.67,49.14) v2(219.2,50.08) v2(219.2,49.42) v2(219.81,50.05) v2(220.41,50.05) v2(233.44,44.57) v2(233.82,45.08) v2(234.22,44.64) v2(234.68,45.1) v2(235.06,44.64) v2(235.44,45.13) v2(253.3,23.1) v2(253.88,23.1) v2(254.47,23.13) v2(255.08,23.1) v2(255.69,23.13) v2(256.27,23.13) v4(31.4,22.9)
B++:
  vias: v4(47.6,18.34)
B+_AMP:
  vias: v2(261.15,31.28) v2(261.78,31.26) v2(262.26,30.75) v2(263.56,30.83) v2(267.52,20.23) v2(267.57,21.4) v2(267.55,20.82) v3(262.44,29.7)
B+_CAM: length 29.1
  TOP w0.127: v4(228.56,44.48) 228.14,44.9 v2(228.13,44.9)
  IN4 w1.016: 210.88,57.62 215.61,57.62 217.59,55.64 217.59,48.97 218.45,48.11 220.98,48.11 222.23,46.85 223.76,46.85 225.36,48.45 227.29,48.45 228.58,47.16 228.58,46.19 228.38,45.99
  vias: v2(210.14,58.12) v2(210.75,58.11) v2(228.74,45.05)
BAT1_LED#: length 50.2
  TOP w0.114: QE20.5 252.47,27.25 252.82,27.6 253.45,27.6 253.76,27.9 253.76,29.48 253.26,29.97 249.78,29.97 v3(249.6,30.15) 249.41,30.34 v2(249.41,33.09) ; UE1.1 218.17,30.14 217.76,29.73 RE39.1 218.09,29.33 v2(218.37,29.61)
  IN3 w0.127: v2(249.41,33.09) 249.41,32.65 248.96,32.2 245.37,32.2 243.1,29.92 234.01,29.92 234.01,29.92 230.43,29.92 229.83,29.33 221.13,29.33 219.57,27.76 218.5,27.76 217.95,28.32 217.95,28.98 218.37,29.4 v2(218.37,29.61)
BAT2_LED#: length 33.3
  TOP w0.114: v2(234.02,21.71) 233.91,21.82 233.91,22.2 233.07,23.04 233.07,23.91 233.07,24.43 232.38,25.12 232.38,28.67 232.67,28.97 232.67,29.38 232.23,29.82 230.88,29.82 230.53,30.17 230.53,30.51 230.65,30.63 UE1.106 230.65,32.72 230.51,32.86 v3(230.51,33.47) 230.51,34.45 RE113.1 ; v2(248.04,26.36) 247.8,26.59 QE23.2
  IN3 w0.127: v2(234.02,21.71) 234.46,21.71 235.94,20.22 238.97,20.22 239.57,20.82 240.95,20.82 244.61,24.48 246.16,24.48 v2(248.04,26.36)
BATDRV_CHG: length 25.8
  TOP w0.114: v2(34.43,37.46) 34.43,37.86 v3(34.62,38.05)
  IN1 w0.635: v2(39.63,15.48) v2(40.4,15.48) 40.4,16.75 38.62,18.53 38.62,23.46 33.28,28.79 33.28,36.95
  vias: v2(33.79,37.46)
BATSRC_CHG: length 28.1
  TOP w0.114: v3(33.75,39.03) 33.41,38.69 v2(33.41,38.34)
  IN4 w0.635: v2(34.12,38.34) v2(33.41,38.34) 33.26,38.34 32.62,37.71 32.62,32.73 33.41,31.94 33.41,27.24 38.62,22.04 v2(38.62,15.48) v2(37.86,15.48)
BATT++: length 3.5
  TOP w0.102: v2(46.86,16.49) v4(46.86,15.42) ; v2(46.86,16.49) v4(46.86,17.47) ; v2(46.86,16.49) v4(48.33,16.49)
BATT_PRS#: length 16.7
  TOP w0.114: v2(27.59,14.51) 27.59,14.57 v3(28.19,15.17)
  BOTTOM w0.114: JBAT10.6 37.69,13.82 36.31,15.2 28.29,15.2 v2(27.59,14.51) 26.41,13.33 PR111.1
BBS_BIT0: length 3.4
  TOP w0.114: v3(163.24,28.9) 163.28,28.9 164.15,28.03 RH130.2 164.35,27.86 164.35,26.96 v2(164.42,26.89)
  BOTTOM w0.102: UH2.AT29 165.05,26.27 v2(164.42,26.89)
BEEP: length 59.1
  TOP w0.114: v2(226.65,14.54) UE1.45
  IN1 w0.094: v2(269.68,25.24) 269.1,24.65 267.85,24.65 267.42,25.08 263.51,25.08 263.15,24.73 257.71,24.73 256.52,23.53 249.04,23.53 248.31,22.8 247.98,22.8 247.81,22.97 246.16,22.97 245.55,22.36 245.55,19.78 243.8,18.02 235.98,18.02 233.31,15.36 227.46,15.36 v2(226.65,14.54)
  BOTTOM w0.114: v2(269.68,25.24) 269.68,25.02 v3(270.15,24.56) 270.27,24.43 270.27,23.07 270.82,22.52 270.9,22.44 270.94,22.4 271.73,22.4 272.17,21.96 272.17,19.78 272.48,19.47 D1.2
BIA_PWM_PCH: length 103.9
  TOP w0.114: RH20.2 161.05,35.04 v2(160.92,35.04) v3(160.92,34.5) ; DV2.2 67.3,30.18 v2(67.7,29.78)
  IN3 w0.127: v2(160.92,35.04) 160.02,35.94 158.76,35.94 157.38,37.33 156.32,37.33 154.58,35.59 154.58,33.11 152.59,31.12 147.25,31.12 146.09,29.95 142.62,29.95 140.99,28.32 109.6,28.32 108.88,29.05 73.51,29.05 72.2,30.37 68.29,30.37 v2(67.7,29.78)
  BOTTOM w0.089: UH2.W36 161.35,34.61 v2(160.92,35.04)
BOARD_ID: length 5.7
  TOP w0.114: v2(228.56,30.34) 228.65,30.44 UE1.111 228.65,33.05 v3(228.93,33.33)
  BOTTOM w0.114: v2(228.56,30.34) 228.56,29.9 CE98.1 RE14.2 RE13.2
BOARD_ID_14_15: length 9
  TOP w0.114: v2(161.65,28.22) v3(161.23,27.8) 160.05,27.8 159.92,27.93 159.3,27.93 159.12,27.75 156.6,27.75 156.07,28.29 156.07,28.9 RH495.1 155.64,28.82 RH494.2
  BOTTOM w0.102: UH2.AL35 v2(161.65,28.22)
BREATH_LED: length 123.7
  TOP w0.114: JPW.2 202.09,33.32 201.44,32.67 LED4.1 200.69,31.99 v3(200.38,31.68) 200.14,31.44 v2(200.14,31.23)
  IN3 w0.127: v2(287.03,63.49) 287.03,60.62 284.82,58.41 283.99,58.41 273.83,48.25 272.42,48.25 271.69,47.51 270.8,47.51 266.99,43.7 262.04,43.7 261.95,43.61 261.95,42.19 261.67,41.91 258.03,41.91 251.74,35.62 246.16,35.62 242.84,32.3 236.27,32.3 233.65,34.93 233.14,34.93 231.46,36.6 228.03,36.6 227.71,36.28 227.71,35.38 225.51,33.18 225.51,32.84 224.43,31.77 219.93,31.77 219.56,31.77 219.55,31.76 217.21,31.76 217.07,31.63 215.86,30.41 215.86,28.98 213.85,26.96 212.41,26.96 211.69,26.24 205.56,26.24 205.19,25.87 202.59,25.87 200.14,28.32 v2(200.14,31.23)
  BOTTOM w0.114: QE24.3 286.92,59.06 287.54,59.68 287.54,62.08 LED3.1 287.03,62.84 v2(287.03,63.49)
BREATH_LED#_EC: length 80.1
  TOP w0.114: UE1.70 237,19.74 v2(237.68,19.07)
  IN3 w0.127: v2(237.68,19.07) 238.25,19.07 239.77,20.59 241.13,20.59 244.74,24.2 246.76,24.2 249.58,27.02 257.02,27.02 257.95,27.94 257.95,30.9 261.86,34.81 263.31,34.81 264.12,35.63 264.12,38.5 265.34,39.72 274.13,39.72 276.13,41.72 276.13,47.84 284.96,56.67 287.73,56.67 v2(288.35,56.05)
  BOTTOM w0.114: v2(288.35,56.05) v4(288.35,56.71) 286.27,58.79 QE24.2 ; v2(237.68,19.07) 237.7,19.04 RE119.1
BST1_3V: length 2.7
  BOTTOM w0.114: PR412.1 50.52,16.82 v3(50.25,17.08)
  BOTTOM w0.508: PC411.2 52.09,16.82 PR412.1
BST1_5V: length 1
  BOTTOM w0.114: 51.31,26.28 v3(51.31,27.26)
BST1_NVVDDS:
  vias: v3(202.44,54.87)
BST2_NVVDD: length 2.8
  BOTTOM w0.114: PR1616.1 174.19,51.22 v3(174.19,49.43)
BST_1VALWP_R: length 1
  BOTTOM w0.114: PC605.1 247.79,19.08 v3(246.94,19.08)
BST_3V:
  vias: v2(51.78,18.95)
BST_5V: length 3.7
  BOTTOM w0.127: PR413.1 50.05,24.82 v3(49.49,24.26)
  BOTTOM w0.203: PU400.17 51.87,23.67 50.72,24.82 PR413.1
BST_+0.95VSP: length 2.2
  TOP w0.114: PR701.1 69.15,70.44 69.76,71.05 v3(71.03,71.05)
BST_+0.95VSP_R: length 1
  TOP w0.114: PC701.1 71.49,70.22 v3(71.79,69.92)
BST_+1.0VSP: length 1.7
  TOP w0.114: v2(221.87,45.98) 221.62,46.22 220.69,46.22 v4(220.38,45.91)
BST_+1.8VSP: length 1
  TOP w0.114: v2(205.84,120.69) 205.32,121.21 v4(205.04,121.21)
BST_+1.8VSP_R: length 2.7
  BOTTOM w0.114: v3(204.42,124.09) 204.42,123.38 205.19,122.61 PC1001.1
BT_RADIO_DIS#: length 44.1
  IN4 w0.094: v2(159.5,25.41) 159.6,25.52 161.64,25.52 165.6,29.47 170.85,29.47 171.1,29.72 172.71,29.72 172.76,29.68 173.81,29.68 173.99,29.85 179.92,29.85 180.39,30.32 180.39,30.75 180.56,30.93 182.22,30.93 183.36,32.07 186.39,32.07 188.37,34.05 192.6,34.05 v2(192.87,33.77)
  BOTTOM w0.102: UH2.AV43 v2(159.5,25.41)
  BOTTOM w0.114: v2(192.87,33.77) 193.56,34.46 v3(193.56,35.42) 194.95,36.82 195.84,36.82 196.22,36.44 DN2.1
