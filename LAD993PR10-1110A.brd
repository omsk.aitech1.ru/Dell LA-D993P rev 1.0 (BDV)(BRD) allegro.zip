# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_PTX_SSDRX_N10_C: length 12.5
  BOTTOM w0.114: CD45.2 201.38,34.92 201.38,34.42 201.28,34.32 200.95,34.32 200.85,34.22 200.85,34.06 200.99,33.92 201.68,33.92 203.43,32.17 204.27,32.17 205.72,30.71 205.72,29.98 205.74,29.97 205.74,29.43 205.72,29.41 205.72,29.23 206.3,28.65 v1(206.5,28.45) 206.77,28.18 207.73,28.18 207.88,28.33 JNGFF2.35
PCIE_PTX_SSDRX_N11: length 55.8
  IN1 w0.094: v2(161.86,44.08) 161.78,44.16 161.35,44.16 161.17,44.34 161.17,46.21 162.55,47.59 167.21,47.59 167.51,47.89 170.13,47.89 171.39,49.16 178.03,49.16 179.08,50.21 190.46,50.21 192.53,48.13 193.27,48.13 200.32,41.08 200.32,40.44 v2(200.54,40.22)
  BOTTOM w0.076: UH2.C33 162.84,42.85 162.51,43.18 162.51,43.7 162.13,44.08 v2(161.86,44.08)
  BOTTOM w0.114: CD43.1 202.8,36.32 202.8,37.16 200.26,39.7 200.26,39.94 v2(200.54,40.22)
PCIE_PTX_SSDRX_N11_C: length 8.5
  BOTTOM w0.114: JNGFF2.23 207.81,31.33 207.69,31.2 207.69,31.1 207.64,31.05 206.88,31.05 206.86,31.07 206.28,31.07 204.41,32.94 203.79,32.94 203.77,32.96 v1(203.32,33.41) 202.7,34.03 202.7,34.48 CD43.2
PCIE_PTX_SSDRX_N12: length 59.6
  IN1 w0.094: v2(160.74,43.87) 160.68,43.93 160.21,43.93 160.01,44.13 160.01,45.87 162.31,48.17 166.96,48.17 167.27,48.48 169.85,48.48 171.11,49.74 177.79,49.74 178.84,50.79 190.76,50.79 192.84,48.72 193.53,48.72 200.75,41.49 201.9,41.49 202.58,40.82 202.58,40.49 v2(202.8,40.26)
  BOTTOM w0.076: v2(160.74,43.87) 160.95,44.09 161.07,44.09 161.84,43.31 162.02,43.31 UH2.B35
  BOTTOM w0.114: CD37.1 204.86,36.17 204.86,36.6 202.47,38.99 202.47,40.04 202.69,40.26 v2(202.8,40.26)
PCIE_PTX_SSDRX_N12_C: length 5.1
  BOTTOM w0.114: JNGFF2.11 207.86,34.33 207.65,34.12 v1(206.61,34.12) 205.63,34.12 205.61,34.14 205.07,34.14 205.06,34.12 204.96,34.12 204.68,34.4 204.68,34.92 204.77,35 CD37.2
PCIE_PTX_SSDRX_P10: length 52.1
  IN1 w0.094: v2(162.75,45) 162.53,45 162.45,45.08 162.45,46.27 163,46.82 167.53,46.82 167.78,47.07 170.4,47.07 171.71,48.39 178.35,48.39 179.4,49.44 190.13,49.44 198.71,40.86 198.71,40.62 198.48,40.39 198.48,39.88 198.39,39.78 198.19,39.78 198.07,39.9 v2(198.07,40.06)
  BOTTOM w0.076: v2(162.75,45) 162.75,44.96 163.1,44.61 163.1,43.58 163.29,43.4 163.29,43.1 UH2.B32
  BOTTOM w0.114: CD46.1 200.75,36.25 200.75,37.49 198.18,40.06 198.08,40.06 v2(198.07,40.06)
PCIE_PTX_SSDRX_P10_C: length 12.5
  BOTTOM w0.114: JNGFF2.37 207.85,27.83 207.72,27.95 206.68,27.95 206.54,28.09 206.52,28.09 206.14,28.47 206.14,28.5 205.5,29.13 v1(205.5,29.7) 205.5,30.62 204.18,31.94 203.34,31.94 201.58,33.7 200.89,33.7 200.63,33.97 200.63,34.79 CD46.2
PCIE_PTX_SSDRX_P11: length 55.8
  IN1 w0.094: v2(199.69,40.27) 199.69,40.1 199.87,39.92 200.01,39.92 200.14,40.05 200.14,41 193.19,47.95 192.46,47.95 190.38,50.02 179.16,50.02 178.11,48.97 171.47,48.97 170.2,47.71 167.59,47.71 167.28,47.4 162.63,47.4 161.35,46.13 161.35,44.42 161.43,44.35 161.54,44.35 v2(161.86,44.67)
  BOTTOM w0.076: UH2.B33 162.77,43.2 162.68,43.29 162.68,43.77 161.86,44.59 v2(161.86,44.67)
  BOTTOM w0.114: v2(199.69,40.27) 200.03,39.93 200.03,39.61 200.27,39.37 202.57,37.06 202.57,36.17 CD44.1
PCIE_PTX_SSDRX_P11_C: length 8.6
  BOTTOM w0.114: CD44.2 202.47,34.85 202.47,33.94 202.96,33.45 202.96,33.43 203.32,33.06 203.33,33.06 203.68,32.72 204.32,32.72 206.21,30.83 v1(206.59,30.83) JNGFF2.25
PCIE_PTX_SSDRX_P12: length 59.6
  IN1 w0.094: v2(160.77,44.47) 160.41,44.12 160.28,44.12 160.19,44.21 160.19,45.8 162.38,47.99 167.04,47.99 167.35,48.29 169.93,48.29 171.19,49.55 177.87,49.55 178.92,50.6 190.69,50.6 192.76,48.53 193.46,48.53 200.68,41.31 201.83,41.31 202.39,40.74 202.39,40.15 202.25,40.01 202.07,40.01 201.93,40.15 v2(201.93,40.28)
  BOTTOM w0.076: UH2.A35 162.09,43.47 161.91,43.47 161.13,44.25 160.91,44.25 160.77,44.39 v2(160.77,44.47)
  BOTTOM w0.114: CD42.1 204.64,36.32 204.64,36.51 202.25,38.9 202.25,39.96 v2(201.93,40.28)
PCIE_PTX_SSDRX_P12_C: length 5.2
  BOTTOM w0.114: JNGFF2.13 207.81,33.83 207.73,33.9 206.9,33.9 206.88,33.88 206.34,33.88 206.33,33.9 v1(205.34,33.9) 204.87,33.9 204.46,34.31 204.46,34.76 CD42.2
PCIE_PTX_WLANRX_N6: length 43
  IN1 w0.094: v2(195.14,40.7) 194.93,40.9 194.91,40.9 194.76,40.9 194.24,41.43 194.24,41.58 194.24,43.52 189.51,48.26 179.92,48.26 178.88,47.22 172.21,47.22 170.9,45.91 169.74,45.91 169,45.17 169,44.9 168.41,44.31 v2(168.41,44.29)
  BOTTOM w0.076: UH2.B22 168.26,43.23 168.21,43.29 168.21,43.47 168.26,43.53 168.26,43.73 168.17,43.82 168.17,44.16 168.3,44.29 v2(168.41,44.29)
  BOTTOM w0.114: CN20.1 192.22,35.88 191.88,36.22 191.88,36.35 191.98,36.45 192.55,36.45 192.86,36.14 193.54,36.14 194.6,37.2 194.6,41.05 194.71,41.17 194.8,41.17 195.14,40.83 v2(195.14,40.7)
PCIE_PTX_WLANRX_P6: length 43
  IN1 w0.094: v2(195.13,41.42) 195.13,41.23 195,41.09 194.84,41.09 194.42,41.5 194.42,43.6 189.58,48.44 179.84,48.44 178.8,47.4 172.14,47.4 170.82,46.09 169.67,46.09 168.82,45.24 168.82,44.98 168.73,44.9 v2(168.41,44.9)
  BOTTOM w0.076: v2(168.41,44.9) 168.41,44.8 168.01,44.39 UH2.A23
  BOTTOM w0.114: v2(195.13,41.42) 195.1,41.39 194.62,41.39 194.38,41.14 194.38,37.29 193.45,36.37 192.95,36.37 192.65,36.67 191.89,36.67 191.65,36.44 191.65,36.13 CN21.1
PCIE_PTX_WLANRX_RE_N6: length 20.2
  BOTTOM w0.114: CN20.2 192,34.68 192,34.19 191.72,33.9 190.38,33.9 189.8,33.33 189.8,33.3 189.42,32.92 189.39,32.92 188.61,32.14 188.45,32.14 v1(188.13,31.81) 186.76,30.45 186.76,27.71 188.74,25.73 190.82,25.73 193.16,23.39 193.16,22.95 193.31,22.8 JNGFF1.29
PCIE_PTX_WLANRX_RE_P6: length 20.2
  BOTTOM w0.114: CN21.2 191.78,34.58 191.78,34.28 191.62,34.13 190.29,34.13 v1(189.44,33.28) 188.52,32.36 188.36,32.36 188.17,32.17 188.15,32.17 187.77,31.79 187.77,31.77 186.54,30.54 186.54,27.62 188.65,25.51 190.73,25.51 192.94,23.3 192.94,22.93 192.81,22.8 JNGFF1.27
PCIE_RCOMPN: length 3.9
  BOTTOM w0.089: UH2.B18 170.66,43.37 170.72,43.43 170.72,44.64 170.82,44.74
  BOTTOM w0.127: RH108.1 171,46.75 v3(171.19,46.94)
  BOTTOM w0.305: RH108.1 171,45.55 170.82,45.38 170.82,44.74
PCIE_RCOMPP: length 4.7
  BOTTOM w0.089: 170.37,44.69 170.54,44.52 170.54,43.51 170.43,43.4 170.43,43.08 170.76,42.75 UH2.C17
  BOTTOM w0.127: RH108.2 170.08,46.67 v3(169.78,46.97)
  BOTTOM w0.305: RH108.2 170.08,45.53 170.37,45.24 170.37,44.69
PCIE_WAKE#: length 148.9
  TOP w0.114: UE1.4 218.22,28.94 218.14,28.86 215.61,28.86 v4(214.13,27.38) 213.29,26.54 213.29,26 212.61,25.31 212.61,22.45 213.02,22.04 v2(214.09,22.04)
  IN4 w0.094: v2(174.74,12.59) 175.16,12.16 175.56,12.16 175.78,12.39 175.78,12.84 176.32,13.39 179.2,13.39 183.37,17.57 188.08,17.57 188.9,16.75 193.71,16.75 v2(197.49,20.53) 198.2,20.53 200.01,22.34 213.79,22.34 v2(214.09,22.04) 214.23,21.9 216.85,21.9 217.53,21.21 219.41,21.21 219.96,20.66 220.92,20.66 221.37,20.21 225.09,20.21 225.48,19.82 227.59,19.82 229.15,21.39 232.2,21.39 233.04,22.23 236.61,22.23 236.81,22.43 237.77,22.43 238.09,22.76 243.25,22.76 244.08,23.59 244.26,23.59 245.2,24.52 253.96,24.52 255.41,25.96 256.15,26.71 265.79,26.71 267.9,24.61 271.62,24.61 272.91,25.9 273.75,25.9 274.99,27.13 274.99,32.6 275.91,33.52 277.29,33.52 279.12,35.35 280.22,35.35 281.75,36.87 284.48,36.87 284.77,37.16 284.77,38.17 v2(284.46,38.47)
  BOTTOM w0.114: RH114.2 174.71,12.61 v2(174.74,12.59) ; v2(284.46,38.47) 285.62,38.47 286.14,38.99 RL2.1 ; JNGFF1.47 197.81,20.85 v2(197.49,20.53)
PECI: length 11.1
  BOTTOM w0.076: 181.62,30.36 181.62,30.32 180.3,28.99 178.67,28.99 178.57,29.09 178.24,29.09 178.01,28.86 UH2.AL3
  BOTTOM w0.102: 182.97,32.03 182.97,31.7 181.62,30.36
  BOTTOM w0.114: RH138.1 185.23,34.51 184.6,34.51 183.86,33.77 183.86,33.74 183.79,33.67 183.79,32.85 v3(183.42,32.48) 182.97,32.03
PECI_EC: length 226.9
  TOP w0.114: RE17.2 239.35,30.88 238.87,31.36 DE8.1 238.4,31.92 238.27,32.05 v2(238.27,33.02)
  IN3 w0.127: v2(189.34,38.39) 191.88,35.85 206.65,35.85 208.99,33.52 216.01,33.52 217.53,35.03 224.91,35.03 225.56,35.68 225.56,36.65 226.96,38.05 228.15,38.05 228.48,38.38 233.83,38.38 238.27,33.94 v2(238.27,33.02)
  IN4 w0.094: v2(79.21,96.38) 79.21,98.4 87.6,106.79 128.62,106.79 151.71,83.7 151.71,81.46 153.64,79.53 155.2,79.53 155.52,79.21 155.52,76.98 157,75.5 163.7,75.5 164.74,74.47 167,74.47 168.48,72.98 169.32,72.98 171.78,70.52 171.78,67.32 171.78,66 183.94,53.84 183.94,53.56 191.05,46.45 191.05,39.47 189.98,38.39 v2(189.34,38.39)
  BOTTOM w0.114: v2(79.21,96.38) 79.21,98.64 v4(79.5,98.93) 80,99.43 RH190.1 ; v2(189.34,38.39) 189.2,38.26 188.53,38.26 188.06,37.79 187.78,37.79 187.54,37.54 187.54,37.28 186.14,35.88 RH138.2
PECI_EC_R: length 8.3
  BOTTOM w0.102: UH1.BT34 86.34,97.43
  BOTTOM w0.114: 86.34,97.43 85.35,98.42 85.35,99.05 83.73,100.68 v4(82.38,100.68) 82.13,100.42 RH190.2
PECI_MEC1404: length 2.6
  TOP w0.114: RE17.1 237.47,29.45 v3(237.42,29.4) 237.36,29.34 UE1.94
PEG_GTX_C_HRX_N0: length 28.8
  TOP w0.102: 129.3,78.41 129.15,78.26 128.53,78.26 128.36,78.26 127.79,78.83 126.59,78.83 126.44,78.98 126.23,78.98 126.08,78.83 125.77,78.83 125.64,78.96 125.64,79.09 125.78,79.24 v2(125.93,79.24)
  TOP w0.114: 129.3,78.41 129.42,78.53 130.24,78.53 130.52,78.81 v1(132.61,78.81) 139.02,78.81 142.86,82.65 145.05,82.65 145.49,83.09 150.69,83.09 150.89,82.89 CV532.2
  BOTTOM w0.076: v2(125.93,79.24) 125.61,79.56 UH1.E10
PEG_GTX_C_HRX_N1: length 29.7
  TOP w0.102: v2(125.93,80.02) 125.97,80.02 126.61,79.39 127.98,79.39 128.36,79.01 128.53,79.01 129.1,79.01 129.27,79.18 129.3,79.18
  TOP w0.114: CV534.2 152.41,83.97 150.78,83.97 150.63,83.82 150.62,83.82 150.59,83.79 150.59,83.79 150.58,83.78 142.56,83.78 138.24,79.47 v1(134.88,79.47) 130.16,79.47 129.87,79.18 129.3,79.18
  BOTTOM w0.076: UH1.E11 125.61,80.35 v2(125.93,80.02)
PEG_GTX_C_HRX_N2: length 28.5
  TOP w0.102: v2(125.93,80.81) 125.93,80.78 126.09,80.63 127.9,80.63 128.36,80.18 129.3,80.18
  TOP w0.114: CV536.2 150.89,85.57 150.73,85.73 150.57,85.73 150.43,85.59 150.43,85.18 150.33,85.08 149.93,85.08 149.55,84.7 142.09,84.7 137.77,80.38 v1(130.59,80.38) 129.78,80.38 129.78,80.38 129.59,80.38 129.39,80.18 129.3,80.18
  BOTTOM w0.076: v2(125.93,80.81) 125.82,80.81 125.61,81.02 UH1.E12
PEG_GTX_C_HRX_N3: length 30.2
  TOP w0.102: v2(125.93,81.6) 126.07,81.46 126.07,81.4 126.07,81.23 126.39,80.91 128.2,80.91 128.52,80.59 129.09,80.59
  TOP w0.114: 129.09,80.59 129.34,80.84 137.53,80.84 142.92,86.23 v1(149.23,86.23) 151.5,86.23 151.86,85.87 CV538.2
  BOTTOM w0.076: UH1.E13 125.61,81.92 v2(125.93,81.6)
PEG_GTX_C_HRX_N4: length 30
  TOP w0.114: CV540.2 150.63,87.26 147.34,87.26 147.32,87.28 146.78,87.28 146.76,87.26 142.7,87.26 137.15,81.72 129.18,81.72 129.03,81.87 128.09,81.87 127.74,82.22 125.7,82.22 125.39,81.91 125.14,81.91 124.97,82.08 124.97,82.19 124.99,82.21 124.99,82.31 125.06,82.38 v2(125.29,82.38)
  BOTTOM w0.076: UH1.E14 125.37,82.78 125.29,82.7 v2(125.29,82.38)
PEG_GTX_C_HRX_N5: length 30.3
  TOP w0.114: v2(125.94,83.15) 126.1,82.99 126.1,82.75 126.39,82.47 128.07,82.47 128.41,82.14 136.97,82.14 142.95,88.12 v1(149.2,88.12) 150.26,88.12 150.48,87.9 CV542.2
  BOTTOM w0.076: v2(125.94,83.15) 125.61,83.48 UH1.E15
PEG_GTX_C_HRX_N6: length 28.9
  TOP w0.114: v2(125.93,83.96) 126.1,83.8 127.94,83.8 128.29,83.45 137.03,83.45 142.72,89.14 v1(146.4,89.14) 150.3,89.14 150.45,89.3 150.45,89.75 150.58,89.88 150.76,89.88 150.89,89.75 CV544.2
  BOTTOM w0.076: v2(125.93,83.96) 125.61,84.28 UH1.E16
PEG_GTX_C_HRX_N7: length 30.5
  TOP w0.114: CV546.2 152.45,90.02 151.37,90.02 151.08,90.3 149.77,90.3 149.59,90.12 v1(148.71,90.12) 143.1,90.12 137.09,84.11 129.47,84.11 129.12,83.77 128.38,83.77 128.08,84.06 126.47,84.06 126.16,84.37 126.16,84.56 125.97,84.75 v2(125.93,84.75)
  BOTTOM w0.114: UH1.E17 125.61,85.07 v2(125.93,84.75)
PEG_GTX_C_HRX_N8: length 29
  TOP w0.114: v2(125.28,85.53) 125.68,85.13 126.08,85.13 126.13,85.18 127.37,85.18 127.75,84.81 136.84,84.81 142.99,90.95 146.68,90.95 146.69,90.93 147.3,90.93 147.32,90.95 150.89,90.95 CV548.2
  BOTTOM w0.102: UH1.F18 124.96,85.86 v2(125.28,85.53)
PEG_GTX_C_HRX_N9: length 31.2
  TOP w0.114: CV551.2 152.54,92.72 152.36,92.9 152.18,92.9 152.05,92.78 152.05,92.34 151.94,92.23 151.33,92.23 151.01,92.56 v1(149.68,92.56) 143.36,92.56 136.54,85.73 133.81,85.73 133.8,85.74 133.25,85.74 133.24,85.73 129.22,85.73 129.06,85.57 128.37,85.57 128.01,85.93 126.41,85.93 126.02,86.32 v2(125.93,86.32)
  BOTTOM w0.114: v2(125.93,86.32) 126.26,86.65 UH1.D19
PEG_GTX_C_HRX_N10: length 29.2
  TOP w0.114: v2(125.28,87.11) 125.36,87.11 125.76,86.71 126.77,86.71 127.07,86.41 134.95,86.41 134.97,86.4 135.51,86.4 135.53,86.41 136.62,86.41 143.19,92.98 CV557.2
  BOTTOM w0.114: UH1.F20 124.96,87.43 v2(125.28,87.11)
PEG_GTX_C_HRX_N11: length 30.8
  TOP w0.114: v2(126.58,87.9) 126.47,87.9 126.32,87.75 126.32,87.58 126.43,87.46 128.41,87.46 128.59,87.28 129.02,87.28 129.03,87.28 129.29,87.28 136.24,87.28 143.02,94.07 148.35,94.07 148.37,94.08 148.94,94.08 148.96,94.07 149.52,94.07 150.04,94.58 151.51,94.58 151.7,94.39 152.07,94.39 152.14,94.47 152.14,94.69 152.23,94.77 152.4,94.77 CV559.2
  BOTTOM w0.076: UH1.D21 126.26,88.22 v2(126.58,87.9)
PEG_GTX_C_HRX_N12: length 29.5
  TOP w0.114: CV561.2 149.83,95.02 149.42,94.61 147.58,94.61 147.56,94.59 146.97,94.59 146.95,94.61 142.96,94.61 136.15,87.8 129.89,87.8 129.39,88.3 125.67,88.3 v2(125.28,88.68)
  BOTTOM w0.076: UH1.F22 124.96,89.01 v2(125.28,88.68)
PEG_GTX_C_HRX_N13: length 30.8
  TOP w0.114: CV563.2 152.54,96.54 152.44,96.43 152.26,96.43 152.04,96.65 150.17,96.65 149.11,95.59 142.7,95.59 136.78,89.67 134.21,89.67 134.19,89.69 133.65,89.69 133.63,89.67 129.1,89.67 129.1,89.68 128.32,89.68 128.14,89.68 127.51,89.05 126.44,89.05 126.31,89.18 126.31,89.3 126.32,89.31 126.32,89.4 126.4,89.47 v2(126.58,89.47)
  BOTTOM w0.076: v2(126.58,89.47) 126.58,89.65 126.37,89.86 UH1.D23
PEG_GTX_C_HRX_N14: length 29.5
  TOP w0.114: CV565.2 150.72,97.52 150.02,97.52 149.65,97.15 149.63,97.15 149.25,96.76 149.25,96.74 148.93,96.42 v1(146.47,96.42) 142.62,96.42 136.64,90.44 129.19,90.44 129.02,90.26 126.52,90.26 126.12,90.66 125.68,90.66 v2(125.28,90.26)
  BOTTOM w0.076: v2(125.28,90.26) 125.28,90.33 UH1.F24
PEG_GTX_C_HRX_N15: length 30.6
  TOP w0.114: CV567.2 152.34,98.5 149.95,98.5 148.66,97.22 142.46,97.22 136.62,91.37 v1(135.01,91.37) 128.24,91.37 128.1,91.23 127.7,91.23 127.29,90.82 127.13,90.82 127.01,90.94 127.01,91.32 126.88,91.46 126.69,91.46 126.58,91.36 v2(126.58,91.05)
  BOTTOM w0.076: v2(126.58,91.05) 126.58,91.05 126.26,91.37 UH1.D25
PEG_GTX_C_HRX_P0: length 28.9
  TOP w0.102: 129.3,78.72 129.03,78.46 128.45,78.46 127.87,79.03 126.68,79.03 126.09,79.62 125.74,79.62 125.36,79.24 v2(125.28,79.24)
  TOP w0.114: CV531.2 150.75,83.31 145.4,83.31 144.96,82.87 142.77,82.87 138.93,79.03 132.9,79.03 132.88,79.05 132.34,79.05 132.32,79.03 130.42,79.03 130.15,78.76 129.33,78.76 129.3,78.72
  BOTTOM w0.076: v2(125.28,79.24) 124.96,79.56 UH1.F10
PEG_GTX_C_HRX_P1: length 29.7
  TOP w0.102: 129.3,79.4 129.2,79.4 129.01,79.21 128.44,79.21 128.06,79.59 127.89,79.59 127.74,79.75 127.56,79.75 127.4,79.59 126.69,79.59 126.5,79.79 126.5,79.93 v2(126.58,80.02)
  TOP w0.114: CV533.2 152.4,84.62 152.22,84.62 152.09,84.5 152.09,84.29 152,84.19 150.68,84.19 150.5,84.01 150.49,84.01 150.49,84.01 142.47,84.01 138.15,79.69 135.17,79.69 135.15,79.71 134.61,79.71 134.6,79.69 130.07,79.69 129.78,79.4 129.3,79.4
  BOTTOM w0.076: v2(126.58,80.02) 126.26,80.35 UH1.D11
PEG_GTX_C_HRX_P2: length 28.5
  TOP w0.102: 129.3,79.95 129.28,79.95 129.27,79.96 129.2,79.96 129.19,79.97 129.1,79.97 128.27,79.97 127.82,80.43 125.67,80.43 v2(125.28,80.81)
  TOP w0.114: 129.3,79.95 129.48,79.95 129.69,80.16 130.3,80.16 130.32,80.14 130.86,80.14 130.88,80.16 137.86,80.16 142.18,84.48 149.65,84.48 150.03,84.86 CV535.2
  BOTTOM w0.076: v2(125.28,80.81) 124.96,81.14 UH1.F12
PEG_GTX_C_HRX_P3: length 30.2
  TOP w0.102: v2(126.58,81.6) 126.45,81.6 126.27,81.42 126.27,81.31 126.47,81.11 128.28,81.11 128.61,80.79 129,80.79 129.07,80.87 129.07,80.89 129.25,81.06 129.3,81.06
  TOP w0.114: CV537.2 152.13,86.09 151.95,86.09 151.6,86.45 149.51,86.45 149.5,86.47 148.96,86.47 148.94,86.45 142.83,86.45 137.44,81.06 129.3,81.06
  BOTTOM w0.076: v2(126.58,81.6) 126.58,81.66 UH1.D13
PEG_GTX_C_HRX_P4: length 30
  TOP w0.114: v2(124.6,82.37) 124.73,82.24 124.73,82.01 125.05,81.69 125.48,81.69 125.79,82 127.65,82 128,81.65 128.94,81.65 129.1,81.49 137.24,81.49 142.79,87.04 v1(147.05,87.04) 150.74,87.04 CV539.2
  BOTTOM w0.076: v2(124.6,82.37) 124.96,82.73 UH1.F14
PEG_GTX_C_HRX_P5: length 30.3
  TOP w0.114: CV541.2 152.13,88.13 150.57,88.13 150.36,88.34 149.48,88.34 149.47,88.36 148.93,88.36 148.91,88.34 142.86,88.34 136.88,82.36 129.3,82.36 129.29,82.35 128.5,82.35 128.16,82.69 126.51,82.69 126.32,82.88 126.32,83.04 126.45,83.17 v2(126.58,83.17)
  BOTTOM w0.076: v2(126.58,83.17) 126.43,83.17 126.26,83.34 UH1.D15
PEG_GTX_C_HRX_P6: length 28.9
  TOP w0.114: v2(125.28,83.96) 125.28,83.86 125.57,83.57 126.1,83.57 126.1,83.58 127.85,83.58 128.2,83.23 137.12,83.23 142.81,88.92 146.09,88.92 146.1,88.9 146.67,88.9 146.69,88.92 150.89,88.92 CV543.2
  BOTTOM w0.076: UH1.F16 125.28,84.03 v2(125.28,83.96)
PEG_GTX_C_HRX_P7: length 30.6
  TOP w0.114: CV545.2 152.39,90.72 152.19,90.72 152.11,90.64 152.11,90.36 152,90.24 151.46,90.24 151.18,90.53 149.68,90.53 149.5,90.35 149.04,90.35 149.03,90.36 148.42,90.36 148.4,90.35 143.01,90.35 137,84.34 129.37,84.34 129.02,83.98 128.47,83.98 128.17,84.28 126.56,84.28 126.37,84.46 126.37,84.59 126.53,84.75 v2(126.58,84.75)
  BOTTOM w0.114: UH1.D17 126.58,84.81 v2(126.58,84.75)
PEG_GTX_C_HRX_P8: length 29
  TOP w0.114: CV547.2 150.89,91.71 150.73,91.86 150.58,91.86 150.45,91.73 150.45,91.28 150.35,91.17 v1(147.03,91.17) 142.9,91.17 136.75,85.03 127.83,85.03 127.46,85.4 127.28,85.4 127.28,85.4 126.07,85.4 v2(125.93,85.53)
  BOTTOM w0.102: v2(125.93,85.53) 125.61,85.86 UH1.E18
PEG_GTX_C_HRX_P9: length 31.2
  TOP w0.114: CV550.2 152.5,92.01 151.24,92.01 150.91,92.33 150.04,92.33 150.02,92.32 149.39,92.32 149.37,92.33 143.46,92.33 136.63,85.5 v1(133.53,85.5) 129.31,85.5 129.16,85.36 128.28,85.36 127.92,85.72 126.32,85.72 126.12,85.92 125.78,85.92 125.38,86.32 v2(125.28,86.32)
  BOTTOM w0.114: UH1.E19 125.61,86.65 v2(125.28,86.32)
PEG_GTX_C_HRX_P10: length 29.1
  TOP w0.114: CV552.2 150.89,93.69 150.66,93.92 150.53,93.92 150.4,93.79 150.4,93.36 150.25,93.21 143.1,93.21 136.53,86.64 v1(135.24,86.64) 127.15,86.64 126.86,86.93 126.11,86.93 v2(125.93,87.11)
  BOTTOM w0.114: UH1.E20 125.93,87.18 v2(125.93,87.11)
PEG_GTX_C_HRX_P11: length 30.8
  TOP w0.114: CV558.2 152.37,94.17 151.6,94.17 151.42,94.36 150.13,94.36 149.62,93.84 v1(148.65,93.84) 143.11,93.84 136.33,87.06 128.5,87.06 128.32,87.25 126.34,87.25 126.11,87.49 126.11,87.73 v2(125.93,87.9)
  BOTTOM w0.076: v2(125.93,87.9) 125.61,88.22 UH1.E21
PEG_GTX_C_HRX_P12: length 29.5
  TOP w0.114: CV560.2 150.89,95.72 150.66,95.95 150.55,95.95 150.43,95.83 150.43,95.34 150.34,95.24 149.74,95.24 149.33,94.83 v1(147.25,94.83) 142.87,94.83 136.06,88.02 129.98,88.02 129.48,88.52 129.3,88.52 126.1,88.52 v2(125.93,88.68)
  BOTTOM w0.076: UH1.E22 125.61,89.01 v2(125.93,88.68)
PEG_GTX_C_HRX_P13: length 30.8
  TOP w0.114: v2(125.93,89.47) 126.1,89.31 126.1,89.1 126.35,88.84 127.6,88.84 128.23,89.46 129.01,89.46 129.02,89.45 v1(133.92,89.45) 136.88,89.45 142.79,95.37 149.2,95.37 150.26,96.43 151.94,96.43 152.16,96.21 152.36,96.21 CV562.2
  BOTTOM w0.076: UH1.E23 125.61,89.8 v2(125.93,89.47)
PEG_GTX_C_HRX_P14: length 29.5
  TOP w0.114: v2(125.93,90.26) 125.74,90.26 125.66,90.18 125.66,89.96 125.75,89.87 126.21,89.87 126.39,90.05 126.39,90.05 129.11,90.05 129.28,90.22 136.73,90.22 142.71,96.2 146.17,96.2 146.18,96.19 146.79,96.19 146.8,96.2 149.02,96.2 v1(149.61,96.79) 150.11,97.29 150.64,97.29 CV564.2
  BOTTOM w0.076: v2(125.93,90.26) 125.93,90.32 125.61,90.64 UH1.E24
PEG_GTX_C_HRX_P15: length 30.6
  TOP w0.114: CV566.2 152.32,98.28 150.04,98.28 148.76,96.99 142.55,96.99 136.71,91.15 135.38,91.15 135.36,91.13 134.64,91.13 134.62,91.15 129.3,91.15 129.29,91.16 128.33,91.16 128.19,91.01 127.79,91.01 127.38,90.6 126.48,90.6 126.04,91.05 v2(125.89,91.05)
  BOTTOM w0.114: UH1.E25 125.89,91.15 v2(125.89,91.05)
PEG_GTX_HRX_N0: length 10
  TOP w0.089: 156.42,85.05 156.45,85.08 156.88,85.08 156.93,85.13 157,85.13 157,85.13 158.07,85.13 158.93,85.99 158.93,86.21 v2(159.17,86.45)
  TOP w0.114: CV532.1 151.69,83.04 152.17,83.04 152.37,83.24 153.74,83.24 153.77,83.27 153.78,83.27 153.84,83.33 153.86,83.33 v1(153.98,83.45) 154.72,84.19 154.72,84.22 155.56,85.05 156.42,85.05
  BOTTOM w0.114: v2(159.17,86.45) 158.74,86.87 UV1.AJ14
PEG_GTX_HRX_N1: length 8.9
  TOP w0.089: 156.43,86.86 156.56,86.99 157.72,86.99 157.91,86.8 159.01,86.8 159.02,86.81 159.67,86.81 v2(159.98,86.5)
  TOP w0.114: CV534.1 153.39,84.1 153.68,84.1 v1(154.5,84.93) 156.43,86.86
  BOTTOM w0.114: v2(159.98,86.5) 160.38,86.91 UV1.AG14
PEG_GTX_HRX_N2: length 8.7
  TOP w0.114: CV536.1 151.65,85.32 153.66,85.32 v1(155.64,87.29) 156.07,87.72 158.02,87.72 158.31,88.01 v2(158.31,88.07)
  BOTTOM w0.114: UV1.AJ15 158.67,87.71 v2(158.31,88.07)
PEG_GTX_HRX_N3: length 6.1
  TOP w0.114: v2(157.51,88.15) 157.28,88.38 156.06,88.38 v1(154.04,86.37) 153.75,86.07 153.32,86.07 CV538.1
  BOTTOM w0.114: UV1.AK16 157.89,88.54 v2(157.51,88.15)
PEG_GTX_HRX_N4: length 9.5
  TOP w0.114: v2(159.13,89.02) 158.93,89.22 158.93,89.32 158.62,89.63 156.04,89.63 154.08,87.67 153.92,87.67 153.6,87.34 151.65,87.34 CV540.1
  BOTTOM w0.114: UV1.AJ17 v2(159.13,89.02)
PEG_GTX_HRX_N5: length 10.1
  TOP w0.089: 155.68,89.92 155.69,89.93 158.66,89.93 158.74,89.93 159.45,89.22 159.45,89.21 159.5,89.16 159.5,88.74 159.68,88.56 160.16,88.56 160.58,88.98 160.7,88.98 v2(160.72,88.97)
  TOP w0.114: 155.68,89.92 154.85,89.08 154.85,89.05 154.57,88.78 154.57,88.75 154.19,88.37 154.16,88.37 153.9,88.11 153.33,88.11 CV542.1
  BOTTOM w0.114: v2(160.72,88.97) 160.69,88.99 160.59,88.99 160.39,89.19 UV1.AG17
PEG_GTX_HRX_N6: length 8.2
  TOP w0.114: v2(158.34,90.58) 158.34,90.58 158.34,90.58 158.34,90.57 158.06,90.57 157.67,90.96 157.12,90.96 156.88,90.72 156.13,90.72 156.1,90.75 155.4,90.75 155.37,90.72 155.25,90.72 154.09,89.55 CV544.1
  BOTTOM w0.114: UV1.AJ18 158.71,90.21 v2(158.34,90.58)
PEG_GTX_HRX_N7: length 5.6
  TOP w0.114: CV546.1 153.18,89.99 153.9,89.99 v1(154.36,90.45) 154.9,90.99 156.81,90.99 157.3,91.48 v2(157.52,91.48)
  BOTTOM w0.114: v2(157.52,91.48) 157.89,91.11 UV1.AK19
PEG_GTX_HRX_N8: length 9.4
  TOP w0.089: 156.03,91.7 156.27,91.7 156.42,91.84 157.69,91.84 157.95,91.59 157.95,91.3 158.18,91.07 158.79,91.07 v2(159.22,91.51)
  TOP w0.114: CV548.1 151.67,91.15 152.16,91.15 152.37,91.35 153.62,91.35 153.94,91.68 154.47,91.68 154.49,91.7 156.03,91.7 156.03,91.7
  BOTTOM w0.114: v2(159.22,91.51) 158.82,91.91 UV1.AJ20
PEG_GTX_HRX_N9: length 8.8
  TOP w0.089: 156.07,92.57 156.14,92.5 156.26,92.38 159.94,92.38 160.57,91.75 160.57,91.62 v2(160.72,91.48)
  TOP w0.114: CV551.1 153.32,92.41 153.44,92.41 153.6,92.57 156.07,92.57
  BOTTOM w0.114: v2(160.72,91.48) 160.72,91.58 UV1.AG20
PEG_GTX_HRX_N10: length 8.4
  TOP w0.089: 155.85,93.21 155.87,93.21 156.49,92.59 157.88,92.59 158.1,92.8 158.1,92.97 v2(158.33,93.21)
  TOP w0.114: CV557.1 151.68,93.19 151.87,93.19 152.05,93.37 153.98,93.37 154.16,93.19 v1(154.62,93.19) 155.06,93.19 155.08,93.21 155.85,93.21
  BOTTOM w0.114: v2(158.33,93.21) 158.33,93.11 UV1.AJ21
PEG_GTX_HRX_N11: length 5.2
  TOP w0.114: CV559.1 153.33,94.43 v1(154.21,94.43) 156.78,94.43 157.2,94 v2(157.49,94)
  BOTTOM w0.114: UV1.AK22 157.89,93.6 v2(157.49,94)
PEG_GTX_HRX_N12: length 9.4
  TOP w0.089: 155.51,94.66 157.39,94.66 157.92,94.12 157.92,93.84 158.18,93.58 158.75,93.58 v2(159.12,93.94)
  TOP w0.114: CV561.1 151.67,95.21 154.95,95.21 155.51,94.66
  BOTTOM w0.114: v2(159.12,93.94) 159.12,94.22 158.93,94.41 UV1.AJ23
PEG_GTX_HRX_N13: length 9.6
  TOP w0.089: v2(160.79,94.01) 160.6,94.2 160.6,94.42 160.35,94.67 160.03,94.67 159.37,95.33 157.79,95.33 157.67,95.21 156.38,95.21 156.24,95.36 156.02,95.58 156.02,95.62 155.98,95.66
  TOP w0.114: 155.98,95.66 155.31,96.33 154.98,96.33 154.96,96.34 154.4,96.34 154.38,96.33 153.97,96.33 153.82,96.47 153.32,96.47 CV563.1
  BOTTOM w0.114: v2(160.79,94.01) UV1.AG23
PEG_GTX_HRX_N14: length 8.5
  TOP w0.089: 156.08,96.66 156.1,96.64 156.1,96.43 156.38,96.15 157.87,96.15 158.33,95.69 v2(158.34,95.69)
  TOP w0.102: 155.66,97.09 156.08,96.66
  TOP w0.114: CV565.1 151.61,97.54 153.79,97.54 154.25,97.09 155.66,97.09
  BOTTOM w0.114: v2(158.34,95.69) 158.74,95.29 UV1.AJ24
PEG_GTX_HRX_N15: length 6.4
  TOP w0.114: v2(157.49,96.53) 157.34,96.67 157.34,97.57 156.98,97.93 v1(155.51,97.93) 154.42,97.93 153.87,98.48 153.34,98.48 CV567.1
  BOTTOM w0.114: UV1.AK25 157.89,96.13 v2(157.49,96.53)
PEG_GTX_HRX_P0: length 9.9
  TOP w0.089: v2(158.33,86.43) 158.68,86.43 158.75,86.36 158.75,86.06 158,85.31 156.92,85.31 156.92,85.3 156.85,85.3 156.81,85.26 156.3,85.26
  TOP w0.114: CV531.1 151.67,83.26 152.08,83.26 152.28,83.46 153.65,83.46 154,83.81 154.02,83.81 155.47,85.26 v1(156.03,85.26) 156.3,85.26
  BOTTOM w0.114: v2(158.33,86.43) 157.89,86.86 UV1.AK14
PEG_GTX_HRX_P1: length 8.9
  TOP w0.089: v2(159.97,87.32) 159.97,87.21 159.75,86.99 158.94,86.99 158.94,86.98 157.98,86.98 157.79,87.16 156.45,87.16 156.27,86.99
  TOP w0.114: 156.27,86.99 155.75,86.46 155.72,86.46 153.58,84.32 153.27,84.32 CV533.1
  BOTTOM w0.114: v2(159.97,87.32) 159.59,86.93 UV1.AH14
PEG_GTX_HRX_P2: length 8.7
  TOP w0.114: CV535.1 151.71,85.09 153.75,85.09 156.16,87.5 158.16,87.5 v2(158.32,87.34)
  BOTTOM w0.114: UV1.AK15 158.11,87.71 158.32,87.5 v2(158.32,87.34)
PEG_GTX_HRX_P3: length 6.1
  TOP w0.114: v2(157.48,88.95) 157.13,88.61 155.97,88.61 154.14,86.78 154.11,86.78 153.74,86.41 153.74,86.41 153.63,86.29 153.34,86.29 CV537.1
  BOTTOM w0.114: UV1.AL16 157.09,88.57 v2(157.48,88.95)
PEG_GTX_HRX_P4: length 9.6
  TOP w0.114: CV539.1 151.71,87.12 153.69,87.12 154.01,87.44 154.19,87.44 v1(155.8,89.06) 156.17,89.42 158.52,89.42 158.71,89.23 158.71,89.05 158.6,88.94 158.36,88.94 v2(158.29,89.01)
  BOTTOM w0.114: UV1.AK17 v2(158.29,89.01)
PEG_GTX_HRX_P5: length 10.1
  TOP w0.089: v2(160.05,88.99) 160.05,88.84 159.95,88.74 159.75,88.74 159.67,88.81 159.67,89.24 159.62,89.29 159.62,89.3 158.81,90.11 158.59,90.11 155.78,90.11 155.77,90.12 155.6,90.12 155.58,90.11
  TOP w0.114: 155.58,90.11 v1(154.21,88.73) 153.81,88.33 153.65,88.33 153.55,88.43 153.55,88.79 153.44,88.9 153.21,88.9 153.12,88.82 CV541.1
  BOTTOM w0.114: UV1.AH17 160,88.99 v2(160.05,88.99)
PEG_GTX_HRX_P6: length 8.2
  TOP w0.114: v2(157.49,90.58) 157.49,90.62 157.36,90.75 157.2,90.75 156.96,90.52 v1(155.72,90.52) 155.34,90.52 154.85,90.02 154.85,89.99 154.18,89.33 152.01,89.33 151.91,89.23 151.91,88.73 151.8,88.62 151.56,88.62 151.47,88.71 CV543.1
  BOTTOM w0.114: v2(157.49,90.58) 157.49,90.42 157.71,90.21 UV1.AK18
PEG_GTX_HRX_P7: length 5.6
  TOP w0.114: v2(156.68,91.42) 156.68,91.32 156.58,91.21 156.23,91.21 156,91.45 155.85,91.45 155.62,91.21 154.81,91.21 154.4,90.81 154.38,90.81 154,90.43 154,90.4 153.81,90.21 153.65,90.21 153.55,90.32 153.55,90.69 153.43,90.8 153.24,90.8 153.12,90.68 CV545.1
  BOTTOM w0.114: UV1.AL19 157.09,91.26 156.93,91.42 v2(156.68,91.42)
PEG_GTX_HRX_P8: length 9.4
  TOP w0.089: v2(158.37,91.51) 158.69,91.51 158.86,91.68 158.86,91.89 158.73,92.02 158.35,92.02 158.14,91.81 157.98,91.81 157.76,92.02 156.34,92.02 156.24,91.92 155.93,91.92
  TOP w0.114: CV547.1 151.69,91.37 152.07,91.37 152.28,91.58 153.52,91.58 153.86,91.92 v1(154.18,91.92) 155.93,91.92
  BOTTOM w0.114: v2(158.37,91.51) 157.97,91.91 UV1.AK20
PEG_GTX_HRX_P9: length 8.8
  TOP w0.089: v2(159.99,91.51) 160.09,91.4 160.17,91.4 160.36,91.59 160.36,91.71 159.86,92.21 156.14,92.21 156,92.34
  TOP w0.114: CV550.1 153.34,92.18 153.53,92.18 153.69,92.34 v1(155.67,92.34) 156,92.34
  BOTTOM w0.114: UV1.AH20 v2(159.99,91.51)
PEG_GTX_HRX_P10: length 8.4
  TOP w0.089: v2(157.52,93.16) 157.64,93.28 157.77,93.28 157.92,93.13 157.92,92.88 157.81,92.76 156.56,92.76 155.92,93.41
  TOP w0.114: 155.92,93.41 155.08,93.41 155.06,93.43 154.24,93.43 154.08,93.59 151.95,93.59 151.77,93.41 151.68,93.41 CV552.1
  BOTTOM w0.114: v2(157.52,93.16) 157.89,92.78 UV1.AK21
PEG_GTX_HRX_P11: length 5.3
  TOP w0.114: CV558.1 153.33,94.2 153.93,94.2 153.94,94.19 154.48,94.19 154.5,94.2 v1(155.79,94.2) 156.04,94.2 156.14,94.1 156.14,93.77 156.38,93.54 156.63,93.54 156.78,93.69 156.78,93.87 v2(156.65,94)
  BOTTOM w0.114: v2(156.65,94) 157.09,93.56 UV1.AL22
PEG_GTX_HRX_P12: length 9.5
  TOP w0.089: v2(158.48,93.94) 158.48,93.85 158.39,93.76 158.26,93.76 158.1,93.92 158.1,94.22 v1(157.82,94.5) 157.49,94.83 155.65,94.83 155.5,94.99
  TOP w0.114: 155.5,94.99 155.04,95.44 152.08,95.44 151.93,95.6 151.93,95.85 151.77,96 151.6,96 151.47,95.88 CV560.1
  BOTTOM w0.114: UV1.AK23 158.35,93.94 v2(158.48,93.94)
PEG_GTX_HRX_P13: length 9.5
  TOP w0.089: v2(159.99,94.01) 160.32,94.01 160.42,94.11 160.42,94.34 160.27,94.49 159.96,94.49 159.29,95.16 157.86,95.16 157.74,95.04 156.31,95.04 155.85,95.5 155.83,95.51
  TOP w0.114: CV562.1 153.34,96.25 153.73,96.25 153.87,96.1 v1(154.67,96.1) 155.24,96.1 155.83,95.51
  BOTTOM w0.114: UV1.AH23 v2(159.99,94.01)
PEG_GTX_HRX_P14: length 8.5
  TOP w0.089: v2(157.49,95.61) 157.83,95.61 157.92,95.7 157.92,95.85 157.8,95.97 156.31,95.97 156.19,96.1 156.19,96.1 155.92,96.36 155.92,96.55 155.89,96.58
  TOP w0.102: 155.89,96.58 155.61,96.86 155.46,96.86
  TOP w0.114: 155.46,96.86 154.13,96.86 v1(153.87,97.12) 153.67,97.32 151.75,97.32 CV564.1
  BOTTOM w0.114: UV1.AK24 v2(157.49,95.61)
PEG_GTX_HRX_P15: length 6.4
  TOP w0.114: v2(156.69,96.52) 156.99,96.52 157.14,96.67 157.14,97.46 156.89,97.71 155.6,97.71 155.58,97.69 155.24,97.69 155.22,97.71 154.32,97.71 153.77,98.26 153.32,98.26 CV566.1
  BOTTOM w0.114: UV1.AL25 157.09,96.12 v2(156.69,96.52)
PEG_HTX_C_GRX_N0: length 23.2
  BOTTOM w0.114: UV1.AM12 156.03,85.21 155.68,85.56 155.29,85.56 154.94,85.91 153.38,85.91 153.31,85.99 149.83,85.99 149.81,86.01 149.27,86.01 149.25,85.99 145.89,85.99 v1(142.21,82.3) 138.27,78.37 137.46,78.37 137.11,78.02 136.87,78.02 CH36.2
PEG_HTX_C_GRX_N1: length 24.8
  BOTTOM w0.114: UV1.AM14 156.06,86.91 155.65,86.5 155.42,86.5 155.14,86.23 154.21,86.23 153.93,86.5 145.76,86.5 144.36,85.11 144.36,85.09 143.98,84.71 143.96,84.71 138.17,78.92 v1(137.55,78.92) 136.49,78.92 136.23,78.66 135.34,78.66 CH34.2
PEG_HTX_C_GRX_N2: length 21.4
  BOTTOM w0.114: UV1.AP15 154.69,87.51 154.61,87.43 151.57,87.43 151.55,87.45 151.01,87.45 150.99,87.43 v1(148,87.43) 145.38,87.43 137.93,79.98 136.93,79.98 CH32.2
PEG_HTX_C_GRX_N3: length 24.8
  BOTTOM w0.114: CH30.2 135.43,80.77 138.1,80.77 145.42,88.1 145.95,88.1 145.97,88.08 146.51,88.08 146.53,88.1 v1(149.88,88.1) 154.82,88.1 155.12,87.8 155.12,87.54 155.3,87.36 155.94,87.36 UV1.AM15
PEG_HTX_C_GRX_N4: length 23.4
  BOTTOM w0.114: CH28.2 136.93,82.01 138.06,82.01 145.03,88.99 v1(147.94,88.99) 151.63,88.99 151.65,89.01 152.19,89.01 152.21,88.99 154.98,88.99 155.12,89.13 155.12,89.59 155.33,89.81 155.98,89.81 156.29,89.5 UV1.AM17
PEG_HTX_C_GRX_N5: length 24.2
  BOTTOM w0.114: CH26.2 135.43,82.81 138.12,82.81 145.02,89.7 145.81,89.7 145.83,89.69 146.37,89.69 146.39,89.7 v1(149.9,89.7) 153.43,89.7 154.12,90.39 154.24,90.39 154.33,90.31 154.33,90.05 154.09,89.81 154.09,89.66 154.19,89.56 154.34,89.56 154.69,89.91 UV1.AP18
PEG_HTX_C_GRX_N6: length 23.1
  BOTTOM w0.076: 155.2,90.85 155.23,90.85 155.37,90.71 155.9,90.71 156.1,90.51 156.1,90.32 156.21,90.21 UV1.AM18
  BOTTOM w0.114: 155.2,90.85 154.94,91.11 v1(148.22,91.11) 145.15,91.11 139.93,85.89 139.9,85.89 139.52,85.51 139.52,85.49 138.08,84.05 136.93,84.05 CH24.2
PEG_HTX_C_GRX_N7: length 24.4
  BOTTOM w0.076: UV1.AM20 156.23,91.91 156.1,91.78 156.1,91.6 155.89,91.39 155.39,91.39 155.39,91.39 155.34,91.39 155.29,91.34 155.2,91.34
  BOTTOM w0.114: CH22.2 135.43,84.84 138.15,84.84 v1(141.69,88.38) 143.27,89.96 143.3,89.96 143.68,90.34 143.68,90.37 144.87,91.56 153.98,91.56 154.2,91.34 154.38,91.34 155.2,91.34
PEG_HTX_C_GRX_N8: length 20.8
  BOTTOM w0.114: UV1.AP21 154.41,92.43 146.62,92.43 146.6,92.45 146.06,92.45 146.04,92.43 144.46,92.43 138.11,86.08 v1(137.63,86.08) 136.93,86.08 CH20.2
PEG_HTX_C_GRX_N9: length 24
  BOTTOM w0.114: CH18.2 135.42,87.09 138.16,87.09 144.36,93.28 v1(150.21,93.28) 152.02,93.28 152.03,93.3 152.58,93.3 152.6,93.28 155.02,93.28 155.22,93.08 155.67,93.08 156.04,92.71 UV1.AM21
PEG_HTX_C_GRX_N10: length 22.6
  BOTTOM w0.114: UV1.AM23 155.93,94.05 155.47,94.05 155.09,93.67 154.37,93.67 154.07,93.98 v1(147.7,93.98) 145.55,93.98 145.53,93.96 144.99,93.96 144.97,93.98 144.43,93.98 138.28,87.83 136.9,87.83 CH16.2
PEG_HTX_C_GRX_N11: length 22.2
  BOTTOM w0.114: CH14.2 135.39,89.14 138.26,89.14 144.14,95.02 v1(149.9,95.02) 151.79,95.02 151.81,95.05 152.34,95.05 152.37,95.02 153.67,95.02 153.86,95.02 153.98,94.9 154.39,94.9 UV1.AP24
PEG_HTX_C_GRX_N12: length 22.6
  BOTTOM w0.114: UV1.AM24 155.94,94.86 155.31,94.86 155.1,95.06 155.1,95.34 154.82,95.63 v1(147.24,95.63) 144.99,95.63 144.97,95.61 144.42,95.61 144.4,95.63 144.12,95.63 138.41,89.91 136.95,89.91 CH12.2
PEG_HTX_C_GRX_N13: length 24.1
  BOTTOM w0.114: CH10.2 135.44,91.13 138.34,91.13 143.82,96.61 v1(149.34,96.61) 151.42,96.61 151.44,96.62 151.98,96.62 152,96.61 154.14,96.61 154.24,96.51 154.88,96.51 155.09,96.72 155.09,97.01 155.35,97.26 155.94,97.26 UV1.AM26
PEG_HTX_C_GRX_N14: length 20.3
  BOTTOM w0.114: CH8.2 136.95,92.16 138.41,92.16 143.67,97.42 v1(144.94,97.42) 146.97,97.42 146.99,97.44 147.54,97.44 147.55,97.42 154.41,97.42 UV1.AP27
PEG_HTX_C_GRX_N15: length 23.8
  BOTTOM w0.114: CH6.2 135.37,93.23 135.8,93.23 135.98,93.05 138.37,93.05 143.35,98.03 143.37,98.03 143.54,98.2 148.96,98.2 149.17,98.41 v1(149.79,98.41) 151.55,98.41 151.58,98.44 152.11,98.44 152.14,98.41 155.14,98.41 155.49,98.06 155.64,98.06 155.99,97.71 UV1.AM27
PEG_HTX_C_GRX_P0: length 23.3
  BOTTOM w0.114: CH35.2 137.02,77.8 137.2,77.8 137.55,78.15 138.36,78.15 142.16,81.94 142.19,81.94 142.57,82.32 142.57,82.35 145.98,85.77 v1(149.54,85.77) 153.21,85.77 153.29,85.69 154.81,85.69 155.08,85.43 155.08,84.88 155.18,84.78 155.36,84.78 155.49,84.91 UV1.AN12
PEG_HTX_C_GRX_P1: length 24.7
  BOTTOM w0.114: CH33.2 135.5,78.88 136.14,78.88 136.4,79.14 137.26,79.14 137.28,79.16 137.82,79.16 137.84,79.14 138.08,79.14 v1(144,85.07) 145.66,86.73 154.03,86.73 154.3,86.45 155.05,86.45 155.18,86.58 155.18,86.71 155.04,86.85 155.04,87.07 155.11,87.14 155.43,87.14 155.49,87.08 UV1.AN14
PEG_HTX_C_GRX_P2: length 21.4
  BOTTOM w0.114: CH31.2 136.95,79.76 138.02,79.76 145.47,87.21 147.71,87.21 147.73,87.19 148.27,87.19 148.29,87.21 v1(151.28,87.21) 154.58,87.21 154.69,87.09 UV1.AP14
PEG_HTX_C_GRX_P3: length 24.8
  BOTTOM w0.114: UV1.AN15 155.85,87.71 155.95,87.81 155.95,88.02 155.79,88.18 155.47,88.18 155.34,88.05 155.19,88.05 154.91,88.33 150.17,88.33 150.15,88.34 149.61,88.34 149.59,88.33 v1(146.24,88.33) 145.33,88.33 138,81 135.41,81 CH29.2
PEG_HTX_C_GRX_P4: length 23.3
  BOTTOM w0.114: CH27.2 136.95,81.79 138.15,81.79 145.13,88.77 147.65,88.77 147.67,88.75 148.21,88.75 148.23,88.77 v1(151.92,88.77) 155.07,88.77 155.22,88.92 155.81,88.92 155.94,89.04 155.94,89.47 155.83,89.58 155.58,89.58 155.49,89.48 UV1.AN17
PEG_HTX_C_GRX_P5: length 24.3
  BOTTOM w0.114: UV1.AP17 154.69,89.54 155.04,89.9 155.04,90.34 155.04,90.34 155.04,90.35 154.77,90.62 154.02,90.62 153.33,89.93 150.19,89.93 150.17,89.94 149.63,89.94 149.62,89.93 v1(146.1,89.93) 144.93,89.93 138.03,83.03 135.41,83.03 CH25.2
PEG_HTX_C_GRX_P6: length 23
  BOTTOM w0.076: UV1.AN18 155.84,90.21 155.93,90.3 155.93,90.44 155.83,90.54 155.28,90.54 155.27,90.55 155.21,90.55
  BOTTOM w0.114: 155.21,90.55 155.13,90.63 155.11,90.63 154.85,90.89 148.51,90.89 148.49,90.87 147.95,90.87 147.93,90.89 145.24,90.89 v1(139.88,85.53) 138.17,83.82 136.95,83.82 CH23.2
PEG_HTX_C_GRX_P7: length 24.4
  BOTTOM w0.076: UV1.AN20 155.83,91.91 155.93,91.81 155.93,91.66 155.82,91.55 155.23,91.55 155.22,91.56 155.2,91.56
  BOTTOM w0.114: CH21.2 135.41,85.06 138.06,85.06 141.31,88.32 141.31,88.34 141.71,88.75 141.74,88.75 v1(143.32,90.32) 144.77,91.78 154.07,91.78 154.29,91.56 155.2,91.56
PEG_HTX_C_GRX_P8: length 20.8
  BOTTOM w0.114: CH19.2 136.95,85.85 137.31,85.85 137.34,85.83 137.89,85.83 137.92,85.85 138.2,85.85 144.55,92.21 v1(146.33,92.21) 154.04,92.21 154.34,91.91 UV1.AP20
PEG_HTX_C_GRX_P9: length 24
  BOTTOM w0.114: UV1.AN21 155.49,92.37 155.39,92.27 155.18,92.27 155.08,92.37 155.08,92.9 154.93,93.06 v1(152.31,93.06) 150.5,93.06 150.48,93.04 149.94,93.04 149.92,93.06 144.45,93.06 138.25,86.86 135.42,86.86 CH17.2
PEG_HTX_C_GRX_P10: length 22.6
  BOTTOM w0.114: UV1.AN23 155.49,94.56 155.41,94.64 155.11,94.64 155.04,94.57 155.04,94.33 155.19,94.18 155.19,94.08 155,93.89 154.47,93.89 154.16,94.2 147.99,94.2 147.97,94.22 147.42,94.22 147.41,94.2 v1(145.26,94.2) 144.33,94.2 138.19,88.05 136.97,88.05 136.74,88.28 CH15.2
PEG_HTX_C_GRX_P11: length 22.2
  BOTTOM w0.114: CH13.2 135.45,88.92 138.35,88.92 144.23,94.8 149.61,94.8 149.63,94.78 150.17,94.78 150.18,94.8 v1(152.08,94.8) 153.76,94.8 153.88,94.68 154.42,94.68 UV1.AP23
PEG_HTX_C_GRX_P12: length 22.7
  BOTTOM w0.114: CH11.2 136.94,90.13 138.31,90.13 144.03,95.85 v1(144.69,95.85) 146.95,95.85 146.97,95.87 147.51,95.87 147.53,95.85 154.91,95.85 155.07,95.69 155.84,95.69 155.97,95.56 155.97,95.38 155.94,95.35 155.94,95.27 155.81,95.14 155.56,95.14 UV1.AN24
PEG_HTX_C_GRX_P13: length 24.1
  BOTTOM w0.114: CH9.2 135.4,90.9 138.43,90.9 143.91,96.38 149.05,96.38 149.07,96.37 149.62,96.37 149.64,96.38 v1(151.71,96.38) 154.04,96.38 154.15,96.28 154.98,96.28 155.17,96.48 155.83,96.48 155.97,96.61 155.97,96.74 155.94,96.76 155.94,96.87 155.81,96.99 155.57,96.99 UV1.AN26
PEG_HTX_C_GRX_P14: length 20.4
  BOTTOM w0.114: CH7.2 136.94,91.94 138.5,91.94 143.77,97.2 144.65,97.2 144.67,97.18 145.21,97.18 145.23,97.2 v1(147.27,97.2) 154.4,97.2 UV1.AP26
PEG_HTX_C_GRX_P15: length 23.7
  BOTTOM w0.114: CH5.2 135.21,92.83 135.39,93 135.71,93 135.89,92.83 138.28,92.83 138.28,92.83 138.47,92.83 143.44,97.8 143.46,97.8 143.63,97.98 149.05,97.98 149.26,98.19 149.51,98.19 149.52,98.17 150.06,98.17 150.08,98.19 v1(151.85,98.19) 155.05,98.19 155.18,98.06 155.18,97.9 155.04,97.76 155.04,97.53 155.1,97.47 155.41,97.47 155.49,97.56 UV1.AN27
PEG_HTX_GRX_N0: length 10.3
  BOTTOM w0.076: UH1.B10 127.29,79.63 127.2,79.54 127.2,79.41 127.33,79.29 128.54,79.29 128.63,79.2 128.99,79.2 129.07,79.28 129.3,79.28
  BOTTOM w0.114: 129.3,79.28 v1(130.6,79.28) 132.07,79.28 132.36,79 132.38,79 132.76,78.62 132.76,78.59 133.28,78.07 134.72,78.07 134.87,77.91 135.92,77.91 CH36.1
PEG_HTX_GRX_N1: length 8.1
  BOTTOM w0.076: UH1.B11 127.57,80.41 127.69,80.29 127.69,80.13 127.91,79.91 128.52,79.91 128.63,80.02 129.25,80.02 129.29,79.98 129.3,79.98
  BOTTOM w0.114: CH34.1 134.43,78.72 v1(133.73,78.72) 133.41,78.72 133.19,78.94 132.15,79.98 131.82,79.98 131.8,79.96 131.26,79.96 131.24,79.98 129.3,79.98
PEG_HTX_GRX_N2: length 10
  BOTTOM w0.076: UH1.B12 127.29,81.2 127.2,81.11 127.2,80.99 127.33,80.86 128.54,80.86 128.6,80.8 129,80.8 129.11,80.91 129.46,80.91
  BOTTOM w0.114: 129.46,80.91 v1(129.92,80.91) 133.24,80.91 133.53,80.62 133.56,80.62 133.94,80.24 133.94,80.21 134.12,80.03 136,80.03 CH32.1
PEG_HTX_GRX_N3: length 7.9
  BOTTOM w0.076: 129.46,81.46 129.45,81.46 129.44,81.47 129.3,81.47 129.16,81.61 128.6,81.61 128.49,81.5 127.89,81.5 127.69,81.71 127.69,81.87 127.57,81.99 UH1.B13
  BOTTOM w0.114: 129.46,81.46 130.77,81.46 130.79,81.45 131.33,81.45 131.35,81.46 v1(132.47,81.46) 133.37,81.46 134.08,80.75 134.43,80.75 CH30.1
PEG_HTX_GRX_N4: length 9.8
  BOTTOM w0.076: 129.46,82.38 129.45,82.38 129.43,82.36 128.59,82.36 128.52,82.43 127.33,82.43 127.2,82.56 127.2,82.69 127.29,82.78 UH1.B14
  BOTTOM w0.114: CH28.1 135.94,81.99 134.18,81.99 133.8,82.38 v1(129.93,82.38) 129.46,82.38
PEG_HTX_GRX_N5: length 7.7
  BOTTOM w0.076: 129.17,83.21 129.16,83.21 128.64,83.21 128.49,83.06 127.89,83.06 127.68,83.28 127.68,83.46 127.57,83.56 UH1.B15
  BOTTOM w0.114: CH26.1 134.43,82.79 134.12,82.79 133.7,83.21 133.51,83.21 133.49,83.19 132.95,83.19 132.93,83.21 v1(130.95,83.21) 129.17,83.21
PEG_HTX_GRX_N6: length 9.7
  BOTTOM w0.076: 129.17,84.11 129.13,84.11 129.02,84 128.55,84 128.53,84.03 127.32,84.03 127.2,84.14 127.2,84.3 127.3,84.39 127.52,84.39 UH1.B16
  BOTTOM w0.114: CH24.1 136.02,84.11 v1(132.09,84.11) 130,84.11 129.99,84.13 129.44,84.13 129.43,84.11 129.17,84.11
PEG_HTX_GRX_N7: length 7.6
  BOTTOM w0.076: 129.17,84.72 129.16,84.72 129.14,84.75 129.09,84.75 129.08,84.76 128.57,84.76 128.46,84.65 127.9,84.65 127.69,84.86 127.69,85.02 127.57,85.14 UH1.B17
  BOTTOM w0.114: CH22.1 134.41,84.84 133.96,84.84 133.84,84.72 133.53,84.72 133.52,84.71 132.98,84.71 132.96,84.72 v1(130.93,84.72) 129.17,84.72
PEG_HTX_GRX_N8: length 10
  BOTTOM w0.076: 129.17,85.61 129.1,85.61 129.03,85.55 128.58,85.55 128.49,85.63 128.1,85.63 127.89,85.84 127.89,85.99 127.67,86.21 127.19,86.21 UH1.C18
  BOTTOM w0.114: 129.17,85.61 129.54,85.61 129.56,85.63 130.1,85.63 130.12,85.61 130.26,85.61 130.38,85.73 v1(131.99,85.73) 133.55,85.73 133.88,86.06 135.94,86.06 CH20.1
PEG_HTX_GRX_N9: length 7.7
  BOTTOM w0.076: UH1.A19 127.94,86.71 127.85,86.63 127.85,86.5 127.98,86.38 128.43,86.38 128.58,86.53 129.15,86.53 129.17,86.55
  BOTTOM w0.114: 129.17,86.55 v1(130.99,86.55) 133.39,86.55 133.79,86.94 133.81,86.94 133.96,87.09 134.43,87.09 CH18.1
PEG_HTX_GRX_N10: length 10
  BOTTOM w0.076: 129.17,86.99 129.15,87.01 127.25,87.01 127.04,87.22 127.04,87.38 126.92,87.5 UH1.C20
  BOTTOM w0.114: 129.17,86.99 129.6,86.99 129.62,86.97 130.15,86.97 130.17,86.99 v1(132.27,86.99) 133.21,86.99 134.08,87.86 135.96,87.86 CH16.1
PEG_HTX_GRX_N11: length 8.1
  BOTTOM w0.076: 129.68,88.08 129.2,88.08 129.06,88.22 128.64,88.22 128.39,87.96 127.97,87.96 127.82,88.11 127.82,88.17 127.94,88.29 UH1.A21
  BOTTOM w0.114: CH14.1 134.42,89.11 133.83,89.11 133.41,88.7 133.39,88.7 133,88.32 133,88.29 132.79,88.08 v1(131.52,88.08) 129.68,88.08
PEG_HTX_GRX_N12: length 10.2
  BOTTOM w0.076: 129.68,88.66 129.52,88.66 129.39,88.53 128.53,88.53 128.5,88.57 127.26,88.57 127.04,88.8 127.04,88.95 126.92,89.08 UH1.C22
  BOTTOM w0.114: 129.68,88.66 129.94,88.66 130.25,88.97 v1(130.61,88.97) 132.96,88.97 133.36,89.36 133.39,89.36 133.77,89.74 133.77,89.77 133.9,89.9 135.96,89.9 CH12.1
PEG_HTX_GRX_N13: length 8.1
  BOTTOM w0.076: 129.5,89.67 129.46,89.63 129.4,89.63 129.39,89.63 128.48,89.63 128.38,89.53 127.98,89.53 127.85,89.65 127.85,89.78 127.94,89.86 UH1.A23
  BOTTOM w0.114: CH10.1 134.41,91.14 v1(133.8,91.14) 133.46,91.14 132.25,89.92 131.67,89.92 131.65,89.91 129.75,89.91 129.51,89.67 129.5,89.67
PEG_HTX_GRX_N14: length 10.6
  BOTTOM w0.076: 129.5,90.57 129.49,90.57 129.45,90.53 129.42,90.53 129.4,90.51 129.26,90.51 128.99,90.24 128.51,90.24 128.4,90.35 128.1,90.35 127.92,90.53 127.92,90.68 127.67,90.93 127.19,90.93 UH1.C24
  BOTTOM w0.114: 129.5,90.57 v1(130.4,90.57) 131.04,90.57 131.16,90.69 131.93,90.69 132.08,90.85 132.08,90.88 132.51,91.3 132.53,91.3 133.37,92.14 135.47,92.14 135.5,92.17 135.96,92.17 CH8.1
PEG_HTX_GRX_N15: length 8.3
  BOTTOM w0.076: UH1.A25 127.94,91.44 127.85,91.35 127.85,91.23 127.98,91.1 128.35,91.1 128.5,91.25 129.36,91.25 129.38,91.27 129.48,91.27 129.5,91.29
  BOTTOM w0.114: CH6.1 134.42,93.18 134.23,93.18 133.86,92.8 133.45,92.8 133.43,92.78 132.36,92.78 131.58,92 v1(130.99,92) 130.5,92 129.79,91.29 129.5,91.29
PEG_HTX_GRX_P0: length 10.2
  BOTTOM w0.076: 129.3,79.05 129.09,79.05 129.07,79.03 128.56,79.03 128.47,79.12 127.26,79.12 127.04,79.35 127.04,79.51 126.92,79.63 UH1.C10
  BOTTOM w0.114: 129.3,79.05 130.32,79.05 130.33,79.04 130.87,79.04 130.89,79.05 131.98,79.05 v1(132.4,78.64) 133.19,77.85 134.62,77.85 134.78,77.69 135.97,77.69 CH35.1
PEG_HTX_GRX_P1: length 8
  BOTTOM w0.076: 129.3,80.21 129.28,80.19 128.56,80.19 128.45,80.08 127.98,80.08 127.85,80.2 127.85,80.33 127.94,80.41 UH1.A11
  BOTTOM w0.114: 129.3,80.21 v1(131.53,80.21) 132.24,80.21 133.48,78.96 134,78.96 134.02,78.95 134.41,78.95 CH33.1
PEG_HTX_GRX_P2: length 10.1
  BOTTOM w0.076: UH1.C12 126.92,81.2 127.04,81.08 127.04,80.92 127.26,80.7 128.47,80.7 128.53,80.64 129.07,80.64 129.14,80.7 129.44,80.7 129.46,80.68
  BOTTOM w0.114: CH31.1 135.89,79.8 134.03,79.8 v1(133.58,80.25) 133.15,80.68 130.21,80.68 130.19,80.67 129.65,80.67 129.63,80.68 129.46,80.68
PEG_HTX_GRX_P3: length 7.8
  BOTTOM w0.076: UH1.A13 127.94,81.99 127.85,81.9 127.85,81.78 127.96,81.67 128.42,81.67 128.53,81.78 129.23,81.78 129.32,81.69 129.46,81.69
  BOTTOM w0.114: CH29.1 134.41,80.98 134.17,80.98 133.46,81.69 132.76,81.69 132.74,81.71 132.2,81.71 132.18,81.69 v1(131.06,81.69) 129.46,81.69
PEG_HTX_GRX_P4: length 9.8
  BOTTOM w0.076: 129.46,82.15 129.44,82.17 129.38,82.17 129.36,82.19 128.52,82.19 128.45,82.27 127.27,82.27 127.04,82.5 127.04,82.66 126.92,82.78 UH1.C14
  BOTTOM w0.114: 129.46,82.15 129.64,82.15 129.66,82.14 130.2,82.14 130.22,82.15 133.68,82.15 v1(133.86,81.98) 134.07,81.77 135.96,81.77 CH27.1
PEG_HTX_GRX_P5: length 7.7
  BOTTOM w0.076: 129.17,83.43 128.61,83.43 128.41,83.24 127.97,83.24 127.85,83.35 127.85,83.48 127.94,83.56 UH1.A15
  BOTTOM w0.114: 129.17,83.43 130.66,83.43 130.68,83.45 131.22,83.45 131.23,83.43 v1(133.22,83.43) 133.79,83.43 134.21,83.01 134.41,83.01 CH25.1
PEG_HTX_GRX_P6: length 9.7
  BOTTOM w0.076: UH1.C16 126.92,84.35 127.04,84.23 127.04,84.07 127.25,83.86 128.46,83.86 128.48,83.84 129.09,83.84 129.14,83.89 129.17,83.89
  BOTTOM w0.114: CH23.1 135.87,83.89 132.38,83.89 132.36,83.87 131.82,83.87 131.8,83.89 v1(129.72,83.89) 129.17,83.89
PEG_HTX_GRX_P7: length 7.5
  BOTTOM w0.076: UH1.A17 127.94,85.14 127.85,85.05 127.85,84.93 127.97,84.81 128.39,84.81 128.5,84.93 129.15,84.93 129.17,84.95
  BOTTOM w0.114: 129.17,84.95 130.65,84.95 130.66,84.97 131.2,84.97 131.22,84.95 v1(133.25,84.95) 133.75,84.95 133.86,85.06 134.43,85.06 CH21.1
PEG_HTX_GRX_P8: length 10
  BOTTOM w0.076: UH1.B18 127.48,86 127.31,86 127.19,85.89 127.19,85.71 127.32,85.59 127.91,85.59 128.03,85.47 128.42,85.47 128.51,85.38 129.09,85.38 129.1,85.39 129.17,85.39
  BOTTOM w0.114: CH19.1 135.96,85.83 133.97,85.83 133.64,85.5 132.28,85.5 132.26,85.49 131.67,85.49 131.65,85.5 130.47,85.5 130.35,85.39 v1(129.83,85.39) 129.17,85.39
PEG_HTX_GRX_P9: length 7.8
  BOTTOM w0.076: 129.17,86.32 129.08,86.32 129.05,86.36 128.65,86.36 128.5,86.21 127.91,86.21 127.69,86.43 127.69,86.59 127.57,86.71 UH1.B19
  BOTTOM w0.114: CH17.1 134.42,86.87 134.06,86.87 v1(133.77,86.58) 133.51,86.32 131.27,86.32 131.26,86.31 130.71,86.31 130.7,86.32 129.17,86.32
PEG_HTX_GRX_P10: length 10
  BOTTOM w0.076: UH1.B20 127.29,87.5 127.2,87.41 127.2,87.29 127.32,87.18 129.13,87.18 129.17,87.21
  BOTTOM w0.114: 129.17,87.21 v1(129.88,87.21) 131.98,87.21 131.99,87.23 132.54,87.23 132.56,87.21 133.12,87.21 133.99,88.09 135.94,88.09 CH15.1
PEG_HTX_GRX_P11: length 8.1
  BOTTOM w0.076: 129.66,87.85 129.19,87.85 128.99,88.05 128.71,88.05 128.46,87.8 127.9,87.8 127.66,88.04 127.66,88.19 UH1.B21
  BOTTOM w0.114: CH13.1 134.43,88.89 133.92,88.89 v1(133.37,88.34) 132.88,87.85 131.81,87.85 131.79,87.84 131.25,87.84 131.23,87.85 129.66,87.85
PEG_HTX_GRX_P12: length 10.2
  BOTTOM w0.076: UH1.B22 127.29,89.08 127.2,88.99 127.2,88.86 127.33,88.74 128.56,88.74 128.6,88.7 129.33,88.7 129.51,88.88
  BOTTOM w0.114: 129.51,88.88 129.84,88.88 130.15,89.19 130.32,89.19 130.34,89.21 130.88,89.21 130.9,89.19 132.87,89.19 v1(133.4,89.72) 133.8,90.12 135.94,90.12 CH11.1
PEG_HTX_GRX_P13: length 8.1
  BOTTOM w0.076: 129.45,89.45 128.54,89.45 128.45,89.36 127.91,89.36 127.69,89.58 127.69,89.74 127.57,89.86 UH1.B23
  BOTTOM w0.114: CH9.1 134.45,90.9 133.54,90.9 132.32,89.68 v1(131.94,89.68) 129.84,89.68 129.6,89.45 129.45,89.45
PEG_HTX_GRX_P14: length 10.7
  BOTTOM w0.076: UH1.B24 127.35,90.65 127.22,90.52 127.22,90.35 127.39,90.19 127.54,90.19 127.75,90.39 127.83,90.39 128.04,90.19 128.33,90.19 128.44,90.08 129.06,90.08 129.33,90.35 129.5,90.35
  BOTTOM w0.114: CH7.1 135.94,91.95 135.6,91.95 135.56,91.92 133.47,91.92 v1(132.46,90.92) 132.02,90.47 131.25,90.47 131.13,90.35 130.69,90.35 130.67,90.33 130.13,90.33 130.11,90.35 129.5,90.35
PEG_HTX_GRX_P15: length 8.3
  BOTTOM w0.076: UH1.B25 127.57,91.44 127.69,91.32 127.69,91.16 127.91,90.93 128.42,90.93 128.57,91.08 129.36,91.08 129.38,91.07 129.5,91.07
  BOTTOM w0.114: 129.5,91.07 129.88,91.07 130.59,91.77 130.7,91.77 130.71,91.76 131.26,91.76 131.28,91.77 131.67,91.77 132.46,92.56 v1(133.72,92.56) 133.93,92.56 134.33,92.95 134.43,92.95 CH5.1
PEG_RCOMP: length 8
  BOTTOM w0.152: UH1.G2 124.42,74.38 124.74,74.07 125.18,74.07 125.19,74.08 125.57,74.08 125.86,73.79 125.86,73.59 126.21,73.24 126.56,73.24
  BOTTOM w0.508: RH24.2 v4(127.59,70.7) 127.59,72.2 126.56,73.24
PEX_TERMP: length 4.4
  BOTTOM w0.114: UV1.AP29 154.34,99.41 154.32,99.43 v3(152.58,99.43) RV50.2
PG_+1.0VSP: length 7
  TOP w0.254: v2(229.47,42.51) 229.5,42.53 229.5,42.58 229.88,42.97 PR801.1 PR811.1
  BOTTOM w0.203: v2(229.47,42.51) 229.21,42.24 226.5,42.24 v3(225.77,42.97) 225.54,43.2 PU800.9
PIRQA#: length 7.3
  BOTTOM w0.076: RH90.1 172.17,19.57 172.17,20.2 v3(172.15,20.22) 172.02,20.35 171.72,20.35 171.32,20.75 171.32,21.46 171.76,21.9 171.76,23.49 171.84,23.57 171.84,24.03 171.6,24.27 171.31,24.27 UH2.AW17
PLTRST_CPU#: length 185.2
  IN3 w0.127: v2(85.78,98.59) 85.63,98.74 85.63,101.02 89.98,105.37 104.53,105.37 105.22,106.06 131.34,106.06 140.75,96.65 140.75,83.4 145.31,78.84 145.31,76.9 144.7,76.29 144.7,74.62 145.06,74.26 145.06,68.38 143.57,66.89 143.57,65.95 141.63,64.01 141.63,47.31 143.38,45.56 144.66,45.56 144.71,45.61 149.26,45.61 150.75,47.11 170.04,47.11 170.83,47.9 176.77,47.9 177.29,47.9 179.93,45.26 179.93,43.71 186.26,37.38 186.26,35.25 185.75,34.74 185.45,34.44 184.51,34.44 183.49,33.41 183.49,32.9 v2(182.53,31.94)
  BOTTOM w0.076: UH2.AK2 178.43,29.48 178.62,29.29 178.62,29.29 178.64,29.28 178.64,29.28 178.76,29.16 180.23,29.16 181.37,30.29 181.37,30.53 181.46,30.63
  BOTTOM w0.102: v2(85.78,98.59) 86.54,97.83 87.87,97.83 87.93,97.89 88.52,97.89 88.88,98.26 UH1.BP35 ; v2(182.53,31.94) 182.53,31.7 v3(181.69,30.86) 181.46,30.63
POWER_SW#_MB: length 170.3
  TOP w0.114: v2(291.22,58.41) 292.07,58.41 v4(292.35,58.69) ; v2(178.24,12.54) 178.18,12.47 JAPS.11 ; v2(206.96,34.85) 206.57,35.24 203.44,35.24 203.09,34.89 JPW.3
  IN3 w0.127: v2(291.22,58.41) 290.99,58.41 289.48,56.9 284.61,56.9 275.9,48.19 275.9,42.15 273.75,40 264.7,40 256.09,31.38 245.97,31.38 243.77,29.18 237.97,29.18 236.5,27.71 225.42,27.71 225.09,27.38 222.66,27.38 222.41,27.63 222.41,28.24 v2(222.25,28.39) 222.09,28.55 221.32,28.55 220.32,27.55 220.32,26.92 215.28,21.88 215.17,21.88 214.67,21.38 214.09,21.38 213.01,20.3 205.8,20.3 205.48,19.98 196.56,19.98 195.44,18.86 188.45,18.86 187.42,17.83 183.7,17.83 179.26,13.4 179.09,13.4 178.24,12.55 v2(178.24,12.54)
  IN4 w0.094: v2(206.96,34.85) 210.03,31.78 214.37,31.78 216.68,29.46 217.82,29.46 218.11,29.16 219.73,29.16 220.19,28.7 221.94,28.7 v2(222.25,28.39)
  BOTTOM w0.114: RE47.2 222.84,28.99 v2(222.25,28.39) ; v2(291.22,58.41) 291.09,58.54 291.09,62.86 292.62,64.38 SW5.1
