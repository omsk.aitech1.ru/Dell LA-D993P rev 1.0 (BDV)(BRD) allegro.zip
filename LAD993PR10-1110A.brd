# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
POWER_SW_IN#: length 3.7
  TOP w0.114: v2(222.39,30.47) 222.25,30.61 UE1.127
  BOTTOM w0.114: RE31.2 222.51,30.6 v2(222.39,30.47) 221.93,30.01 CE12.1 RE47.1
PQ703_S:
  vias: v2(34.93,18.53) v2(34.93,17.9) v2(34.93,17.26) v2(35.57,18.53) v2(35.57,17.9) v2(35.57,17.26) v2(36.2,18.53) v2(36.2,17.9) v2(36.2,17.26) v2(36.84,18.53) v2(36.84,17.9) v2(36.84,17.26) v2(37.47,18.53) v2(37.47,17.9) v4(41.35,23.05)
PROC_DETECT#: length 3.4
  TOP w0.114: RH89.1 155.24,34.72 156.2,34.72 v4(156.46,34.46) 156.64,34.28 v2(157.03,34.28)
  BOTTOM w0.102: v2(157.03,34.28) 157.15,34.16 157.3,34.16 UH2.Y44
PS_ID: length 243.2
  TOP w0.114: UE1.36 223.05,14.92 v2(223.2,14.77) ; PR102.2 16.72,27.42 PR101.2 17.03,26.23 17.03,24.48 16.26,23.71 16.26,21.68 14.74,20.16 v4(14.74,16.61) v2(14.74,15.57)
  IN3 w0.127: v2(60.21,17.07) 60.62,16.66 61.67,16.66 63.23,18.23 92.52,18.23 94.07,16.68 109.74,16.68 110.35,16.07 111.57,16.07 112.69,14.95 118.37,14.95 119.14,15.71 122.93,15.71 124.06,16.84 134.67,16.84 134.96,16.56 144.97,16.56 145.22,16.31 148.63,16.31 151.6,13.34 151.6,11.34 152.86,10.09 161.15,10.09 162.65,11.59 167.52,11.59 171.59,7.52 182.87,7.52 185.7,10.35 194.43,10.35 199.79,15.71 208.95,15.71 210.53,14.14 219.52,14.14 220.5,15.12 221.65,15.12 221.88,15.34 222.63,15.34 v2(223.2,14.77)
  IN4 w0.094: v2(14.74,15.57) 18.39,11.93 21.47,11.93 24.77,8.63 48.46,8.63 50.01,10.18 50.01,10.18 55.25,15.41 58.04,15.41 59.7,17.07 v2(60.21,17.07)
PSID: length 6
  TOP w0.114: PR114.1 v2(13.22,34.15) v3(12.6,34.15)
  BOTTOM w0.114: v2(13.22,34.15) 12.96,34.15 12.22,34.9 JADP10.4
PSID-1: length 3.1
  TOP w0.114: PQ101.2 11.88,25.41 PR105.1 11.68,25.61 11.68,26.17 11.62,26.23 PR103.2 v3(11.62,27.49)
PSID-2: length 5.8
  TOP w0.114: v3(14.72,23.08) 14.72,24.43 14.4,24.75 PQ101.1 13.4,25.76 PR104.1 PQ100.2
PTP_DIS#: length 129.7
  TOP w0.114: v2(242.86,23.41) 242.86,23.88 241.97,24.77 v3(241.5,24.77) 240.83,25.44 240.52,25.44 240.36,25.61 240.36,26.01 240.29,26.08 239.89,26.48 239.88,26.48 239.35,27.01 RE57.2
  IN3 w0.127: v2(242.86,23.41) 242.86,23.23 240.67,21.05 239.48,21.05 238.88,20.45 236.04,20.45 234.36,22.13 233.75,22.13 228.27,16.64 224.03,16.64 223.47,17.2 220.01,17.2 218.31,15.5 216.11,15.5 215.49,14.87 211.15,14.87 209.62,16.41 205.29,16.41 205.29,16.41 204.91,16.41 199.52,16.41 194.24,11.13 185.15,11.13 183.18,9.16 180.12,9.16 179.37,8.41 171.75,8.41 171.64,8.51 171.51,8.65 171.51,8.65 167.88,12.28 162.37,12.28 160.86,10.77 153.14,10.77 152.29,11.63 152.29,13.7 150.44,15.55 150.44,16.61 149.89,17.16 145.34,17.16 145.26,17.24 143.5,17.24 v2(142.72,18.03)
  BOTTOM w0.114: v2(142.72,18.03) 142.49,17.8 142.49,17.01 RE123.2 141.45,16.35 141.28,16.51 137.91,16.51 137.76,16.37 JTP.3
PTP_DIS#_R: length 2.6
  TOP w0.114: RE57.1 238.25,27.74 v3(237.44,27.74) UE1.90
PTP_INT#: length 113.9
  TOP w0.114: v2(168.31,20.11) 168.28,20.13 DH1.1 ; RE61.1 221.19,14.36 221.19,15.37 220.74,15.82 220.74,16.95 220.37,17.33 219.46,17.33 218.58,16.45 216.21,16.45 215.94,16.18 214.69,16.18 214.41,16.46 212.89,16.46 212.51,16.84 211.93,16.84 211.26,17.51 211.26,18.59 211.75,19.08 211.75,21.49 210.98,22.26 v2(210.98,24.53) ; QE13.1 133.1,16.54 132.88,16.77 132.88,17.92 133.41,18.46 137.64,18.46 138.81,19.63 141.44,19.63 v4(141.58,19.76) 142.33,20.51 v2(142.33,20.59)
  IN3 w0.127: v2(168.31,20.11) 169.42,20.11 170.14,19.4 171.6,19.4 171.83,19.63 174.51,19.63 174.78,19.36 177.78,19.36 178.39,18.75 181.68,18.75 182.82,19.89 186.4,19.89 191.24,24.73 210.78,24.73 v2(210.98,24.53)
  IN4 w0.094: v2(168.31,20.11) 168.31,20.41 167.44,21.29 166.94,21.29 166.75,21.1 166.4,20.75 164.64,20.75 164.24,20.36 162.45,20.36 161.92,19.82 156.18,19.82 153.56,22.45 153.56,24.18 151.97,25.76 147.36,25.76 142.33,20.73 v2(142.33,20.59)
PTP_INT#_EC: length 5
  TOP w0.114: v3(221.94,11.97) 221.61,12.3 RE61.2 221.79,13.02 222.03,13.26 222.03,13.46 RE53.1 222.16,14.28 222.16,14.91 221.85,15.22 UE1.33
PTP_INT#_R: length 4.4
  TOP w0.114: QE13.3 134.82,14 RE87.2 v2(135.96,14)
  BOTTOM w0.114: JTP.4 136.76,14.42 136.34,14 v2(135.96,14)
PWM1_GT: length 69.2
  TOP w0.114: v2(91.07,132.71) v3(90.41,132.71)
  IN4 w0.254: v2(91.07,132.71) 90.97,132.6 90.15,132.6 88,130.44 88,127.75 84.8,124.55 64.16,124.55 63.08,123.47 63.08,107.2 64.88,105.4 64.88,95.6 68.18,92.29 v2(68.29,92.29)
  BOTTOM w0.203: v2(68.29,92.29) 68.23,92.24 68.23,91.91 68.38,91.77 PU1100.12
  BOTTOM w0.254: PR1501.1 v2(91.07,132.71)
PWM1_VCORE: length 97
  TOP w0.114: v2(75.63,94.05) v4(75.63,94.71)
  IN4 w0.254: v2(122.29,132.73) 121.76,132.2 110.8,132.2 109.92,133.09 105.32,133.09 104.05,131.82 95.38,131.82 93.63,130.06 93.23,130.06 90.76,127.6 90.76,126.18 89.72,125.14 89.04,125.14 85.89,121.99 71.3,121.99 70.04,120.72 70.04,115.28 67.68,112.92 67.68,107.67 68.49,106.86 68.49,97.07 69.89,95.67 74.48,95.67 75.63,94.53 v2(75.63,94.05)
  BOTTOM w0.203: v2(75.63,94.05) 75.63,93.64 74.77,92.78 PU1100.25
  BOTTOM w0.254: PR1401.1 121.45,131.89 v2(122.29,132.73)
PWM2_GT: length 19.8
  BOTTOM w0.203: PU1100.13 69.54,92.94 69.48,93
  BOTTOM w0.254: 69.48,93 69.36,93.12 67.74,93.12 66.43,94.43 66.43,100.15 68.78,102.5 v4(68.78,103.79) 68.78,106.56 67.37,107.97 PR1513.1
PWM2_VCORE: length 88.4
  TOP w0.114: v2(75.27,92.52) 74.76,92.01 v4(74.03,92.01)
  IN4 w0.254: v2(75.27,92.52) 74.84,92.95 74.84,94.45 74.23,95.06 69.22,95.06 67.98,96.31 67.98,106.64 67.17,107.46 67.17,113.13 69.53,115.49 69.53,120.93 71.09,122.49 85.68,122.49 90.03,126.84 90.03,129.2 90.54,129.71 90.89,129.71 91.75,130.57 93.42,130.57 95.17,132.32 102.19,132.32 102.45,132.58 102.45,133.01 103.03,133.59 110.25,133.59 v2(111.01,132.83)
  BOTTOM w0.203: PU1100.26 75.2,91.37 75.45,91.61 75.45,91.89 75.27,92.07 v2(75.27,92.52)
  BOTTOM w0.254: PR1415.1 v2(111.01,132.83)
PWM3_VCORE: length 80.1
  IN4 w0.254: v2(94.19,132.78) 93,131.59 90.58,131.59 89.01,130.02 89.01,127.26 85.26,123.51 70.67,123.51 68.51,121.35 68.51,115.92 65.41,112.82 65.41,96.66 69.78,92.29 73.82,92.29 74.18,91.94 75.52,91.94 v2(75.8,92.22)
  BOTTOM w0.203: PU1100.27 75.24,90.97 75.83,91.56 75.83,92.19 v2(75.8,92.22)
  BOTTOM w0.254: v2(94.19,132.78) 94.49,133.07 v4(100.05,133.07) PR1429.1
PWM_SA: length 111.7
  TOP w0.114: v2(130.69,128.9) 130.69,129.31 v4(130.87,129.49)
  IN4 w0.254: v2(75.63,87.59) 75.42,87.59 74.53,88.48 74.53,90.11 76.36,91.94 76.36,95.08 73.92,97.53 71.86,97.53 70.49,98.89 70.49,103.11 69,104.61 69,107.07 68.18,107.88 68.18,112.71 70.55,115.07 70.55,120.51 71.51,121.48 86.1,121.48 89.25,124.63 89.93,124.63 91.86,126.55 91.86,127.97 92.81,128.92 94.45,128.92 95.01,129.48 95.01,130.72 95.59,131.31 104.2,131.31 104.99,132.1 110.19,132.1 110.59,131.69 123.1,131.69 123.28,131.87 129.93,131.87 131.18,130.62 131.18,129.38 v2(130.69,128.9)
  BOTTOM w0.203: PU1100.35 75.45,87.77 v2(75.63,87.59)
  BOTTOM w0.254: PR1532.2 v2(130.69,128.9)
REFADJ_NVVDD: length 3.2
  TOP w0.203: v2(177.12,56.23) 177.23,56.12 v3(177.77,56.12) 178.32,56.12
  TOP w0.254: PR1608.2 178.57,56.38 178.32,56.12
  BOTTOM w0.203: PU1600.6 177.49,55.73 177.64,55.87 177.64,56.16 177.49,56.31 177.2,56.31 v2(177.12,56.23)
REFADJ_NVVDDS: length 3.5
  TOP w0.203: PU1700.6 204.39,50.61 v2(203.71,49.93)
  BOTTOM w0.114: v2(203.71,49.93) v3(203.71,50.54)
  BOTTOM w0.203: v2(203.71,49.93) 203.46,49.68 PR1708.2
REFIN_NVVDD: length 4.6
  BOTTOM w0.114: PR1609.1 178.01,57.37 v3(177.84,57.55)
  BOTTOM w0.203: PU1600.7 178.13,55.33 178.23,55.42 178.32,55.51 PC1608.1 178.83,55.54 PR1607.1 178.83,57.35 PR1609.1
REFIN_NVVDDS: length 4.5
  TOP w0.203: PR1709.1 PR1707.1 PC1707.1 204.33,49.82 v3(204.53,50.03) 204.79,50.29 PU1700.7
REGN_CHG: length 35.7
  TOP w0.114: v3(26.55,40.34) 26.6,40.29 v2(26.6,39.74)
  TOP w0.254: PR205.1 47.14,42.07 v2(46.54,41.47)
  IN1 w0.508: v2(30.52,32.25) 30.25,32.51 30.25,34.7 29.47,35.47 28.53,35.47 27.8,36.21 27.8,39.13 27.19,39.74 v2(26.6,39.74)
  IN3 w0.254: v2(46.54,41.47) 46.24,41.16 46.24,40.85 43.53,38.14 39.53,38.14 38.06,39.61 26.73,39.61 v2(26.6,39.74)
  BOTTOM w0.254: PR316.1 25.59,40 26.35,40 v2(26.6,39.74)
REMOTE1+: length 119.5
  TOP w0.254: v2(138.21,77.26) 145.93,77.26 147.17,76.01 CT83.1 148.08,76.01 QT1.2 149.53,76.21 QT1.1
  BOTTOM w0.254: v2(138.21,77.26) 138.19,77.23 137.7,77.23 137.42,76.95 134.73,76.95 133.49,75.71 133.49,74.03 133.23,73.78 v4(133.23,72.3) 133.23,67.71 137.86,63.09 137.86,54.83 135.62,52.59 67.2,52.59 64.45,49.84 63.9,49.84 CT82.1 63.51,49.98 62.79,49.26 UT1.2
REMOTE1-: length 117.3
  TOP w0.254: QT1.3 148.08,75.1 CT83.2 146.59,75.1 145.02,76.67 v2(138.21,76.67)
  BOTTOM w0.254: v2(138.21,76.67) 137.93,76.39 134.96,76.39 v4(133.99,75.43) 133.99,73.82 133.74,73.57 133.74,67.93 138.36,63.3 138.36,55.04 138.36,54.62 138.31,54.57 136.34,52.59 135.83,52.09 67.41,52.09 64.66,49.33 64.03,49.33 CT82.2 63.39,49.06 63.08,48.76 UT1.3
REMOTE2+: length 190.4
  IN1 w0.254: v2(65.72,44.69) 65.79,44.63 65.79,42.2 67.19,40.79 67.19,29.98 67.22,29.96 67.22,28.14 68.42,26.93 68.42,25.46 68.13,25.17 68.13,23.21 69.63,21.7 69.63,21.55 69.63,21.55 69.63,21.1 70.04,20.69 98.52,20.69 98.79,20.42 138.09,20.42 138.7,21.03 140.78,21.03 141.71,20.1 146.75,20.1 147.97,18.89 155.52,18.89 156.13,18.27 158.6,18.27 162.83,22.51 166.93,22.51 168.34,21.1 168.72,21.1 170.25,19.57 170.34,19.57 170.35,19.57 170.75,19.57 170.8,19.62 172.98,19.62 173.32,19.97 174.34,19.97 175.14,19.17 186.59,19.17 187.13,19.7 198.23,19.7 200.01,21.48 205.78,21.48 206.06,21.2 210.14,21.2 v2(210.14,21.19)
  BOTTOM w0.254: QT3.1 214.78,14.18 QT3.2 212.59,14.18 CT84.1 212.17,14.61 211.65,14.61 211.1,15.16 211.1,18.3 210.24,19.16 210.24,21.1 v2(210.14,21.19) ; UT1.4 62.89,48.26 62.95,48.2 CT85.1 63.95,48.01 64.86,48.01 65.67,47.2 65.67,44.74 v2(65.72,44.69)
REMOTE2-: length 188.6
  IN1 w0.254: v2(210.82,21.17) 210.12,20.47 206.07,20.47 205.57,20.97 200.22,20.97 198.44,19.19 187.34,19.19 186.8,18.66 186.38,18.66 186.38,18.66 174.93,18.66 174.13,19.46 173.54,19.46 173.14,19.06 172.5,19.06 172.5,19.07 172.1,19.07 172.1,19.06 170.13,19.06 170.13,19.07 170.03,19.07 168.51,20.59 168.13,20.59 166.72,22 163.04,22 158.81,17.77 155.92,17.77 155.31,18.38 147.75,18.38 146.54,19.59 141.5,19.59 140.57,20.53 138.92,20.53 138.3,19.91 98.58,19.91 98.31,20.18 69.83,20.18 69.12,20.89 69.12,21.47 67.56,23.03 67.56,25.47 67.88,25.78 67.88,26.76 66.68,27.95 66.68,40.58 65.24,42.03 65.24,44.29 65.11,44.41 v2(65.11,44.69)
  BOTTOM w0.254: UT1.5 63.29,47.76 CT85.2 63.98,47.5 64.65,47.5 65.16,46.99 65.16,44.74 v2(65.11,44.69) ; v2(210.82,21.17) 210.75,21.09 210.75,19.37 211.6,18.51 211.6,15.37 211.86,15.11 212.19,15.11 CT84.2 213.35,15.3 QT3.3
RF_+1.35VS_VGAP: length 3.5
  BOTTOM w0.114: v3(137.67,110.06) 137.67,110.62 138.16,111.12 PR905.1
  BOTTOM w0.254: PR905.1 138.44,110.86 139.46,110.86 139.81,111.21 PU900.5
RING2: length 10.9
  TOP w0.203: HDA1.17 280.71,21.06 280.65,21 280.65,20.16 v2(280.3,19.8)
  IN1 w1.016: 289.05,18.66 288.06,19.65 283.09,19.65 282.1,18.66 281.04,18.66
  vias: v2(280.3,19.19) v2(289.95,18.96) v2(290.36,19.4) v3(290.92,20.09)
RING2_R: length 16.7
  TOP w0.102: v2(307.18,19.38) 307.18,19.91 v4(306.71,20.37)
  BOTTOM w1.016: DA4.2 295.97,19.9 296.76,20.69 305.87,20.69 v2(307.18,19.38) JHP1.3
ROM_CS: length 3.8
  TOP w0.102: v2(176.82,79.73) 177.27,80.19 179.7,80.19 T97.1
  BOTTOM w0.114: v2(176.82,79.73) 176.82,79.8 176.46,80.16 UV1.H6
ROM_SCLK: length 15
  TOP w0.102: v2(175.93,78.12) 176.26,78.12 176.72,77.66 177.01,77.66 177.17,77.5 177.17,77.16 177.41,76.93 v3(181.23,76.93) 183.12,76.93
  TOP w0.114: RV159.1 RV162.2 185.94,76.25 185.94,76.97 185.81,77.1 185.81,77.51 185.5,77.82 184.69,77.82 183.79,76.93 183.12,76.93
  BOTTOM w0.102: UV1.H4 176.29,78.48 v2(175.93,78.12)
ROM_SI: length 15.8
  TOP w0.102: v2(176.79,78.9) 177.17,78.53 183.76,78.53 183.78,78.55
  TOP w0.114: 183.78,78.55 184.04,78.81 186.22,78.81 v3(186.97,78.05) 188.04,76.98 188.04,76.2 RV160.2 RV157.1
  BOTTOM w0.114: UV1.H5 176.39,79.31 v2(176.79,78.9)
ROM_SO: length 17.7
  TOP w0.102: v2(176.79,80.64) 177.17,81.02 178.32,81.02 178.44,81.14
  TOP w0.114: RV158.1 189.62,74.95 189.4,75.17 189.4,75.65 189.24,75.81 189.24,76.22 RV161.2 188.6,76.85 188.6,77.46 185.95,80.11 185.4,80.11 v3(184.99,80.52) 184.37,81.14 178.44,81.14
  BOTTOM w0.114: v2(176.79,80.64) 176.42,81.01 UV1.H7
RTM_DCIN_ENB: length 6
  TOP w0.114: RM595.2 264.42,28.08 264.42,29.45 264.93,29.96 RM584.2 v3(264.93,31.14) 266.11,32.32 UM1.3
RTM_EQ: length 6.7
  TOP w0.114: v3(267.75,27.3) 267.24,27.3 RM594.2 266.33,28.21 266.33,29.48 RM585.2 266.91,30.06 UM1.5
RTM_HDMI_ID: length 5.1
  TOP w0.114: UM1.32 266.91,40.07 v3(267.05,40.21) 267.22,40.38 RM588.2 266.71,41.75 266.71,42.89 RM591.2
RTM_I2C_ADDR: length 5.8
  TOP w0.114: UM1.31 267.31,39.66 267.82,40.17 268.3,40.17 v3(268.38,40.25) 268.38,41.1 RM586.2 267.73,41.75 267.73,42.89 RM593.2
RTM_PDB: length 3.2
  TOP w0.114: RM589.2 265.82,30.95 266.51,31.64 v3(266.51,31.75) UM1.4
RTM_PRE: length 5.9
  TOP w0.114: RM592.2 270.39,43.53 270.77,43.14 270.77,42 RM587.2 270.01,40.49 v3(269.73,40.21) 268.91,39.39 UM1.27
RTM_RST#: length 7.4
  TOP w0.114: v3(262.76,43.42) RM590.2 263.79,43.3 263.28,42.79 263.28,41.65 CM24.1 263.79,40.12 264.18,39.73 265.44,39.73 265.71,39.45 UM1.35
RUNPWROK: length 3.7
  TOP w0.114: UE1.48 227.85,15.3 227.24,14.68 v2(227.24,14.54)
  BOTTOM w0.114: RE62.2 v4(227.01,13.97) 227.01,14.32 v2(227.24,14.54)
SATA_LED_EN: length 49
  TOP w0.114: v2(221.74,14.71) 221.57,14.89 221.57,18.17 221.2,18.54 UE1.30 219.37,18.54 219.23,18.41 217.56,18.41 RE108.2 ; QE21.5 QE21.6 253.78,26.3 v3(253.78,25.76) 253.78,25.67 252.87,24.76 249.83,24.76 248.14,23.08 v2(248.14,23.21)
  IN1 w0.094: v2(221.74,14.71) 222.09,14.37 223.78,14.37 224.97,15.55 233.21,15.55 236.09,18.43 238.08,18.43 238.84,19.19 241.36,19.19 242.4,20.23 244.87,20.23 245.36,20.72 245.36,22.11 245.36,22.44 246.2,23.28 248.07,23.28 v2(248.14,23.21)
SATA_PRX_DTX_N1B: length 57.3
  TOP w0.114: CS25.1 192.49,17.8 192.49,20.36 193.29,21.16 193.29,28.22 193.39,28.32 193.39,29.94 194.59,31.14 194.59,31.3 v2(194.38,31.5)
  IN1 w0.094: v2(194.38,31.5) 194.63,31.25 194.63,31.09 194.51,30.97 192.35,30.97 192.19,31.14 190.78,31.14 186.65,35.27 186.61,35.27 186.6,35.28 183.1,35.28 182.23,36.14 182.23,36.68 181.74,37.18 178.96,37.18 178.12,38.02 176.15,38.02 172.04,42.14 161.15,42.14 160.85,41.83 160.32,41.83 159.98,41.49 159.98,41.27 v2(159.78,41.06)
  BOTTOM w0.102: UH2.D39 160.3,41.92 160.3,41.78 159.99,41.46 159.99,41.23 159.82,41.06 v2(159.78,41.06)
SATA_PRX_DTX_N1B_RC: length 4.5
  TOP w0.114: CS25.2 192.77,15.94 192.77,15.17 192.78,15.15 192.78,14.72 192.59,14.53 192.59,14.26 v2(192.23,13.9)
  BOTTOM w0.114: v2(192.23,13.9) 192.17,13.97 JHDD1.8
SATA_PRX_DTX_P1B: length 57.3
  TOP w0.114: CS26.1 192.72,17.8 192.72,20.27 193.51,21.07 193.51,28.13 193.61,28.22 193.61,29.84 194.81,31.04 194.81,31.29 v2(195.02,31.5)
  IN1 w0.094: v2(160.36,41.06) 160.16,41.26 160.16,41.42 160.4,41.65 160.93,41.65 161.23,41.95 171.96,41.95 176.07,37.84 178.04,37.84 178.88,36.99 181.66,36.99 182.05,36.61 182.05,36.06 183.02,35.09 186.53,35.09 186.54,35.08 186.57,35.08 190.7,30.95 192.11,30.95 192.27,30.79 194.59,30.79 194.82,31.02 194.82,31.3 v2(195.02,31.5)
  BOTTOM w0.102: v2(160.36,41.06) 160.19,41.23 160.19,41.38 160.64,41.82 160.89,41.82 UH2.E37
SATA_PRX_DTX_P1B_RC: length 4.5
  TOP w0.114: CS26.2 193.01,16.51 v1(193.01,15.53) 193.01,14.63 192.82,14.44 v2(192.82,13.9)
  BOTTOM w0.114: JHDD1.7 192.67,13.17 192.67,13.76 v2(192.82,13.9)
SATA_PRX_SSDTX_N0A: length 57.6
  IN4 w0.094: v2(200.03,33.26) 200.14,33.26 200.38,33.02 200.38,32.86 200.29,32.76 199.24,32.76 197.1,34.9 187.56,34.9 187.32,34.66 181.6,34.66 181.11,35.15 180.1,36.16 178.34,36.16 177.61,35.43 174.61,35.43 173.63,36.41 173.63,37.88 173.15,38.35 172.26,38.35 171.82,38.79 167.37,38.79 166.51,37.94 164.84,37.94 164.78,38 164.32,38 164.09,38.22 164.09,40 163.88,40.21 163.59,40.21 163.44,40.36 v2(163.44,40.53)
  BOTTOM w0.101: UH2.G31 163.89,40.95 v2(163.44,40.53)
  BOTTOM w0.114: JNGFF2.43 206.23,26.33 205.98,26.57 205.95,26.57 205.57,26.95 205.57,26.98 205.35,27.2 205.35,27.89 203.58,29.67 203.58,30.73 201.8,32.51 200.53,32.51 200.19,32.84 200.19,33.11 v2(200.03,33.26)
SATA_PRX_SSDTX_P0A: length 57.5
  IN4 w0.094: v2(200.8,33.26) 200.57,33.04 200.57,32.78 200.37,32.58 199.16,32.58 197.02,34.72 187.63,34.72 187.39,34.48 181.53,34.48 181.23,34.78 180.03,35.97 178.42,35.97 177.69,35.25 174.53,35.25 173.44,36.34 173.44,37.8 173.08,38.17 172.18,38.17 171.74,38.61 167.44,38.61 166.59,37.75 164.76,37.75 164.7,37.81 164.24,37.81 163.91,38.14 163.91,39.92 163.81,40.03 163.68,40.03 v2(163.46,39.81)
  BOTTOM w0.101: v2(163.46,39.81) 163.87,40.19 UH2.H31
  BOTTOM w0.114: v2(200.8,33.26) 200.62,33.26 200.42,33.06 200.42,32.93 200.62,32.73 201.89,32.73 203.8,30.82 203.8,29.76 205.57,27.99 205.57,27.3 v1(205.93,26.93) 206.32,26.55 207.57,26.55 207.85,26.83 JNGFF2.41
SATA_PTX_DRX_N1B: length 54.7
  TOP w0.114: v2(193.19,31.49) 192.96,31.27 192.96,28.54 192.87,28.45 192.87,21.53 191.92,20.58 191.92,20.39 190.83,19.29 190.83,17.78 CS27.1
  IN1 w0.094: v2(159.97,42.58) 160.2,42.81 160.2,42.92 160.58,43.3 172.09,43.3 175.54,39.85 176.95,39.85 177.47,39.33 179.43,39.33 180.48,38.28 180.91,38.28 181.4,37.79 182.35,37.79 183.24,36.9 185.84,36.9 190.32,32.42 192.56,32.42 193,31.98 193,31.68 v2(193.19,31.49)
  BOTTOM w0.089: v2(159.97,42.58) 160.02,42.58 160.61,43.16 UH2.B38
SATA_PTX_DRX_N1B_RC: length 4.5
  TOP w0.114: CS27.2 190.7,16.11 190.59,16.11 190.48,15.99 v1(190.48,15.51) 190.48,14.61 190.58,14.51 190.58,14.24 v2(190.89,13.93)
  BOTTOM w0.114: JHDD1.10 191.17,14.21 v2(190.89,13.93)
SATA_PTX_DRX_P1B: length 54.7
  TOP w0.114: v2(192.42,31.49) 192.73,31.18 192.73,28.63 192.65,28.54 192.65,21.62 191.7,20.67 191.7,20.48 190.6,19.39 190.6,17.81 CS28.1
  IN1 w0.094: v2(192.42,31.49) 192.55,31.49 192.81,31.76 192.81,31.91 192.48,32.24 190.24,32.24 185.76,36.71 183.16,36.71 182.27,37.6 181.32,37.6 180.83,38.1 180.4,38.1 179.35,39.14 177.39,39.14 176.87,39.66 175.46,39.66 172.02,43.11 160.66,43.11 160.39,42.84 160.39,42.41 160.56,42.24 v2(160.68,42.24)
  BOTTOM w0.089: UH2.C38 160.38,42.46 160.38,42.26 160.47,42.17 160.62,42.17 v2(160.68,42.24)
SATA_PTX_DRX_P1B_RC: length 4.6
  TOP w0.114: v2(190.29,13.93) 190.36,14 190.36,14.42 190.26,14.52 190.26,15.15 190.24,15.17 190.24,15.78 190.26,15.79 CS28.2
  BOTTOM w0.114: JHDD1.11 190.67,13.03 190.67,13.55 v2(190.29,13.93)
SATA_PTX_SSDRX_N0A: length 50.3
  IN1 w0.094: v2(163.92,45.1) 163.67,45.35 163.67,45.92 163.98,46.24 167.77,46.24 168.02,46.49 170.64,46.49 171.95,47.8 178.59,47.8 179.64,48.85 189.8,48.85 196.67,41.98 196.67,40.73 196.47,40.53 195.89,40.53 195.72,40.71 195.72,40.88 195.89,41.06 v2(196.05,41.06)
  BOTTOM w0.076: v2(163.92,45.1) 163.71,44.9 163.71,44.77 164.01,44.48 164.01,43.89 164.12,43.77 164.12,43.13 163.94,42.94 UH2.C31
  BOTTOM w0.114: CD53.1 199.07,36.24 v1(199.07,37.68) 199.07,38.27 196.48,40.86 196.25,40.86 v2(196.05,41.06)
SATA_PTX_SSDRX_N0A_C: length 17.2
  BOTTOM w0.114: JNGFF2.47 207.81,25.33 207.59,25.11 206.79,25.11 206.77,25.12 206.23,25.12 206.21,25.11 205.83,25.11 204.91,26.03 204.91,27.71 203.13,29.49 203.13,30.58 201.67,32.04 v1(200.81,32.04) 199.7,32.04 198.73,33.02 198.73,34.33 CD53.2
SATA_PTX_SSDRX_P0A: length 50.3
  IN1 w0.094: v2(196.05,40.12) 196.27,40.35 196.55,40.35 196.86,40.66 196.86,42.05 189.87,49.04 179.57,49.04 178.52,47.99 171.87,47.99 170.56,46.68 167.95,46.68 167.69,46.42 163.91,46.42 163.48,46 163.48,45.25 v2(163.33,45.1)
  BOTTOM w0.076: UH2.B31 163.76,43.14 163.66,43.14 163.59,43.22 163.59,43.37 163.71,43.5 163.88,43.5 163.96,43.58 163.96,43.7 163.84,43.82 163.84,44.41 163.55,44.7 163.55,44.88 v2(163.33,45.1)
  BOTTOM w0.114: CD51.1 198.85,36.25 198.85,37.4 198.83,37.41 198.83,37.95 198.85,37.96 198.85,38.18 196.39,40.64 196.18,40.64 196.05,40.5 v2(196.05,40.12)
SATA_PTX_SSDRX_P0A_C: length 17.2
  BOTTOM w0.114: JNGFF2.49 207.8,24.83 207.74,24.88 v1(206.5,24.88) 205.74,24.88 204.69,25.93 204.69,27.62 202.91,29.39 202.91,30.49 201.58,31.82 201.1,31.82 201.08,31.8 200.54,31.8 200.52,31.82 199.61,31.82 198.51,32.92 CD51.2
SDZ_MUTE#: length 20.7
  TOP w0.114: v2(267.93,25.29) 263.33,25.29 259.78,21.73 v2(259.78,20.79)
  BOTTOM w0.114: v2(267.93,25.29) 267.93,25.42 v3(269.35,26.84) 269.76,27.24 272.35,27.24 272.65,27.55 D2.1 ; UA2.29 260.67,19.04 260,19.7 260,20.21 259.78,20.44 v2(259.78,20.79) 259.67,20.89 RA74.2
SIO_EXT_SCI#: length 92
  TOP w0.114: v2(231.86,23.21) 231.89,23.21 232.92,22.17 232.92,20.84 234.44,19.32 234.44,18.69 234.99,18.14 UE1.66 ; v2(164.42,26.3) 163.94,26.79 163.94,26.91 163.69,27.17 163.26,27.17 v3(162.43,26.34) 162.43,26.19 162.09,25.85 162.09,25.44 162.82,24.7 162.82,22.96 162.72,22.86 162.72,22.84 162.48,22.59 162.46,22.59 161.66,21.8 161.66,21.36 161.1,20.79 160.69,20.79 159.81,19.91 159.81,19.07 RH10.2
  IN1 w0.094: v2(164.42,26.3) 165.31,25.42 166.31,25.42 166.38,25.49 166.97,25.49 168.69,23.76 169.44,23.76 169.92,23.29 170.58,23.29 170.77,23.49 171.73,23.49 172.24,22.98 178.19,22.98 178.5,22.67 180.63,22.67 180.91,22.96 187.06,22.96 187.65,23.54 189.55,23.54 189.88,23.88 197.95,23.88 198.59,24.51 210.07,24.51 210.46,24.12 211.95,24.12 212.61,24.78 216.08,24.78 216.57,24.29 216.72,24.15 223.07,24.15 223.86,23.36 231.71,23.36 v2(231.86,23.21)
  BOTTOM w0.089: UH2.AV29 165.05,25.68 v2(164.42,26.3)
SIO_EXT_SMI#: length 80.6
  TOP w0.114: RH110.1 155.26,31.91 156.42,31.91 v3(156.74,31.58) 157.29,31.03 159.11,31.03 159.17,30.97 159.24,30.97 v2(159.62,30.58) ; UE1.10 219.41,26.54 218.09,27.86 215.15,27.86 213.83,26.53 v2(213.83,26.28)
  IN3 w0.127: v2(213.83,26.28) 212.52,24.97 191.16,24.97 186.31,20.12 182.73,20.12 181.58,18.97 178.49,18.97 177.87,19.59 174.87,19.59 174.6,19.86 171.74,19.86 171.66,19.78 171.64,19.78 171.49,19.62 170.27,19.62 169.35,20.54 168.67,20.54 167.2,22.01 166.18,22.01 164.64,23.55 164.32,23.55 163.97,23.9 163.97,29.66 163.61,30.01 163.61,30.75 163.23,31.13 160.17,31.13 v2(159.62,30.58)
  BOTTOM w0.089: v2(159.62,30.58) 159.36,30.66 159.13,31.08 UH2.AF41
SIO_EXT_WAKE#: length 88.2
  TOP w0.114: UE1.116 226.65,32.91 v2(226.78,33.04)
  IN3 w0.127: v2(226.78,33.04) 224.83,31.08 219.84,31.08 219.69,30.93 218.66,30.93 217.18,29.45 217.18,28.72 211.72,23.26 204.51,23.26 203.92,23.84 191.44,23.84 186.8,19.21 183.13,19.21 181.35,17.43 178.74,17.43 178.1,18.06 171.55,18.06 170.9,18.71 169.6,18.71 169.29,19.03 167.13,19.03 166.49,19.66 166.49,19.95 166.01,20.44 164.65,20.44 163.06,22.02 162.7,22.02 160.01,24.72 159.36,24.72 155.82,28.26 v2(155.64,28.26)
  BOTTOM w0.114: RH91.2 155.29,28.32 155.57,28.32 v2(155.64,28.26) 156.14,28.26 156.76,27.64 UH2.AN44 ; v3(226.29,33.16) 226.42,33.04 v2(226.78,33.04)
SIO_PWRBTN#: length 69.4
  TOP w0.114: v2(227.75,25.13) 227.22,24.6 227.22,21.89 227.85,21.25 227.85,18.29 228.88,17.26 229.26,17.26 229.45,17.07 UE1.52 ; v2(173.64,26.15) 173.64,26.97 174.18,27.5 v3(174.37,27.5)
  IN1 w0.094: v2(173.64,26.15) 173.85,26.36 175.34,26.36 176.27,25.43 177.28,25.43 177.47,25.62 180.36,25.62 180.5,25.76 183.98,25.76 184.76,24.98 189.37,24.98 189.73,24.62 197.73,24.62 198.21,25.1 210.15,25.1 210.59,25.53 216.32,25.53 217.18,24.68 223.31,24.68 224.34,25.71 227.14,25.71 227.72,25.14 227.75,25.14 v2(227.75,25.13)
  BOTTOM w0.089: UH2.AT13 173.49,26.33 173.64,26.18 v2(173.64,26.15)
SIO_RCIN#: length 72.4
  TOP w0.114: RH87.1 180.71,24.91 v3(180.71,25.9) 180.58,26.03 v2(180.17,26.03) ; UE1.53 229.85,17.02 229.4,17.47 228.97,17.47 228.07,18.37 228.07,21.34 227.44,21.98 227.44,24.13 228.34,25.03 v2(228.34,25.14)
  IN1 w0.094: v2(228.34,25.14) 227.94,25.53 227.61,25.53 227.19,25.95 224.24,25.95 223.16,24.87 217.26,24.87 216.4,25.73 210.51,25.73 210.07,25.3 198.13,25.3 197.65,24.82 189.81,24.82 189.45,25.18 184.84,25.18 184.04,25.97 180.22,25.97 v2(180.17,26.03) 179.76,26.44 175.98,26.44 175.81,26.6 172.37,26.6 171.59,25.82 v2(171.31,25.82)
  BOTTOM w0.102: v2(171.31,25.82) 170.98,26.15 UH2.AT17
SIO_SLP_A#: length 15.5
  TOP w0.114: v2(171.7,21.26) 171.92,21.26 172.31,20.86 v3(172.31,19.75) 171.84,19.28 171.84,15.24 171.68,15.08 171.68,14.49 172.62,13.55 175.22,13.55 175.93,12.85 175.93,12.29 175.68,12.04 JAPS.6
  BOTTOM w0.076: v2(171.7,21.26) 171.66,21.29 171.66,21.53 171.92,21.79 171.92,22.52 172.06,22.66 UH2.BC15
SIO_SLP_S0#: length 28.6
  TOP w0.114: JAPS.15 180.18,10.6 178.61,9.03 174.53,9.03 173.21,10.35 172.76,10.35 168.23,14.89 165.82,14.89 164.91,15.8 164.91,17.39 164.13,18.16 164.13,20.22 164.6,20.69 v3(165.02,20.69) 165.62,20.69 166.01,21.09 v2(166.01,21.28)
  BOTTOM w0.076: UH2.BC26 166.09,22.67 166.09,21.36 v2(166.01,21.28)
SIO_SLP_S3#: length 439.3
  TOP w0.114: v2(68.77,53.1) 72.07,53.1 75.02,50.16 75.02,48.61 74.69,48.28 UZ16.3 ; v2(67.27,26.63) 67.46,26.44 QV2.2 ; UZ1.3 216.06,12.54 216.07,12.53 216.63,12.53 216.88,12.78 v2(216.88,12.93) 216.48,13.33 215.92,13.33 215.9,13.34 UZ1.5 ; v2(63.95,62.44) RZ107.1 63.09,63.21 DZ2.1 ; v2(186.89,23.36) 187.17,23.64 UZ21.2 ; v2(172.58,24.5) 172.91,24.17 172.91,22.33 172.6,22.02 172.29,22.02 172.17,21.91 171.51,21.91 170.94,21.35 170.94,19.82 171.19,19.56 171.19,15.51 171.03,15.35 171.03,14.22 172.35,12.91 173.01,12.91 v2(173.46,12.45) 173.68,12.24 JAPS.2 ; UE1.23 219.03,21.34 218.67,21.71 CE74.1 216.75,21.2 215.91,21.2 215.74,21.03 214.73,21.03 214.4,21.36 212.89,21.36 211.57,22.68 v2(211.57,24.53)
  IN1 w0.094: v2(211.57,24.53) 211.57,24.88 211.33,25.12 210.73,25.12 210.31,24.71 198.44,24.71 197.85,24.12 189.78,24.12 189.4,23.74 187.27,23.74 v2(186.89,23.36) ; v2(65.92,34.66) 65.92,31.92 66.25,31.59 66.25,27.77 67.27,26.75 v2(67.27,26.63) 67.04,26.4 67.04,20.61 67.91,19.74 98.02,19.74 98.61,19.15 100.1,19.15 v2(100.59,18.66)
  IN3 w0.127: v2(172.58,24.5) 172.58,24.15 173.54,23.18 175.32,23.18 175.63,22.88 177.58,22.88 178.8,24.1 186.15,24.1 v2(186.89,23.36) ; v2(173.46,12.45) 173.46,12.96 173.28,13.15 170.37,13.15 169.62,13.9 161.33,13.9 159.48,15.75 159.48,16.82 158.24,18.06 156.25,18.06 155.52,18.79 153.09,18.79 151.92,19.95 147.97,19.95 146.92,18.91 136.14,18.91 134.76,17.53 116.1,17.53 115.24,16.67 110.51,16.67 109.1,18.07 101.18,18.07 v2(100.59,18.66) ; v2(211.57,24.53) 212.67,24.53 216.32,28.18 216.32,30.22 217.26,31.16 219.59,31.16 219.75,31.31 224.62,31.31 226.17,32.86 226.17,33.19 227.59,34.61 233.64,34.61 236.18,32.07 243.15,32.07 246.33,35.25 252.89,35.25 258.12,40.48 v2(258.12,41.06) ; v2(132.18,102.52) 131.32,103.37 90.17,103.37 88.78,101.98 88.78,99.77 88.27,99.26 88.27,96.86 85.86,94.45 85.86,91.09 86.73,90.22 86.73,89.04 86.09,88.41 86.09,86.69 82.76,83.36 82.76,81.23 80.47,78.94 73.29,78.94 70.61,76.25 70.61,75.81 63.31,68.51 63.31,63.53 63.95,62.88 v2(63.95,62.44)
  IN4 w0.094: v2(65.92,34.66) 66.11,34.85 66.11,38.92 65.35,39.68 65.35,41.01 66.11,41.77 66.11,44.25 67.19,45.33 67.19,50.99 68.55,52.35 68.55,52.89 v2(68.77,53.1)
  BOTTOM w0.102: v2(172.58,24.5) 172.25,24.5 UH2.AW15
  BOTTOM w0.114: v2(211.57,24.53) 211.57,24.49 211.04,23.95 211.04,23.63 209.56,22.15 209.56,21 209.8,20.76 209.8,18.98 210.66,18.12 210.66,14.3 212.6,12.36 216.3,12.36 v2(216.88,12.93) ; v2(68.77,53.1) 68.72,53.15 68.72,54.35 63.56,59.5 v4(63.56,61.01) 63.56,62.05 v2(63.95,62.44) ; v2(258.12,41.06) 261.21,37.98 261.21,34.29 264.22,31.29 264.22,30.24 263.9,29.92 QA1.2 ; v2(100.59,18.66) 100.59,18.51 PR511.1 ; v2(132.18,102.52) 132.55,102.14 UZ9.4
SIO_SLP_S4#: length 246.3
  TOP w0.114: v2(149.77,26.43) 147.71,24.37 147.71,19.85 v2(148.17,19.39) 148.69,18.87 149.65,18.87 RZ102.1 150.39,19.31 DZ1.1 ; v2(171.92,20.7) 171.92,20.46 171.93,20.46 171.93,19.67 171.63,19.36 171.63,15.33 171.47,15.17 171.47,14.4 172.53,13.34 175.13,13.34 175.71,12.76 175.71,12.39 175.18,11.85 JAPS.5 ; UZ15.4 129.72,99.1 v2(129.61,98.99) ; UE1.67 237.87,18.54 238.09,18.77 238.09,20.49 238.8,21.2 240.77,21.2 241.68,20.28 243.75,20.28 244.26,20.79 244.26,21.05 244.76,21.55 244.76,23.06 243.99,23.82 243.99,25.83 242.82,27.01 242.82,27.44 243.18,27.81 243.18,28.75 241.89,30.04 241.89,31.4 240.55,32.74 240.55,33.07 237.94,35.67 237.94,36.12 235.85,38.22 231.12,38.22 v4(230.26,37.36) 229.98,37.07 v2(229.98,36.12)
  IN1 w0.094: v2(145.22,37.86) 148.51,34.58 148.51,27.69 v2(149.77,26.43)
  IN3 w0.127: v2(129.61,98.99) 129.61,95.2 130.29,94.53 131.11,94.53 133.41,92.23 133.41,83.05 136.05,80.4 136.05,74.22 135.92,74.09 135.92,69.88 135.92,69.35 138.58,66.69 138.58,45.11 145.22,38.47 v2(145.22,37.86) ; v2(229.98,36.12) 229.98,35.6 229.37,34.99 227.64,34.99 225.74,33.09 225.74,32.75 224.53,31.54 219.84,31.54 219.84,31.54 219.65,31.54 219.65,31.53 217.3,31.53 216.09,30.32 216.09,28.88 213.94,26.74 212.51,26.74 211.18,25.41 191.25,25.41 187.02,21.17 185.63,21.17 184.81,20.35 182.63,20.35 181.49,19.2 178.62,19.2 178,19.81 174.97,19.81 174.66,20.12 172.51,20.12 v2(171.92,20.7)
  IN4 w0.094: v2(171.92,20.7) 171.48,20.7 171.01,21.17 170.49,21.17 169.88,20.56 168.87,20.56 167.8,21.63 166.5,21.63 166.45,21.68 165.29,21.68 164.16,20.55 162.37,20.55 161.87,20.05 156.27,20.05 153.75,22.57 153.75,24.31 152.05,26 150.2,26 v2(149.77,26.43)
  BOTTOM w0.076: UH2.BD15 172.11,22.32 172.11,21.74 172.07,21.7 172.07,20.85 v2(171.92,20.7)
  BOTTOM w0.114: PR1801.1 147.59,16.75 147.59,17.75 148.17,18.33 v2(148.17,19.39)
SIO_SLP_S5#: length 17.6
  TOP w0.114: JAPS.4 174.68,11.88 173.44,13.12 172.44,13.12 171.25,14.31 171.25,15.26 171.41,15.42 171.41,19.45 171.71,19.76 171.71,20.37 171.31,20.77 171.31,21.42 171.58,21.69 172.28,21.69 172.36,21.77 172.72,21.77 173.25,22.3 v3(173.25,23.08) 173.25,23.56 173.13,23.68 173.13,24.09 v2(173.54,24.5)
  BOTTOM w0.089: UH2.BA13 173.47,24.43 v2(173.54,24.5)
SIO_SLP_WLAN#: length 2.2
  TOP w0.114: v2(172.6,26.15) 172.6,26.58 T4934.1
  BOTTOM w0.089: v2(172.6,26.15) 173.09,25.67 UH2.AV13
SKU_ID: length 4.7
  TOP w0.114: v2(227.39,33.04) 227.45,32.98 UE1.114
  BOTTOM w0.114: CE104.1 227.34,32.98 v2(227.39,33.04) v3(227.8,33.45) ; CE104.1 227.31,32.1 RE124.2 ; CE104.1 227.31,32.15 RE125.2
SLEEVE: length 18.6
  TOP w0.203: HDA1.18 281.11,20.92 280.97,20.78 280.97,19.99 v2(281.19,19.78)
  IN4 w1.016: 286.85,22.09 286.85,22.15 287.22,22.52 288.66,22.52 289.54,21.63 289.54,21.5 292.49,18.56 293.28,18.56 294.09,19.37 295.99,19.37 296.16,19.19 296.17,19.19 296.78,18.58 296.78,16.32 297.6,15.51 297.6,14.94
  vias: v2(281.72,19.52) v2(286.34,21.58) v2(286.34,20.97) v2(298.08,14.21) v2(298.08,13.58) v4(284.9,20.07)
SLEEVE_R: length 13.2
  TOP w0.102: v2(296.45,10.44) 297.69,10.44 298.54,11.29 v4(298.54,11.78)
  BOTTOM w1.016: JHP1.4 307.18,7.86 298.9,7.86 298.71,8.05
SM_PG_CTRL: length 114.5
  TOP w0.114: v2(81.29,81.14) 81.29,78.81 v3(85.13,74.97) 85.71,74.39 85.71,65.23 75.86,55.38 67.6,55.38 67.35,55.13 67.34,55.13 65.51,53.3 65.51,49.99 66.18,49.32 66.18,44.34 65.9,44.06 v2(64.65,44.06)
  IN1 w0.094: v2(64.65,44.06) 64.81,43.91 64.81,40.4 65.64,39.56 65.64,35.42 65.34,35.12 65.34,31.94 65.95,31.33 65.95,27.73 66.8,26.87 66.8,20.51 67.81,19.5 68.42,19.5 68.42,19.5 97.92,19.5 v2(98.7,18.72)
  BOTTOM w0.114: v2(81.29,81.14) 81.4,81.26 RH93.2 ; v2(98.7,18.72) 98.7,17.53 PR509.1
  BOTTOM w0.305: UC1.4 81.42,81.81 RH93.2
SMBALERT#: length 3.9
  TOP w0.114: v2(159.26,23.54) 159.26,23.4 158,22.14 v3(157.91,22.14) 157.91,22.14 157.11,21.34 RH66.2
  BOTTOM w0.089: UH2.BB41 159.25,23.49 v2(159.26,23.54)
SMBCLK: length 11.7
  TOP w0.114: RH21.2 149.6,21.37 QH4.6 150.76,21.37 151.16,21.78 151.16,23.14 151.5,23.47 153.41,23.47 v3(153.62,23.68) 153.75,23.81 154.2,23.81 154.56,24.17 155.23,24.17 155.71,24.65 v2(155.71,25.24)
  BOTTOM w0.089: v2(155.71,25.24) 155.71,25.57 155.84,25.69 156.5,25.69 157.05,25.14 157.41,25.14 UH2.AW44
SMBDATA: length 6.1
  TOP w0.114: QH4.3 153.56,22.67 RH22.2 154.05,23.17 154.44,23.17 154.82,23.55 v3(156.87,23.55) 157.58,23.55 v2(157.69,23.66)
  BOTTOM w0.076: v2(157.69,23.66) 157.83,23.51 UH2.BB43
SML0_SMBCLK: length 7.8
  BOTTOM w0.089: 154.19,24.45 155.31,24.45 155.46,24.61 157.32,24.61 157.64,24.28 UH2.AY44
  BOTTOM w0.114: RH62.2 152.17,26.72 152.17,26.14 v3(153.08,25.22) 153.86,24.45 154.19,24.45
SML0_SMBDATA: length 3.8
  TOP w0.114: v2(160.16,22.98) 159.29,22.98 158,21.69 RH63.2
  BOTTOM w0.089: UH2.BB39 160.16,23 v2(160.16,22.98)
SML0ALERT#: length 4.5
  TOP w0.114: RH64.2 161.14,24.25 161.45,24.55 161.46,24.55 v3(161.46,24.55) 161.52,24.61 v2(161.52,25.06)
  BOTTOM w0.089: UH2.BA40 161.17,24.04 161.52,24.39 161.52,25.05 v2(161.52,25.06)
SML1_SMBCLK: length 7.7
  TOP w0.114: v2(158.24,24.92) 158.24,24.73 RH23.2 157.4,24.29 157.04,24.64 156.36,24.64 v2(155.97,24.25)
  BOTTOM w0.089: UH2.AW42 158.31,24.99 v2(158.24,24.92)
  BOTTOM w0.114: v2(155.97,24.25) 155.58,23.87 154.65,23.87 154.58,23.81 v3(153.12,23.81) QH5.1
SML1_SMBDAT: length 12.3
  TOP w0.114: RH25.2 157.39,25.24 v2(156.35,25.24)
  BOTTOM w0.089: v2(156.35,25.24) 156.68,24.91 UH2.AW45
  BOTTOM w0.114: QH5.4 150.62,26.26 150.31,26.56 150.31,27.49 150.5,27.68 152.03,27.68 v3(152.7,27.01) 152.7,26.5 154.04,25.16 155.1,25.16 155.46,24.81 155.92,24.81 v2(156.35,25.24)
SML1ALERT#: length 3.1
  TOP w0.114: v2(165.72,25.87) 165.64,25.87 165.14,26.38 v3(165.14,26.79) 165.14,27.98 RH65.2
  BOTTOM w0.089: UH2.AT27 166.05,26.15 165.77,25.87 v2(165.72,25.87)
SNUB_1VALWP: length 1.2
  TOP w0.114: PC600.1 v3(254.84,10.75)
SNUB_3V: length 1.3
  BOTTOM w0.114: PC418.1 v4(67.13,7.61)
SNUB_5V: length 1.2
  TOP w0.114: PC419.1 v3(44.9,35)
SNUB_+0.95VSP: length 1.6
  BOTTOM w0.127: PC700.1 v4(61.15,69.31)
SNUB_+1.0VSP: length 3
  TOP w0.127: v3(230.01,41.4) 229.33,41.4 228.95,41.77 PC800.1
  TOP w0.254: PR802.2 227.85,41.77 PC800.1
SNUB_+1.8VSP: length 1.1
  TOP w0.127: PC1000.1 v3(210.58,114.89)
SNUB_CHG: length 1.4
  TOP w0.114: PR315.2 v3(24.9,27.07)
SPKR: length 121.7
  TOP w0.114: RH82.2 165.49,19.34 v2(166,19.85)
  IN4 w0.094: v2(166,19.85) 167.04,18.81 169.73,18.81 170.59,17.96 175.96,17.96 176.34,18.33 178.65,18.33 179.21,18.89 191.38,18.89 194.41,21.92 197.89,21.92 199.49,23.51 205.23,23.51 206.07,24.35 209.56,24.35 209.94,23.97 212.16,23.97 212.52,24.32 214.24,24.32 215.5,23.07 219.45,23.07 220.68,21.84 223.98,21.84 224.11,21.98 231.96,21.98 232.9,22.92 236.18,22.92 236.69,23.43 240.12,23.43 240.54,23.84 244.24,23.84 244.98,24.58 245.11,24.71 253.88,24.71 255.21,26.05 256.07,26.91 265.87,26.91 266.93,25.85 269.94,25.85 270.42,25.36 v2(270.42,25.24)
  BOTTOM w0.076: 166,20.41 166.43,20.84 166.43,22 166.34,22.09 UH2.BD26
  BOTTOM w0.114: D1.3 272.82,21.4 272.39,21.84 272.39,22.05 271.82,22.62 271.03,22.62 270.49,23.16 270.49,25.17 v2(270.42,25.24) ; 166,20.41 166,19.85 v2(166,19.85)
SRCCLKREQ1#: length 7.4
  BOTTOM w0.076: UH2.AW24 167.56,24.4 168.26,24.4 168.36,24.3 168.36,23.63 168.25,23.52 168.25,23.28 168.26,23.27 168.26,23.26 168.32,23.19 168.32,22.31 168.92,21.71 168.92,19.75
  BOTTOM w0.102: RP2.8 169.42,19.26 168.92,19.75
SRCCLKREQ4#: length 5.5
  BOTTOM w0.076: 168.67,19.57 168.67,20.27 v3(168.35,20.59) 168.09,20.84 168.09,21.49 167.76,21.83 167.76,22.11 167.86,22.22 167.86,22.22 167.86,22.53 167.76,22.63 167.76,23.11 UH2.BB24
  BOTTOM w0.102: RP2.7 168.92,19.32 168.67,19.57
SRCCLKREQ5#: length 4.1
  BOTTOM w0.076: UH2.BE25 166.79,21.83 166.79,20.48 167.01,20.25 v3(167.01,19.99) 167.01,19.75 167.47,19.29 167.78,19.29 167.92,19.15 RP2.5
SRCCLKREQ7#: length 10
  TOP w0.114: RP3.6 162.39,19.02 163.2,19.84 163.2,20.75 v3(163.64,21.19) 164.02,21.57 164.02,24.7 163.08,25.64 163.08,26.36 v2(163.43,26.71)
  BOTTOM w0.102: v2(163.43,26.71) 163.63,26.71 UH2.AR31
SRCCLKREQ8#: length 6.1
  BOTTOM w0.076: 161.86,20.34 162.23,20.7 162.94,20.7 163.68,21.45 163.68,22.18 163.55,22.31 UH2.BD32
  BOTTOM w0.114: 161.86,20.34 160.66,19.14 RP22.7
SRCCLKREQ9#: length 6.3
  BOTTOM w0.076: UH2.BC32 163.55,22.92 163.31,22.69 163.31,22.21 163.21,22.11 163.21,21.98 162.64,21.4 162.5,21.4 162.27,21.16 162.27,21.06
  BOTTOM w0.114: 162.27,21.06 160.16,18.95 RP22.6
SRCCLKREQ10#: length 6.7
  BOTTOM w0.076: 162.16,20.28 162.4,20.53 163.07,20.53 163.86,21.32 163.86,22.25 163.83,22.28 163.83,23.06 163.94,23.17 UH2.BB31
  BOTTOM w0.114: RP22.8 161.16,19.28 162.16,20.28
SRCCLKREQ11#: length 7
  BOTTOM w0.076: 161.21,20.8 161.43,20.8 162.37,21.73 162.5,21.73 162.83,22.06 162.83,22.25 162.83,22.55 162.97,22.69 UH2.BC33
  BOTTOM w0.102: 161.21,20.8 161.13,20.8 v3(160.95,20.62) 158.99,18.66
  BOTTOM w0.114: RP23.8 158.55,18.22 158.99,18.66
SRCCLKREQ13#: length 9.8
  TOP w0.114: v2(158,19.14) 158.06,19.14 158.63,19.7 158.63,21.44 v3(159.23,22.04) 159.54,22.35 160.41,22.35 160.78,22.72 160.78,23 162.3,24.53 v2(162.37,24.53)
  BOTTOM w0.076: v2(158,19.14) 157.87,19.14 157.39,18.66
  BOTTOM w0.089: v2(162.37,24.53) 162.37,24.55 162.59,24.78 UH2.AW33
  BOTTOM w0.114: 157.39,18.66 157.24,18.51 RP23.6
SRCCLKREQ14#: length 8.1
  BOTTOM w0.076: 161.05,21.07 161.3,21.07 161.95,21.73 161.95,22.05 162.14,22.24 162.31,22.24 162.54,22.24 162.64,22.34 162.64,22.62 162.73,22.7 162.73,23.02 162.94,23.24 UH2.BB33
  BOTTOM w0.102: 157.92,18.66 158.03,18.76 158.23,18.76 158.61,19.15 159.04,19.15 160.97,21.07 161.05,21.07
  BOTTOM w0.114: RP23.7 157.74,18.48 157.92,18.66
SRCCLKREQ15#: length 5.7
  BOTTOM w0.076: UH2.BD33 163,22.3 163,22 162.57,21.57 162.44,21.57 161.38,20.51
  BOTTOM w0.114: 161.38,20.51 161.29,20.51 v3(160.31,19.52) 159.66,18.87 RP22.5
SSD_CLK_REQ#: length 64.4
  TOP w0.114: RP3.8 162.19,20.34 162.19,21.44 163.45,22.69 v3(163.45,23.17) 163.45,23.47 163.76,23.79 163.76,24.46 v2(162.55,25.67)
  IN1 w0.094: v2(213.95,23.49) 213.55,23.09 212.71,23.09 212.46,22.84 206.55,22.84 206.41,22.98 199.38,22.98 198.5,22.1 193.18,22.1 192.81,22.47 188.09,22.47 187.45,21.82 182.09,21.82 181.51,21.24 178.36,21.24 178.14,21.02 177.25,21.02 176.45,21.83 170.54,21.83 170.25,22.11 168.45,22.11 166.95,23.61 166.43,23.61 166.02,23.21 164.91,23.21 163.87,24.25 163.87,24.35 v2(162.55,25.67)
  BOTTOM w0.089: UH2.AT33 162.67,25.96 162.67,25.8 v2(162.55,25.67)
  BOTTOM w0.114: JNGFF2.52 214.3,24.08 213.95,23.73 v2(213.95,23.49)
SSD_LED#: length 61.4
  TOP w0.114: RH502.1 253.48,24.42 v3(252.49,24.42) 250.17,24.42 v2(249.84,24.09)
  IN1 w0.094: v2(249.84,24.09) 249.77,24.17 245.45,24.17 244.75,23.46 244.36,23.46 243.47,22.57 234.3,22.57 231.38,19.65 229.68,19.65 228.72,18.68 226.74,18.68 225.38,20.04 223.14,20.04 222.7,19.61 217.22,19.61 216.77,20.06 212.97,20.06 v2(212.28,20.75)
  BOTTOM w0.114: v2(212.28,20.75) 212.28,23.44 213.23,24.39 213.23,26.34 214.12,27.23 214.12,30.51 213.62,31 213.62,34.31 213.89,34.58 JNGFF2.10
SSD_PCIE_WAKE#: length 3.5
  BOTTOM w0.114: JNGFF2.54 217.52,23.58 RD8.1 217.56,24.26 v3(217.84,24.54)
STRAP0: length 10.8
  TOP w0.102: v2(175.12,77.31) 175.12,77.05 175.47,76.7 175.47,76.25 v3(175.7,76.02) 176.2,76.02 176.34,75.89 178.08,75.89 178.79,75.17
  TOP w0.114: RV146.1 183.06,74.49 181.03,74.49 180.99,74.46 179.51,74.46 RV152.2 178.79,75.17
  BOTTOM w0.114: UV1.J2 175.49,76.94 v2(175.12,77.31)
STRAP1: length 21.6
  TOP w0.114: RV147.1 191.39,75.03 RV153.2 191.53,75.91 191.53,76.93 190.98,77.47 v3(189.95,77.47) 189.52,77.47 185.35,81.64 178.26,81.64 178.06,81.44 176.73,81.44 v2(175.86,80.57)
  BOTTOM w0.114: v2(175.86,80.57) 175.49,80.94 UV1.J7
STRAP2: length 20.1
  TOP w0.114: RV148.1 190.51,74.89 RV154.2 189.54,75.87 189.54,77 185.11,81.43 178.35,81.43 178.15,81.23 176.82,81.23 176.33,80.73 176.33,80.2 v3(176.3,80.17) v2(175.85,79.72)
  BOTTOM w0.114: UV1.J6 175.49,80.16 175.85,79.8 175.85,79.72 v2(175.85,79.72)
STRAP3: length 15.4
  TOP w0.102: v2(175.85,78.91) 176.74,78.02 177.05,78.02 177.36,77.71 183.78,77.71
  TOP w0.114: RV149.1 RV155.2 186.15,76.27 186.15,77.06 186.03,77.19 186.03,77.86 185.66,78.22 v3(185.44,78.22) 184.67,78.22 184.16,77.71 183.78,77.71
  BOTTOM w0.114: UV1.J5 175.88,78.92 175.87,78.91 v2(175.85,78.91)
STRAP4: length 11.7
  TOP w0.102: v2(175.87,76.49) 175.94,76.43 176.35,76.43 176.67,76.11 183.07,76.11 183.45,75.73 v3(183.58,75.73)
  TOP w0.114: v3(183.58,75.73) RV156.2 RV150.1
  BOTTOM w0.114: v2(175.87,76.49) 175.89,76.51 175.89,77.12 175.49,77.52 UV1.J3
STRAP5: length 8.2
  TOP w0.114: RV593.1 181.45,73.78 v3(179.85,73.78) 178.6,73.78 178.1,73.27 177.4,73.27 RV66.2 176.39,74.29 176.39,74.35 175.88,74.85 v2(175.88,74.97)
  BOTTOM w0.114: UV1.J1 175.49,75.36 v2(175.88,74.97)
SUSCLK: length 80.8
  TOP w0.114: RE106.1 v4(216.63,34.53) 215.4,34.53 214.7,33.84 214.7,33.83 214.4,33.52 214.4,32.46 v2(212.18,30.24)
  IN3 w0.127: v2(212.18,30.24) 211.35,31.08 205.55,31.08 203.87,32.76 198.88,32.76 196.14,30.01 191.45,30.01 191.02,30.44 v2(191.02,31.59)
  IN4 w0.094: v2(191.02,31.59) 188.57,31.59 186.75,29.77 183.72,29.77 181.02,27.07 179.22,27.07 178.6,27.69 177.68,27.69 176.64,26.65 174.25,26.65 174.15,26.75 173.05,26.75 v2(172.58,27.22)
  BOTTOM w0.102: UH2.AN15 172.1,27.7 v2(172.58,27.22)
  BOTTOM w0.114: v2(191.02,31.59) 191.13,31.59 191.88,32.34 192.36,32.34 194.27,34.24 194.27,35.13 RN1.2 ; v2(212.18,30.24) 212.18,29.39 213.23,28.34 213.23,27.6 212.26,26.63 212.26,24.3 211.66,23.7 211.66,20.79 212.18,20.26 213.17,20.26 213.6,20.7 215.54,20.7 216.04,21.2 RD9.2
SUSCLK_R: length 6.5
  BOTTOM w0.114: RN1.1 195.56,34.67 v3(195.56,32.7) 196.86,31.4 196.86,30.7 196.56,30.4 JNGFF1.42
SW_+1.35VS_VGAP: length 11.3
  IN1 w0.635: 143.32,126.3 143.32,125.19 142.2,124.07 142.2,117.8 140.8,116.4 v2(140.8,116.04)
  vias: v2(140.78,115.41) v2(143.8,128.34) v2(143.9,127.68) v2(143.95,127.02) v2(144.08,126.36) v2(144.15,128.95) v2(144.64,127.02) v2(144.76,127.78) v2(144.84,128.59) v2(145.12,126.41) v2(145.63,130.62) v2(145.7,128.54) v2(145.65,127.7) v2(145.86,126.71) v2(146.52,128.54) v2(146.57,127.63) v2(146.8,126.71) v2(147.33,131.89) v2(147.38,128.54) v2(147.53,127.6) v2(147.74,126.74) v2(148.17,131.89) v2(148.17,128.51) v2(148.35,127.63) v2(148.88,131.89) v2(148.85,126.69) v2(149.08,128.49) v2(149.13,127.6) v2(149.54,131.89) v4(148.54,130.14)
SWF_BSNL: length 48.2
  TOP w0.114: v2(260.64,11.37) v4(260.64,12.18)
  IN2 w1.27: 306.21,2.89 306.08,2.76 299.48,2.76 291.45,10.79 291.07,10.79 287.26,14.6 284.46,14.6 280.55,10.68 265.36,10.68
  vias: v2(261.24,11.37) v2(261.85,11.39) v2(306,4.77) v2(306.31,4.23) v2(306.59,4.77)
SWF_BSNR: length 52.1
  TOP w0.127: v2(257.39,11.37) v3(257.39,12.31)
  IN2 w1.27: 260.02,12.47 260.32,12.78 263.14,12.78 263.71,12.21 279.82,12.21 283.73,16.12 288,16.12 291.73,12.39 292.01,12.39 298.21,6.19 304.17,6.19 304.78,5.58
  vias: v2(258,11.37) v2(258.64,11.37) v2(304.55,4.76) v2(304.56,4.16) v2(305.11,4.41)
SYS_PEX_RST_MON#: length 35.8
  TOP w0.114: v2(152.79,73.88) 152.9,73.77 UV18.1
  IN1 w0.094: v2(170.09,81.4) 168.51,81.4 168.11,80.99 162.37,80.99 162.23,81.13 158.85,81.13 157.58,79.86 156.41,79.86 155.52,78.98 155.52,78.28 154.7,77.46 154.7,76.27 152.79,74.36 v2(152.79,73.88)
  IN4 w0.094: v2(149.15,76.81) 149.25,76.81 150.66,75.4 151.92,75.4 152.79,74.53 v2(152.79,73.88)
  BOTTOM w0.114: UV1.R8 170.49,81.8 v2(170.09,81.4) ; RV587.2 145.01,78.63 146.43,77.21 146.43,76.91 v3(146.68,76.66) 147.15,76.19 RV532.1 148.12,75.63 148.71,75.63 149.15,76.06 v2(149.15,76.81)
SYS_PWROK: length 76.8
  TOP w0.114: UE1.89 237.86,27.34 238.22,26.98 238.68,26.98 v3(239.16,26.49) 239.68,25.98 239.68,25.98 239.79,25.87 239.79,25.87 239.86,25.8 239.86,25.36 240.28,24.95 240.59,24.95 241.26,24.27 v2(241.77,24.27)
  IN1 w0.094: v2(181.09,20.72) 181.65,20.15 186.17,20.15 187.24,21.22 187.7,21.22 188.34,21.86 192.56,21.86 192.93,21.5 198.75,21.5 199.63,22.38 206.16,22.38 206.3,22.24 212.71,22.24 212.96,22.49 215.51,22.49 216.42,21.58 222.98,21.58 223.23,21.82 225.19,21.82 225.84,21.17 232.21,21.17 234.08,23.05 236.15,23.05 236.69,23.59 241.08,23.59 v2(241.77,24.27)
  BOTTOM w0.089: UH2.AY1 179.62,24.34 181.09,22.88 181.09,22.09
  BOTTOM w0.114: 181.09,22.09 v2(181.09,20.72)
SYS_RESET#: length 17.1
  TOP w0.114: v2(182.12,20.77) 182.12,20.24 181.37,19.48 181.37,17.01 179.77,15.42 v4(179.77,14.58) 179.77,12.55 179.18,11.95 JAPS.13
  BOTTOM w0.089: UH2.AW1 178.82,24.91 178.97,24.76 179.64,24.76 182.03,22.37
  BOTTOM w0.114: 182.03,22.37 182.12,22.27 v2(182.12,20.77) 182.05,20.7 RH193.1
TB_STAT#_CHG: length 1.8
  BOTTOM w0.203: PU300.16 32.44,38.14 33.28,38.98 PR320.1
TESTMODE: length 12.4
  BOTTOM w0.114: v3(149.05,81.57) 149.39,81.23 149.89,81.23 150.4,81.74 RV62.1 151.61,81.98 152.17,81.42 152.82,81.42 152.98,81.58 154.41,81.58 154.46,81.53 155.65,81.53 155.86,81.75 155.86,82.01 156.13,82.28 156.39,82.28 156.66,82.55 156.66,82.81 157.03,83.18 158.04,83.18 158.26,83.4 158.26,84 158.02,84.24 158.02,84.27 UV1.AK11
THERMAL_ALERT#: length 4.6
  BOTTOM w0.114: RV526.1 170.7,74.08 171.06,74.44 171.33,74.44 171.79,74.91 171.79,75.33 172.31,75.85 172.31,76.46 172.76,76.91 UV1.M2
THERMATRIP_GPU#: length 163.1
  IN1 w0.094: v2(151.94,72.95) 152,73.02 152.56,73.02 153.19,73.64 153.19,74.44 154.95,76.2 154.95,77.43 155.72,78.2 155.72,78.9 156.49,79.66 157.66,79.66 158.93,80.94 162.05,80.94 163.14,79.85 165.35,79.85 165.66,80.15 166.28,80.15 166.54,79.89 169.44,79.89 169.71,80.15 171.01,80.15 171.56,79.6 171.56,75.15 v2(172.2,74.51)
  IN2 w0.127: v2(227.21,19.22) 226.37,20.07 219.78,20.07 219.68,19.97 217.75,19.97 215.69,22.02 215.69,29.61 214.42,30.89 213.13,30.89 212.76,30.52 v2(212.76,30.11)
  IN4 w0.094: v2(151.94,72.95) 151.94,72.87 152.97,71.84 156.15,71.84 156.49,71.49 160.68,71.49 160.89,71.71 165.22,71.71 165.31,71.62 166.39,71.62 166.75,71.26 166.75,70.67 167.01,70.41 168.43,70.41 168.82,70.03 168.82,67.95 169.3,67.46 169.3,63.28 174.08,58.5 174.97,58.5 175.95,57.52 175.95,55.87 177.39,54.43 177.39,54.2 179.68,51.91 179.68,51.14 180.91,49.91 v2(180.91,47.84)
  BOTTOM w0.114: v2(227.21,19.22) 227.83,19.84 RV613.1 ; v2(151.94,72.95) 151.36,73.54 v3(151.36,74.25) 150.93,74.25 RV34.1 151.01,75.56 RV614.1 152.37,75.71 153.02,76.36 153.02,77.68 152.66,78.03 151.47,78.03 150.84,77.4 RV615.1 ; UV1.M1 172.99,75.21 172.29,74.51 v2(172.2,74.51) ; v2(212.76,30.11) 212.94,30.29 212.94,33.09 211.95,34.07 211.95,38.15 210.27,39.83 209.59,39.83 207.5,41.91 203.17,41.91 202.17,42.92 202.17,43.58 195.72,50.03 191.67,50.03 189.48,47.84 v2(180.91,47.84)
THM_SML1_CLK: length 5.2
  BOTTOM w0.114: RT7.1 54.3,49.28 QT2.4 55.32,48.65 RT4.2 55.38,48.9 v3(56.11,49.62) 56.24,49.76 UT1.10
THM_SML1_DATA: length 11.9
  BOTTOM w0.114: QT2.1 51.38,47.35 RT5.2 51.32,46.35 51.7,45.96 RT6.1 52.89,45.53 53.25,45.17 54.52,45.17 v3(54.98,45.64) 55.95,46.61 55.95,48.59 56.62,49.26 UT1.9
TMDS_L_TX0N: length 22.7
  TOP w0.076: 301.17,68.99 301.18,69 301.18,69.05 301.34,69.21 301.34,74.48 301.56,74.7 301.66,74.7 301.86,74.5 JHDMI1.9
  TOP w0.089: 301.17,68.99 300.3,68.11 298.35,68.11 296.44,70.02 v1(293.63,70.02) 293.33,70.02 292.67,69.36 292.67,68.06 292.82,67.91 DV5.8 DV5.2 292.82,66.2 292.68,66.06 292.68,65.88 292.52,65.73 292.52,65.6 292.82,65.29 RV557.1 292.49,64.94 292.49,64.58 292.61,64.46 LV25.3 292.78,63.82 RV624.2
TMDS_L_TX0P: length 22.8
  TOP w0.076: JHDMI1.7 301.55,74.86 301.49,74.86 301.18,74.55 301.18,69.28 301.07,69.17 301.01,69.17 301,69.16
  TOP w0.089: RV623.2 291.95,63.82 LV25.2 292.11,64.43 292.25,64.57 292.25,64.92 RV557.2 292.28,65.64 292.28,65.83 292.43,65.98 292.43,66.09 292.32,66.2 DV5.1 DV5.9 292.32,67.89 292.43,68 v1(292.43,69.08) 292.43,69.46 293.23,70.26 296.54,70.26 298.45,68.35 300.2,68.35 301,69.16
TMDS_L_TX1N: length 11.4
  TOP w0.089: JHDMI1.6 300.66,75.89 300.19,76.36 298.93,76.36 v1(298.46,76.83) 297.95,77.34 297.95,78.12 297.04,79.02 296.56,79.02 296.38,78.85 296.38,78.7 296.54,78.54 DV4.1 296.54,77.95 296.43,77.84 296.43,77.59 296.54,77.48 DV4.9 296.54,76.91 296.43,76.81 296.43,76.67 296.54,76.56 296.54,76.28 RV562.1 296.57,75.62 296.57,75.18 296.68,75.07 LV26.3 296.85,74.49 RV626.2
TMDS_L_TX1P: length 11.5
  TOP w0.089: RV625.2 296.01,74.49 LV26.2 296.18,75.05 296.33,75.2 296.33,75.58 RV562.2 296.3,76.27 296.3,76.46 296.19,76.57 296.19,76.75 296.04,76.91 DV4.8 296.04,77.45 296.19,77.6 296.19,77.83 296.04,77.98 DV4.2 296.04,78.54 296.14,78.65 296.14,78.95 296.46,79.27 297.14,79.27 v1(297.85,78.56) 298.19,78.22 298.19,77.44 299.03,76.6 300.59,76.6 JHDMI1.4
TMDS_L_TX2N: length 13.7
  TOP w0.089: JHDMI1.3 301.86,77.39 301.32,77.93 301.22,77.93 300.32,78.82 298.78,78.82 297.81,79.78 v1(297.32,79.78) 295.65,79.78 295.04,79.17 DV4.4 295.04,77.98 294.89,77.83 294.89,77.6 295.04,77.45 DV4.7 295.04,76.93 294.9,76.79 294.9,76.62 294.68,76.4 294.68,76.24 RV565.1 294.66,75.62 294.66,75.21 294.77,75.1 LV27.3 294.94,74.49 RV628.2
TMDS_L_TX2P: length 13.8
  TOP w0.089: JHDMI1.1 301.32,78.17 300.42,79.06 298.88,79.06 297.91,80.03 v1(296.05,80.03) 295.55,80.03 294.8,79.27 294.8,78.67 294.54,78.41 DV4.5 294.54,77.95 294.65,77.84 294.65,77.59 294.54,77.48 DV4.6 294.54,76.94 294.66,76.82 294.66,76.72 294.44,76.5 294.44,76.31 RV565.2 294.42,75.58 294.42,75.23 294.27,75.08 294.27,75.08 LV27.2 294.11,74.49 RV627.2
TMDS_L_TXCN: length 18
  TOP w0.089: RV622.2 294.69,63.82 LV24.3 294.52,64.26 294.38,64.39 294.38,64.93 RV554.2 294.38,65.61 294.38,65.82 294.17,66.04 294.17,66.19 294.32,66.33 DV5.5 DV5.6 294.32,67.79 294.25,67.86 294.25,68.08 294.51,68.34 294.98,68.34 295.36,68.72 295.36,69.07 295.59,69.31 v2(295.74,69.31)
  BOTTOM w0.089: v2(295.74,69.31) 295.31,69.31 295.18,69.44 295.18,70.2 294.29,71.08 294.29,72.51 294.84,73.05 300.28,73.05 JHDMI1.12
TMDS_L_TXCP: length 18
  TOP w0.089: v2(294.75,69.28) 294.95,69.28 295.12,69.12 295.12,68.82 294.88,68.58 294.41,68.58 294,68.18 294,67.9 293.82,67.71 DV5.7 DV5.4 293.82,66.39 293.93,66.28 293.93,66.05 293.93,65.94 294.14,65.72 294.14,65.6 RV554.1 294.14,64.94 294.14,64.35 294.02,64.23 LV24.2 293.85,63.82 RV621.2
  BOTTOM w0.089: v2(294.75,69.28) 294.94,69.47 294.94,70.1 294.05,70.98 294.05,72.61 294.74,73.29 v1(295.79,73.29) 300.28,73.29 JHDMI1.10
TMDS_T_TX0N: length 40
  TOP w0.089: UM1.16 271.01,34.93 271.09,34.85 271.5,34.85 271.56,34.91 272.47,34.91 276.45,38.88 276.45,47.52 v1(284.72,55.79) 289.26,60.33 291.85,60.33 292.6,61.07 292.6,62.19 292.61,62.2 LV25.4 292.78,62.91 RV624.1
TMDS_T_TX0P: length 39.9
  TOP w0.089: UM1.17 271.08,35.33 271.15,35.26 271.15,35.13 271.19,35.09 271.4,35.09 271.46,35.15 272.37,35.15 276.2,38.98 276.2,47.62 v1(280.12,51.54) 289.16,60.57 291.75,60.57 292.36,61.17 292.36,62.02 292.28,62.09 292.16,62.09 292.11,62.14 LV25.1 291.95,62.91 RV623.1
TMDS_T_TX1N: length 51.2
  TOP w0.089: UM1.19 272.65,36.13 275.71,39.19 275.71,47.93 v1(282.74,54.96) 290.97,63.19 290.97,68.7 293.02,70.75 294.7,70.75 295.45,71.5 296.19,71.5 296.86,72.18 296.86,72.65 296.68,72.83 LV26.4 296.85,73.57 RV626.1
