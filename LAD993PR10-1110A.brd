# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBA_MA2_BA0_L: length 38.2
  TOP w0.102: 170.42,108.58 168.63,106.78 168.63,102.55 168.61,102.52 168.61,101.89 168.8,101.7 168.8,100.45 169.05,100.2 169.05,100.05 v2(169.22,99.88) ; v2(183.2,124.89) 183.03,124.72 182.18,124.72 181.9,124.45 181.9,124.05 183.08,122.87 183.36,122.87 183.58,122.65 183.58,118.24 183.52,118.18
  TOP w0.185: 183.52,118.18 183.49,118.15 183.49,115.35 v4(181.12,112.97) 179.2,111.05 172.99,111.05 170.52,108.58 170.42,108.58
  BOTTOM w0.185: UV6.H11 183.6,124.49 v2(183.2,124.89) ; UV1.U29 v2(169.22,99.88)
FBA_MA3_BA3_H: length 31.2
  TOP w0.102: 163.91,106.74 165.45,105.2 165.45,101.29 164.68,100.53 164.68,99.41 v2(165.06,99.03) ; 158.92,118.1 158.71,118.3 158.71,123.45 158.94,123.67 159.39,123.67 v2(160.01,124.29)
  TOP w0.185: 158.92,118.1 158.92,117.36 158.34,116.78 v4(158.34,114.37) 158.34,111.95 161.67,108.62 162.03,108.62 163.91,106.74
  BOTTOM w0.185: UV7.K10 159.7,124.29 v2(160.01,124.29) ; UV1.AA29 v2(165.06,99.03)
FBA_MA3_BA3_L: length 36.8
  TOP w0.102: v2(169.22,101.51) 169.05,101.67 169.05,101.85 168.81,102.09 168.81,102.42 168.83,102.44 168.83,105.91 171.21,108.29 ; v2(182.29,124.29) 182.74,124.29 183.34,123.69 184.14,123.69 184.42,123.41 184.42,123.13 184.64,122.91 184.92,122.91 185.22,122.61 185.22,118.18 185.36,118.05 185.36,117.21
  TOP w0.185: 185.36,117.21 185.36,117.05 185.26,116.96 185.26,116.14 v4(184.12,114.99) 179.49,110.36 173.28,110.36 171.21,108.29
  BOTTOM w0.185: v2(169.22,101.51) 169.62,101.11 UV1.T31 ; UV6.H10 182.48,124.49 v2(182.29,124.29)
FBA_MA4_BA2_H: length 26.5
  TOP w0.185: v2(162.24,110.01) v3(161.17,111.08) 159.73,112.52 159.73,115.22 160.3,115.79 160.3,123.17 160.66,123.54 160.66,125.45 v2(160.49,125.63)
  BOTTOM w0.185: UV1.AC34 163.79,104.69 161.93,106.54 161.93,109.7 v2(162.24,110.01) ; v2(160.49,125.63) 159.82,125.63 159.75,125.69 159.12,125.69 158.72,126.09 UV7.H11
FBA_MA4_BA2_L: length 31.6
  TOP w0.185: v2(181.81,125.67) 181.65,125.51 181.65,123.49 182.76,122.37 182.76,115.6 182.05,114.88 v2(181.3,114.88)
  BOTTOM w0.185: UV6.K11 183.18,125.67 182.52,125.67 182.46,125.61 181.87,125.61 v2(181.81,125.67) ; UV1.R34 170.49,104.89 171.42,105.82 172.13,105.82 172.16,105.79 172.67,105.79 172.99,106.11 172.99,107.5 175.81,110.32 176.75,110.32 v4(179.39,112.97) 179.39,113.11 181.16,114.88 v2(181.3,114.88)
FBA_MA5_BA1_H: length 27.4
  TOP w0.185: v2(162.24,111.41) 161.96,111.41 160.55,112.82 160.55,115.06 161,115.51 v4(161,121.01) 161,123.18 161.05,123.23 161.05,125.66 160.62,126.09 v2(160.05,126.09)
  BOTTOM w0.185: UV1.AC33 163.39,103.11 163.39,104.38 162.05,105.72 162,105.72 161.89,105.83 161.67,105.83 161.22,106.27 161.22,110.39 v2(162.24,111.41) ; UV7.H10 159.5,126.09 v2(160.05,126.09)
FBA_MA5_BA1_L: length 31.2
  TOP w0.185: v2(182.24,126.09) 181.99,126.09 181.98,126.09 181.63,126.09 181.32,125.78 181.32,123.22 182.07,122.48 182.07,116.04 v2(181.91,115.88)
  BOTTOM w0.185: v2(182.24,126.09) 182.8,126.09 UV6.K10 ; UV1.R33 170.89,103.11 170.89,104.88 171.54,105.53 171.96,105.53 172,105.5 172.78,105.5 173.72,106.43 173.72,107.25 176,109.53 177.11,109.53 v4(178.27,110.68) 181.91,114.33 v2(181.91,115.88)
FBA_MA6_MA11_H: length 36.6
  IN1 w0.102: 168.26,125.65 166.91,125.65 166.57,125.31 163.68,125.31 v2(162.9,126.09) ; v2(166.66,98.98) 167.04,99.36
  IN1 w0.152: 167.04,99.36 167.04,101.61 167.47,102.05 167.47,102.81 167.62,102.96 167.62,103.44 167.19,103.88 167.19,112.29 170.62,115.71 170.62,123.29 168.26,125.65
  BOTTOM w0.185: UV1.Y28 v2(166.66,98.98) ; UV7.H5 v2(162.9,126.09)
FBA_MA6_MA11_L: length 37.5
  TOP w0.102: 170.23,109.27 168.41,107.45 168.41,102.83 168.01,102.43 168.01,100.55 168.26,100.3 168.51,100.3 168.77,100.04 168.77,99.41 v2(168.39,99.03)
  TOP w0.185: v2(179.4,126.09) 179.54,126.09 180.66,124.97 v4(180.66,119.13) 180.66,115.01 177.44,111.79 172.75,111.79 170.23,109.27
  BOTTOM w0.185: v2(168.39,99.03) 168.6,98.82 168.6,98.8 UV1.U28 ; UV6.K5 v2(179.4,126.09)
FBA_MA7_MA8_H: length 27.2
  TOP w0.102: 162.4,125.69 v2(163.9,125.69)
  TOP w0.185: 162.4,125.69 162.07,125.36 162.07,121.78 162.67,121.17 162.67,118.99 163.08,118.58 v4(163.08,117.02) 163.08,114.65 v2(162.38,113.95)
  BOTTOM w0.185: UV7.H4 164.3,126.09 v2(163.9,125.69) ; v2(162.38,113.95) 163.48,112.85 163.48,106.62 165.08,105.02 165.08,103.37 165.49,102.96 UV1.AA33
FBA_MA7_MA8_L: length 30.2
  TOP w0.185: v2(177.42,113.25) 177.66,113.25 179.96,115.55 179.96,119.74 180.2,119.98 180.2,122.6 180.38,122.77 180.38,124.85 179.61,125.62 178.47,125.62 v2(178.4,125.69)
  BOTTOM w0.185: UV6.K4 v2(178.4,125.69) ; UV1.U33 168.94,102.71 169.64,103.41 169.64,105.26 175.14,110.76 175.14,111.22 v4(176.02,112.1) 177.17,113.25 v2(177.42,113.25)
FBA_MA12_RFU_H: length 29.4
  TOP w0.102: v2(162.9,125.29) 162.31,124.7 162.31,121.93 162.97,121.28 164.05,121.28 164.28,121.04 164.28,118.26 164.25,118.23 ; v2(165.89,100.71) 165.89,105.9 166.13,106.14
  TOP w0.185: 166.13,106.14 166.13,108.56 165.53,109.16 165.38,109.16 164.1,110.43 v4(164.1,111.43) 164.1,118.07 164.25,118.23
  BOTTOM w0.185: UV1.W31 166.94,101.11 166.54,100.71 v2(165.89,100.71) ; UV7.J5 v2(162.9,125.29)
FBA_MA12_RFU_L: length 33.7
  TOP w0.102: 169.3,109.03 168.17,107.9 168.17,102.94 167.81,102.57 167.81,100.47 168.29,99.98 168.3,99.98 v2(168.39,99.88)
  TOP w0.185: v2(179.4,125.19) 180.03,124.56 180.03,123.03 179.63,122.63 179.63,120.55 179.27,120.19 v4(179.27,117.26) 179.27,116.62 175.22,112.57 172.55,112.57 169.3,109.32 169.3,109.03
  BOTTOM w0.185: v2(168.39,99.88) 167.99,99.48 UV1.V29 ; UV6.J5 179.3,125.29 v2(179.4,125.19)
FBA_RAS#_H: length 30.6
  TOP w0.102: 168.67,120.26 168.24,120.26 168.08,120.11 167.01,120.11 166.84,120.28 166.84,123.43 166.61,123.66 166.46,123.66 166.45,123.67 166.14,123.67 166.13,123.66 165.66,123.66 165.65,123.67 165.11,123.67 v2(164.7,124.09)
  TOP w0.185: v2(165.24,110.91) 166.18,111.85 166.18,112.88 v4(169.32,116.01) 169.63,116.32 169.63,120.01 169.37,120.26 168.67,120.26
  BOTTOM w0.185: v2(164.7,124.09) 165.1,123.69 UV7.L3 ; UV1.Y31 165.89,101.51 165.89,106.17 165.36,106.7 165.36,106.7 164.86,107.2 164.86,109.17 165.24,109.54 v2(165.24,110.91)
FBA_RAS#_L: length 30.7
  IN1 w0.102: v2(177.6,124.09) 177.2,124.49 175.7,124.49 175.42,124.77 174.08,124.77 173.92,124.61
  IN1 w0.152: 173.92,124.61 171.74,122.43 171.74,115.24 168.31,111.81 168.31,104.43 168.44,104.31 168.44,103.01 168.39,102.97 v2(168.39,101.51)
  BOTTOM w0.185: UV6.G3 177.2,123.69 v2(177.6,124.09) ; UV1.U31 v2(168.39,101.51)
FBA_RST#_H: length 27.6
  TOP w0.102: v2(166.3,124.89) 168.24,124.89 ; v2(166.71,105.31) 166.93,105.52 166.93,109.72
  TOP w0.185: 168.24,124.89 RV107.1 168.99,125.35 170.46,123.87 170.46,115.15 v4(168.58,113.26) 166.93,111.61 166.93,109.72
  BOTTOM w0.185: UV1.Y34 166.29,104.88 v2(166.71,105.31) ; UV7.J2 v2(166.3,124.89)
FBA_RST#_L: length 30.4
  TOP w0.102: 174.76,124.84 174.81,124.89 v2(176,124.89)
  TOP w0.185: v2(174.57,116.83) 174.25,117.15 173.27,117.15 172.6,117.82 172.6,124.65 RV108.1 173.89,125.14 174.46,125.14 174.76,124.84
  BOTTOM w0.185: UV6.J2 v2(176,124.89) ; v2(174.57,116.83) 174.12,116.83 167.7,110.4 167.7,106.13 167.99,105.84 UV1.V34
FBA_WCK0: length 23.8
  IN1 w0.102: v2(174.22,101.51) 174.44,101.73 174.44,101.81 174.64,102.02 174.64,105.01 175.2,105.57 175.2,106.55 175.18,106.57 175.18,106.64
  IN1 w0.117: 175.18,106.64 175.18,106.79 175.19,106.8 175.19,107.97 176.23,109.01 176.49,109.01 179.29,111.81 179.29,117.39 179.99,118.08 179.99,118.92 178.98,119.94 178.98,120.31 v2(178.4,120.89)
  BOTTOM w0.124: v2(178.4,120.89) 178,121.29 UV6.D4 ; v2(174.22,101.51) 174.62,101.11 UV1.K31
FBA_WCK0_N: length 24.3
  IN1 w0.102: 175.4,106.64 175.4,105.48 174.84,104.92 174.84,101.93 174.64,101.73 174.64,101.46 174.3,100.8 v2(174.22,100.71)
  IN1 w0.117: 175.4,106.64 175.41,106.65 175.41,107.88 176.32,108.79 176.59,108.79 179.52,111.72 179.52,117.3 180.21,117.99 180.21,119.02 179.2,120.03 v2(179.2,120.89)
  BOTTOM w0.124: UV1.L30 173.82,100.31 v2(174.22,100.71) ; UV6.D5 178.8,121.29 v2(179.2,120.89)
FBA_WCK1: length 31.2
  IN1 w0.102: 179.59,128.49 178.8,128.49 v2(178.4,128.89)
  IN1 w0.117: 179.59,128.49 180.11,128.49 180.3,128.3 181.02,127.58 181.02,127.56 181.02,127.47 181.02,127.47 181.02,117.37 180.43,116.77 180.43,111.89 176.82,108.28 176.82,107.34 176.55,107.07 v2(175.89,107.07)
  BOTTOM w0.124: UV1.H34 176.29,103.79 176.84,104.35 176.84,106.49 176.52,106.82 176.4,106.82 176.14,106.82 v2(175.89,107.07) ; UV6.P4 v2(178.4,128.89)
FBA_WCK1_N: length 31.3
  IN1 w0.102: 176.44,106.64 176.19,106.64 v2(175.89,106.34)
  IN1 w0.117: v2(179.2,128.89) 179.21,128.89 179.33,128.77 180.15,128.77 181.25,127.67 181.25,127.65 181.25,117.27 180.65,116.68 180.65,111.8 177.04,108.19 177.04,107.25 176.44,106.64
  BOTTOM w0.124: UV6.P5 v2(179.2,128.89) ; v2(175.89,106.34) 176.14,106.6 176.15,106.6 176.4,106.6 176.43,106.6 176.62,106.4 176.62,104.44 176.06,103.87 176.06,103.78 175.94,103.65 175.94,103.65 175.79,103.51 UV1.J34
FBA_WCK2: length 24.3
  IN4 w0.102: 162.27,118.23 162.27,120.08 162.68,120.49 163.38,120.49 163.79,120.89 v2(163.9,120.89)
  IN4 w0.117: v2(160.06,100.71) 160.69,101.33 160.69,102.35 160.35,102.69 160.04,103 160.04,105.81 159.6,106.26 159.6,114.67 162.27,117.35 162.27,118.23
  BOTTOM w0.124: UV7.P4 164.29,121.29 v2(163.9,120.89) ; v2(160.06,100.71) 160.46,100.31 UV1.AG30
FBA_WCK2_N: length 22.9
  IN4 w0.102: v2(163.1,120.89) 162.9,120.69 162.6,120.69 162.07,120.16 162.07,118.32 162.06,118.31 162.06,118.25 162.05,118.24 162.05,118.23
  IN4 w0.117: 162.05,118.23 162.05,117.44 159.37,114.76 159.37,106.16 159.82,105.72 159.82,102.91 160.12,102.6 160.19,102.54 160.47,102.26 160.47,101.91 v2(160.06,101.51)
  BOTTOM w0.124: UV7.P5 163.49,121.29 v2(163.1,120.89) ; v2(160.06,101.51) 160.47,101.11 UV1.AG31
FBA_WCK3: length 30.8
  IN1 w0.102: 162.68,129.28 163.51,129.28 v2(163.9,128.89) ; v2(159.21,103.91) 159.07,104.05 158.87,104.05 158.67,104.25 158.49,104.43 158.49,106.64
  IN1 w0.117: 158.49,106.64 158.49,114.96 161.05,117.52 161.05,127.64 162.68,129.28
  BOTTOM w0.124: UV1.AJ34 158.61,103.69 158.61,103.99 158.73,104.11 159.01,104.11 159.21,103.91 v2(159.21,103.91) ; v2(163.9,128.89) 164.3,129.29 UV7.D4
FBA_WCK3_N: length 29.6
  IN1 w0.102: 158.71,106.64 158.71,106.55 158.69,106.53 158.69,104.52 158.82,104.39 158.97,104.39 v2(159.21,104.64)
  IN1 w0.117: 158.71,106.64 158.71,114.86 161.27,117.42 161.27,127.55 162.72,129 162.99,129 v2(163.1,128.89)
  BOTTOM w0.124: UV7.D5 163.5,129.29 v2(163.1,128.89) ; UV1.AK34 158.38,103.9 158.38,104.08 158.45,104.15 158.64,104.34 158.91,104.34 v2(159.21,104.64)
FBA_WE#_H: length 30
  TOP w0.185: v2(162.24,112.11) v4(161.24,113.11) 161.24,114.77 161.69,115.22 161.69,121.19 161.4,121.48 161.4,125.92 160.81,126.51 158.32,126.51 v2(158.3,126.49)
  BOTTOM w0.185: UV1.AA32 165.09,102.31 165.09,102.86 164.68,103.27 164.68,104.44 162.78,106.33 162.78,111.56 v2(162.24,112.11) ; UV7.G12 v2(158.3,126.49)
FBA_WE#_L: length 35.3
  TOP w0.185: v2(184,126.49) 183.63,126.86 182.76,126.86 182.41,126.51 181.55,126.51 181.01,125.97 181.01,122.83 181.38,122.46 181.38,116.33 v2(181.24,116.2)
  BOTTOM w0.185: UV6.L12 184.4,126.89 v2(184,126.49) ; v2(181.24,116.2) v4(180.25,115.21) 179.18,114.14 177.04,114.14 169.91,107.01 169.91,106.52 169.24,105.84 169.24,103.41 168.93,103.11 168.65,103.11 168.41,102.87 168.41,102.29 UV1.U32
FBC_ABI#_H: length 34.7
  IN1 w0.102: v2(203.46,99.46) 203.86,99.06 203.86,95.82 ; 180.82,89.49 180.76,89.43 178,89.43 v2(177.61,89.81)
  IN1 w0.152: 203.86,95.82 203.86,94.8 201.53,92.47 195.2,92.47 192.12,89.39 181.75,89.39 181.65,89.49 180.82,89.49
  BOTTOM w0.185: UV1.G17 177.59,89.81 v2(177.61,89.81) ; UV9.J4 v2(203.46,99.46)
FBC_ABI#_L: length 30.8
  TOP w0.102: 182.66,88.51 182.33,88.18 181.62,88.18 181.49,88.31 179.69,88.31 179.44,88.56 v2(178.04,88.56) ; 196.23,85.33 196.61,84.95 196.61,84.57 196.88,84.3 201.98,84.3 202.32,83.96 202.32,83.68 202.7,83.3 203.02,83.3 203.31,83.59 203.31,84.53 v2(203.46,84.68)
  TOP w0.185: 182.66,88.51 v4(183.55,88.51) 186.73,88.51 189.4,85.83 195.73,85.83 196.23,85.33
  BOTTOM w0.185: UV8.J4 v2(203.46,84.68) ; UV1.F15 v2(178.04,88.56)
FBC_CAS#_H: length 36.6
  TOP w0.102: v2(205.06,99.46) 205.05,99.47 205.05,101.08 ; 182.43,89.75 179.34,89.75 v2(179.29,89.81)
  TOP w0.185: 205.05,101.08 205.11,101.15 205.11,101.97 204.61,102.48 199.07,102.48 198.07,101.48 197.7,101.48 196.9,100.68 196.74,100.68 196.41,100.35 196.41,99.86 v4(195.67,99.11) 194.67,98.11 194.27,98.11 193.47,97.31 193.47,95.16 188.93,90.62 184.72,90.62 183.86,89.75 182.43,89.75
  BOTTOM w0.185: UV9.G3 205.46,99.06 v2(205.06,99.46) ; UV1.E17 v2(179.29,89.81)
FBC_CAS#_L: length 29.6
  IN1 w0.102: v2(205.06,86.28) 204.25,87.09 204.25,88.51
  IN1 w0.152: 204.25,88.51 204.25,88.51 204.25,88.85 201.67,91.43 194.95,91.43 192.35,88.83 182.24,88.83 182.11,88.96 180.91,88.96 v2(180.89,88.98)
  BOTTOM w0.185: v2(180.89,88.98) 180.89,89.01 UV1.C17 ; UV8.L3 v2(205.06,86.28)
FBC_CKE_H: length 31.1
  TOP w0.102: v2(204.26,98.66) 205.01,97.91 205.01,96.64
  TOP w0.185: v2(199.53,91.94) 202.03,91.94 204.58,94.48 204.58,95.38 RV99.2 205.01,95.82 205.01,96.64
  BOTTOM w0.185: UV1.B17 181.69,89.01 185.54,89.01 185.77,88.78 187.9,88.78 188.19,89.07 193.93,89.07 194.8,89.93 197.24,89.93 197.98,90.67 198.26,90.67 v2(199.53,91.94) ; v2(204.26,98.66) 203.86,99.06 UV9.J3
FBC_CKE_L: length 30.6
  TOP w0.102: 204.53,89.27 204.25,88.99 204.25,86.29 v2(204.26,86.28)
  TOP w0.185: 204.53,89.27 RV96.2 204.78,89.95 203.62,91.12 195.23,91.12 193.28,89.17 190.93,89.17 188.99,87.23 v2(188.99,86.99)
  BOTTOM w0.185: v2(188.99,86.99) 188.99,86.99 185,86.99 184.8,87.18 182.63,87.18 182.51,87.31 181.8,87.31 181.41,87.71 UV1.B15 ; UV8.J3 v2(204.26,86.28)
FBC_CLK0: length 32.2
  TOP w0.102: 184.69,83.6 183.71,84.58 180.76,84.58 180.68,84.66 180.68,85.16 180.43,85.41 180.31,85.41 v2(180.09,85.63)
  TOP w0.124: v2(192.97,78.53) 192.53,78.09 192.03,78.09 191.5,78.62 189.65,78.62 188.17,80.1 184.79,83.48 184.79,83.49 184.69,83.59 184.69,83.6
  IN1 w0.102: v2(204.26,79.08) 203.85,79.49 203.34,79.49 203.33,79.5 203.3,79.5 202.06,80.74 202.04,80.74 202.02,80.76 202.01,80.76
  IN1 w0.117: 202.01,80.76 201.96,80.82 201.96,80.86 201.34,81.47 196.7,81.47 195.21,79.99 194.4,79.99 192.97,78.56 v2(192.97,78.53)
  BOTTOM w0.124: v2(180.09,85.63) 180.09,85.61 UV1.D12 ; UV8.J12 v2(204.26,79.08) ; v2(192.97,78.53) 193.05,78.45 RV599.1
FBC_CLK0#: length 32.4
  TOP w0.102: v2(179.29,85.63) 180.07,85.21 180.35,85.21 180.48,85.08 180.48,84.57 180.67,84.38 183.6,84.38 184.47,83.51 184.47,83.5 184.53,83.44
  TOP w0.124: v2(193.63,78.58) 192.92,77.87 191.94,77.87 191.41,78.4 189.56,78.4 187.95,80.01 184.57,83.39 184.57,83.39 184.53,83.44
  IN1 w0.102: 201.73,80.76 201.73,80.75 201.93,80.55 201.95,80.55 201.96,80.54 201.98,80.54 203.22,79.3 203.24,79.3 v2(203.46,79.08)
  IN1 w0.117: v2(193.63,78.58) 193.63,78.91 194.49,79.76 195.3,79.76 196.79,81.25 201.25,81.25 201.73,80.77 201.73,80.76
  BOTTOM w0.124: UV8.J11 v2(203.46,79.08) ; UV1.E12 178.89,85.23 v2(179.29,85.63) ; RV598.1 193.94,78.27 v2(193.63,78.58)
FBC_CLK1: length 37.8
  TOP w0.102: v2(178.46,91.48) 178.32,91.63 178.32,91.81 178.44,91.94 179.46,91.94 179.94,92.42 180.26,92.42 180.59,92.75 181.92,92.75 182.25,92.42 183.94,92.42 184.36,92.85
  TOP w0.124: v2(192.54,103.24) 192.34,103.44 191.42,103.44 185.23,97.25 185.23,93.71 184.36,92.85
  IN1 w0.117: v2(192.54,103.24) 192.86,103.24 193.06,103.04 201.1,103.04 202.7,104.64 202.7,104.99 203.19,105.48 203.3,105.48 203.3,105.48 203.62,105.48 203.87,105.48 v2(204.26,105.86)
  BOTTOM w0.124: v2(192.54,103.24) 192.54,103.29 191.53,104.3 RV601.1 ; UV9.J12 203.86,106.26 v2(204.26,105.86) ; UV1.E20 178.89,91.88 178.5,91.48 v2(178.46,91.48)
FBC_CLK1#: length 37.1
  TOP w0.102: 183.95,92.75 183.82,92.62 182.33,92.62 182,92.95 180.51,92.95 180.18,92.62 179.86,92.62 179.38,92.14 178.36,92.14 178.11,91.9 178.11,91.79 177.8,91.48 v2(177.61,91.48)
  TOP w0.124: v2(192.88,103.71) 192.84,103.67 191.33,103.67 185.01,97.34 185.01,93.81 183.95,92.75
  IN1 w0.117: v2(203.46,105.86) 203.26,105.86 202.48,105.09 202.48,104.73 201.01,103.26 193.16,103.26 192.88,103.53 v2(192.88,103.71)
  BOTTOM w0.124: UV9.J11 v2(203.46,105.86) ; v2(192.88,103.71) 192.76,103.71 192.54,103.93 RV600.1 ; v2(177.61,91.48) 177.91,91.48 178.04,91.61 UV1.F20
FBC_CS#_H: length 31.6
  TOP w0.185: v2(180.09,90.63) 180.54,90.63 180.71,90.8 182.84,90.8 v4(183.06,91.02) 189.01,96.96 189.01,98.87 192.41,102.27 192.94,102.27 195.22,104.55 202.1,104.55 202.66,105.1 v2(202.66,105.86)
  BOTTOM w0.185: UV1.D18 179.69,90.23 v2(180.09,90.63) ; v2(202.66,105.86) 202.26,106.26 UV9.L12
FBC_CS#_L: length 27.7
  TOP w0.102: 182.64,85.45 182.48,85.6 182.39,85.6 181.92,86.07 179.7,86.07 v2(179.29,86.48) ; v2(202.66,79.08) 202.27,79.47 197.37,79.47 197.34,79.49 196.91,79.49 196.81,79.59 196.48,79.59
  TOP w0.185: 182.64,85.45 184.21,85.45 187.03,82.63 187.03,82.38 v4(189.28,80.14) 189.82,79.59 196.48,79.59
  BOTTOM w0.185: UV1.D13 179.29,86.46 v2(179.29,86.48) ; UV8.G12 v2(202.66,79.08)
FBC_D0: length 23.3
  IN1 w0.102: 178.04,82.06 178.04,82.42 177.74,82.72 177.2,82.72 v2(176.79,83.13)
  IN1 w0.152: v2(197.06,84.68) 197.03,84.68 194.23,81.88 178.22,81.88 178.04,82.06
  BOTTOM w0.185: UV1.G9 176.79,83.11 v2(176.79,83.13) ; v2(197.06,84.68) 197.46,85.08 UV8.A4
FBC_D1: length 21.3
  IN1 w0.102: 196.48,85.71 196.68,85.91 196.68,86.7 v2(197.06,87.08) ; 184.79,83.76 184.59,83.56 179.71,83.56 v2(179.29,83.13)
  IN1 w0.152: 184.79,83.76 191.88,83.76 192.19,83.45 194.22,83.45 196.48,85.71
  BOTTOM w0.185: UV1.E9 179.29,83.11 v2(179.29,83.13) ; UV8.A2 197.46,86.68 v2(197.06,87.08)
FBC_D2: length 24
  IN1 w0.152: v2(197.86,84.68) 197.57,84.39 197.53,84.39 194.46,81.32 177.8,81.32 177.47,81.65 177.39,81.65 176.98,82.06 176.98,82.15 v2(176.81,82.31)
  BOTTOM w0.185: v2(197.86,84.68) 198.26,85.08 UV8.B4 ; v2(176.81,82.31) 177.19,81.93 UV1.G8
FBC_D3: length 24.4
  IN1 w0.102: 196.62,85.06 196.66,85.1 197.22,85.1 197.47,85.35 197.47,86.69 v2(197.86,87.08) ; v2(177.61,83.13) 177.83,83.13 178.27,82.69 184.6,82.69 184.85,82.44
  IN1 w0.152: 196.62,85.06 194,82.44 184.85,82.44
  BOTTOM w0.185: UV8.B2 198.26,86.68 v2(197.86,87.08) ; v2(177.61,83.13) UV1.F9
FBC_D4: length 28.9
  IN1 w0.102: 196.19,88.14 196.19,88.55 196.7,89.06 199.22,89.06 199.44,88.84 199.44,87.8 199.88,87.36 199.88,85.86 v2(200.26,85.48) ; v2(178.46,84.81) 178.69,84.81 179.09,85.21 179.4,85.21 179.69,85.49 179.69,85.77 179.93,86.01 180.25,86.01 180.49,85.77 180.49,85.49 180.73,85.25 182.19,85.25 182.38,85.44
  IN1 w0.152: 196.19,88.14 193.49,85.44 182.38,85.44
  BOTTOM w0.185: v2(178.46,84.81) 178.06,84.41 UV1.F11 ; v2(200.26,85.48) 200.66,85.08 UV8.E4
FBC_D5: length 28.6
  IN1 w0.102: v2(177.61,84.81) 178.01,85.21 178.58,85.21 178.89,85.52 178.89,85.77 179.21,86.1 179.44,86.1 179.69,86.34 179.69,86.6 179.93,86.84 180.29,86.84 181.05,86.08 182.3,86.08 182.38,86 ; 196.19,89.07 196.38,89.26 199.82,89.26 200.26,88.82 v2(200.26,87.08)
  IN1 w0.152: 182.38,86 193.12,86 196.19,89.07
  BOTTOM w0.185: v2(177.61,84.81) 177.59,84.81 UV1.G11 ; UV8.E2 200.66,86.68 v2(200.26,87.08)
FBC_D6: length 30.3
  IN1 w0.102: v2(201.06,85.48) 200.68,85.86 200.68,87.4 201.04,87.76 201.04,88.87 ; v2(178.46,85.63) 178.46,85.84 178.89,86.26 178.89,86.62 179.31,87.04 179.33,87.04
  IN1 w0.152: 201.04,88.87 200.16,89.75 196.02,89.75 192.83,86.56 181.03,86.56 180.52,87.07 179.36,87.07 179.33,87.04
  BOTTOM w0.185: v2(201.06,85.48) 201.46,85.08 UV8.F4 ; UV1.F12 v2(178.46,85.63)
FBC_D7: length 35.4
  IN1 w0.102: v2(201.86,86.28) 202.24,85.9 202.82,85.9 203.06,86.14 203.06,87.38 203.36,87.68 203.36,88.89 ; 179.84,87.76 179.57,87.76 178.72,86.91 177.5,86.91 177.23,86.64 177.23,86.01 v2(177.61,85.63)
  IN1 w0.152: 203.36,88.89 201.38,90.87 195.18,90.87 192.44,88.13 180.21,88.13 179.84,87.76
  BOTTOM w0.185: UV8.F2 v2(201.86,86.28) ; v2(177.61,85.63) UV1.G12
FBC_D8: length 22.5
  IN1 w0.102: v2(197.06,79.88) 196.29,79.11 195.92,79.11 ; 184.85,79.29 184.67,79.46 182.69,79.46 181.94,80.21 177.94,80.21 v2(177.57,80.58)
  IN1 w0.152: 195.92,79.11 195.41,79.11 194.27,77.97 191.74,77.97 190.42,79.29 184.85,79.29
  BOTTOM w0.185: v2(197.06,79.88) 197.46,79.48 UV8.A11 ; UV1.G6 v2(177.57,80.58)
FBC_D9: length 21.6
  IN1 w0.102: 195.92,76.95 196.45,77.48 v2(197.06,77.48) ; v2(178.39,78.91) 178.69,78.91 179.07,78.53 183.93,78.53 184.85,77.62 184.85,77.18
  IN1 w0.152: 195.92,76.95 195.26,76.29 190.15,76.29 189.67,76.77 185.25,76.77 184.85,77.18
  BOTTOM w0.185: v2(197.06,77.48) 197.46,77.88 UV8.A13 ; UV1.F5 v2(178.39,78.91)
FBC_D10: length 21.4
  IN1 w0.102: 195.92,78.55 196.05,78.68 197.46,78.68 v2(197.86,79.08) ; 184.85,78.73 184.42,79.16 180.09,79.16 179.44,79.81 v2(179.29,79.81)
  IN1 w0.152: 184.85,78.73 190.19,78.73 191.5,77.41 194.78,77.41 195.92,78.55
  BOTTOM w0.185: UV1.E6 v2(179.29,79.81) ; v2(197.86,79.08) 198.26,79.48 UV8.B11
FBC_D11: length 22.3
  IN1 w0.102: v2(197.86,77.48) 197.48,77.86 196.04,77.86 195.92,77.74 ; v2(178.46,79.73) 178.84,79.36 179.49,79.36 179.99,78.86 184.16,78.86 184.85,78.17
  IN1 w0.152: 184.85,78.17 189.95,78.17 191.27,76.85 195.03,76.85 195.92,77.74
  BOTTOM w0.185: UV1.F6 v2(178.46,79.73) ; v2(197.86,77.48) 198.26,77.88 UV8.B13
FBC_D12: length 29.7
  IN1 w0.102: 182.89,76.06 182.84,76.11 181.02,76.11 180.22,76.91 179.08,76.91 178.8,77.18 178.8,78.24 178.54,78.5 177.97,78.5 v2(177.57,78.91) ; 198.59,74.84 199.46,75.72 199.46,76.78 199.86,77.18 199.86,78.68 v2(200.26,79.08)
  IN1 w0.152: 198.59,74.84 198.28,74.54 184.41,74.54 182.89,76.06
  BOTTOM w0.185: UV1.F4 177.59,78.91 v2(177.57,78.91) ; UV8.E11 v2(200.26,79.08)
FBC_D13: length 32.5
  IN1 w0.102: v2(201.06,78.28) 201.44,77.9 201.44,77.2 201.84,76.8 201.84,75.56 201.13,74.84 ; 178.12,76.63 177.99,76.76 177.99,77.68 v2(177.57,78.11)
  IN1 w0.152: 201.13,74.84 199.14,72.86 181.49,72.86 178.12,76.24 178.12,76.63
  BOTTOM w0.185: UV1.G4 177.54,78.11 v2(177.57,78.11) ; UV8.E13 v2(201.06,78.28)
FBC_D14: length 27.7
  IN1 w0.102: v2(201.06,79.08) 200.67,78.69 200.67,77.19 200.26,76.78 200.26,75.68 199.43,74.84 ; 182.84,75.31 181.14,75.31 180.34,76.11 179.61,76.11 v2(179.22,76.51)
  IN1 w0.152: 182.84,75.31 184.17,73.98 198.56,73.98 199.43,74.84
  BOTTOM w0.185: v2(179.22,76.51) 178.81,76.91 UV1.E2 ; UV8.F11 v2(201.06,79.08)
FBC_D15: length 28.5
  IN1 w0.102: 200.32,74.84 201.06,75.58 v2(201.06,77.48)
  IN1 w0.152: v2(178.39,77.31) 178.39,76.76 181.73,73.42 198.9,73.42 200.32,74.84
  BOTTOM w0.185: UV8.F13 v2(201.06,77.48) ; UV1.F3 v2(178.39,77.31)
FBC_D16: length 35.3
  IN4 w0.102: 207.11,74.59 208.24,75.72 208.24,76.92 208.64,77.32 208.64,77.6 208.92,77.88 209.2,77.88 209.46,78.14 209.46,79.48 v2(209.86,79.88)
  IN4 w0.152: v2(182.52,74.91) 183.1,74.32 206.84,74.32 207.11,74.59
  BOTTOM w0.185: UV1.C2 180.89,76.51 180.89,75.86 181.14,75.61 181.81,75.61 v2(182.52,74.91) ; UV8.U11 v2(209.86,79.88)
FBC_D17: length 38.3
  IN4 w0.102: 208.8,74.59 209.86,75.65 v2(209.86,77.48)
  IN4 w0.152: v2(179.22,78.11) 180.26,77.07 180.3,77.07 180.62,76.74 180.62,76.28 180.5,76.15 180.5,75.31 180.33,75.14 180.33,74.68 181.8,73.2 207.41,73.2 208.8,74.59
  BOTTOM w0.185: UV8.U13 v2(209.86,77.48) ; UV1.D4 179.61,78.51 v2(179.22,78.11)
FBC_D18: length 41
  IN4 w0.102: v2(209.86,79.08) 210.64,78.3 210.64,75.37 209.86,74.59
  IN4 w0.152: v2(180.06,76.51) 179.63,76.08 179.63,74.58 181.57,72.64 207.92,72.64 209.86,74.59
  BOTTOM w0.185: v2(180.06,76.51) 180.06,77.28 UV1.D3 ; v2(209.86,79.08) 209.46,79.48 UV8.T11
FBC_D19: length 33.1
  IN4 w0.102: 207.91,74.59 209.06,75.74 v2(209.06,77.48)
  IN4 w0.152: 207.91,74.59 207.08,73.76 182.04,73.76 v2(180.89,74.91)
  BOTTOM w0.185: UV1.C1 180.49,75.31 v2(180.89,74.91) ; UV8.T13 v2(209.06,77.48)
FBC_D20: length 30.1
  IN4 w0.102: v2(207.46,79.08) 207.08,78.7 207.08,77.36 206.58,76.86 204.29,76.86
  IN4 w0.152: 204.29,76.86 204.25,76.9 196.22,76.9 195.66,77.46 187.49,77.46 186.93,76.9 184.19,76.9 184.15,76.94 182.91,76.94 182.66,76.69 182.66,76.68 v2(182.49,76.51)
  BOTTOM w0.185: UV8.N11 207.06,79.48 v2(207.46,79.08) ; UV1.B3 181.69,77.31 182.41,77.31 182.51,77.21 182.51,76.93 182.49,76.91 v2(182.49,76.51)
FBC_D21: length 30.6
  IN4 w0.102: 203.08,79.49 203.08,79.49 203.08,78.12 203.61,77.59 204.37,77.59 204.86,77.1 206.28,77.1 v2(206.66,77.48)
  IN4 w0.152: v2(180.89,78.13) 181.44,77.59 183.91,77.59 184.41,78.1 194.37,78.1 196.56,80.29 202.29,80.29 203.08,79.49
  BOTTOM w0.185: v2(180.89,78.13) 180.89,78.16 UV1.C4 ; UV8.N13 v2(206.66,77.48)
FBC_D22: length 31.1
  IN4 w0.102: 204.68,79.35 204.68,78.12 204.9,77.9 206.02,77.9 206.26,78.14 206.26,78.68 v2(206.66,79.08)
  IN4 w0.152: v2(183.79,78.13) 183.79,78.59 184.29,79.09 194.47,79.09 196.59,81.21 203.03,81.21 203.27,80.97 203.27,80.64 203.55,80.36 203.67,80.36 204.68,79.35
  BOTTOM w0.185: UV8.M11 206.26,79.48 v2(206.66,79.08) ; UV1.B5 181.54,79.41 182.09,78.86 183.06,78.86 v2(183.79,78.13)
FBC_D23: length 31.2
  IN4 w0.102: 205.47,79.39 205.47,78.67 v2(205.86,78.28)
  IN4 w0.152: 205.47,79.39 205.11,79.75 205.11,80.96 204.04,82.03 196.48,82.03 194.12,79.67 183.32,79.67 182.49,78.84 v2(182.49,78.13)
  BOTTOM w0.185: v2(182.49,78.13) 182.05,78.57 181.97,78.57 181.53,79.01 180.89,79.01 UV1.C5 ; UV8.M13 v2(205.86,78.28)
FBC_D24: length 34.7
  IN4 w0.102: 208.26,88.88 208.26,87.75 208.67,87.34 208.67,86.93 208.9,86.7 209.18,86.7 209.44,86.44 209.44,85.9 v2(209.86,85.48)
  IN4 w0.152: v2(183.09,83.98) 183.09,84.52 184.01,85.44 185.02,85.44 188.12,88.53 194.19,88.53 195.97,90.31 206.84,90.31 208.26,88.88
  BOTTOM w0.185: UV8.U4 v2(209.86,85.48) ; v2(183.09,83.98) 182.82,84.25 182.66,84.41 UV1.A11
FBC_D25: length 37.3
  IN4 w0.102: v2(209.86,87.08) 209.86,89.1 209.1,89.86
  IN4 w0.152: v2(180.09,83.98) 180.55,84.45 181.66,84.45 182.76,85.54 182.76,85.97 183.35,86.55 184.31,86.55 187.56,89.8 193.58,89.8 195.23,91.46 207.5,91.46 209.1,89.86
  BOTTOM w0.185: v2(180.09,83.98) 180.29,84.18 180.29,84.21 UV1.C11 ; UV8.U2 v2(209.86,87.08)
FBC_D26: length 42.3
  IN4 w0.102: v2(209.86,84.68) 210.64,85.46 210.64,89.28 210.07,89.86 ; v2(179.29,84.81) 179.69,85.21 180.48,85.21
  IN4 w0.152: 180.48,85.21 180.5,85.23 181.86,85.23 182.1,85.46 182.1,86.19 183.02,87.11 183.86,87.11 187.13,90.39 193.33,90.39 195.39,92.45 207.48,92.45 210.07,89.86
  BOTTOM w0.185: UV1.D11 v2(179.29,84.81) ; UV8.T4 v2(209.86,84.68)
FBC_D27: length 34.1
  IN4 w0.102: 208.21,89.86 209.06,89.01 v2(209.06,87.08)
  IN4 w0.152: 208.21,89.86 207.2,90.87 195.43,90.87 193.68,89.12 187.89,89.12 184.77,85.99 183.93,85.99 182.33,84.39 182.32,84.39 182.08,84.15 182.08,84.15 181.92,83.98 v2(181.69,83.98)
  BOTTOM w0.185: v2(181.69,83.98) 181.29,84.38 UV1.B11 ; UV8.T2 v2(209.06,87.08)
FBC_D28: length 29.9
  IN4 w0.102: 196.86,85.86 206.28,85.86 v2(206.66,85.48)
  IN4 w0.152: 196.86,85.86 196.84,85.86 192.99,82.01 185,82.01 184.7,82.31 v2(184.24,82.31)
  BOTTOM w0.185: v2(184.24,82.31) 183.44,81.51 180.09,81.51 UV1.D8 ; UV8.N4 v2(206.66,85.48)
FBC_D29: length 28.8
  IN4 w0.102: v2(206.66,86.28) 206.24,86.7 206.24,87.24 206.02,87.46
  IN4 w0.152: v2(183.64,83.13) 184.26,83.75 186.36,83.75 187.49,84.88 193.35,84.88 196.1,87.62 205.86,87.62 206.02,87.46
  BOTTOM w0.102: v2(183.64,83.13) 183.23,82.72 183.23,82.1 183.04,81.91 183.04,81.91 183.02,81.89 182.11,81.89 UV1.A8
  BOTTOM w0.185: UV8.N2 v2(206.66,86.28)
FBC_D30: length 28.1
  IN4 w0.102: v2(180.89,82.31) 181.42,81.78 184.45,81.78 ; 196.86,85.06 205.48,85.06 v2(205.86,84.68)
  IN4 w0.152: 184.45,81.78 184.81,81.42 193.19,81.42 196.83,85.06 196.86,85.06
  BOTTOM w0.185: UV1.C8 v2(180.89,82.31) ; UV8.M4 v2(205.86,84.68)
FBC_D31: length 27.3
  IN4 w0.102: 184.67,82.72 183.25,82.72 v2(182.84,82.31) ; 196.86,86.68 205.46,86.68 v2(205.86,87.08)
  IN4 w0.152: 184.67,82.72 192.88,82.72 196.84,86.68 196.86,86.68
  BOTTOM w0.185: v2(182.84,82.31) 181.69,82.31 UV1.B8 ; UV8.M2 v2(205.86,87.08)
FBC_D32: length 22.8
  IN1 w0.102: v2(177.61,95.63) 178,95.25 184.46,95.25
  IN1 w0.152: 184.46,95.25 184.65,95.25 185.02,95.62 187.06,95.62 191.39,99.95 196.75,99.95 v2(197.06,100.26)
  BOTTOM w0.185: v2(197.06,100.26) 197.45,99.86 UV9.U4 ; UV1.F24 v2(177.61,95.63)
FBC_D33: length 22.4
  IN1 w0.102: 184.45,94.4 184.28,94.57 178.17,94.57 v2(177.59,93.98)
  IN1 w0.152: 184.45,94.4 187.46,94.4 190.93,97.87 v2(197.06,97.87)
  BOTTOM w0.185: v2(197.06,97.87) 197.45,98.26 UV9.U2 ; UV1.G23 177.59,94.01 v2(177.59,93.98)
FBC_D34: length 22.9
  IN1 w0.102: v2(178.46,95.63) 178.91,96.08 182.76,96.08
  IN1 w0.152: v2(197.86,100.26) 197.38,100.74 191.29,100.74 186.81,96.26 182.94,96.26 182.76,96.08
  BOTTOM w0.185: UV1.E24 v2(178.46,95.63) ; UV9.T4 198.26,99.87 v2(197.86,100.26)
FBC_D35: length 25.3
  IN1 w0.102: 196.73,99.05 197.47,99.05 v2(197.86,98.66) ; v2(176.79,94.01) 177.74,94.96 184.46,94.96
  IN1 w0.152: 184.46,94.96 187.23,94.96 191.32,99.05 196.73,99.05
  BOTTOM w0.185: v2(197.86,98.66) 198.26,98.27 UV9.T2 ; v2(176.79,94.01) 176.79,94.81 UV1.G24
FBC_D36: length 26.2
  IN1 w0.102: 199.16,95.82 199.46,96.13 199.46,97.06 199.86,97.46 199.86,99.06 v2(200.26,99.46)
  IN1 w0.152: v2(180.09,93.13) 180.54,92.69 181.63,92.69 182.05,92.27 185.45,92.27 185.91,92.73 189.79,92.73 192.34,95.27 198.65,95.27 199.16,95.79 199.16,95.82
  BOTTOM w0.185: UV9.N4 v2(200.26,99.46) ; v2(180.09,93.13) 179.69,92.73 UV1.D21
FBC_D37: length 27.3
  IN1 w0.102: v2(178.46,93.13) 178.99,92.61 179.64,92.61 180.08,92.17 181.62,92.17 182.05,91.73 182.3,91.73 ; v2(200.26,97.86) 200.26,96.12 199.96,95.82
  IN1 w0.152: 182.3,91.73 182.33,91.71 189.83,91.71 190.23,92.11 190.23,92.37 192.56,94.71 198.87,94.71 199.96,95.8 199.96,95.82
  BOTTOM w0.185: UV9.N2 v2(200.26,97.86) ; UV1.E21 v2(178.46,93.13)
FBC_D38: length 34.2
  IN1 w0.102: 201.56,95.82 201.84,96.11 201.84,97.18 201.46,97.56 201.46,99.06 v2(201.06,99.46) ; 180.73,90.51 180.47,90.25 179.93,90.25 179.66,90.52 179.66,90.78 179.4,91.04 179.2,91.04 178.85,91.38 178.85,91.64 178.62,91.86 177.17,91.86 v2(176.79,91.48)
  IN1 w0.152: 201.56,95.82 201.56,95.82 199.33,93.59 194.74,93.59 191.66,90.51 180.73,90.51
  BOTTOM w0.185: v2(176.79,91.48) 176.79,92.31 UV1.G21 ; UV9.M4 v2(201.06,99.46)
FBC_D39: length 29.6
  IN1 w0.102: v2(177.64,93.11) 178.49,92.26 179.05,92.26 179.69,91.62 179.69,91.34 179.97,91.07 181.87,91.07 ; 200.76,95.82 201.06,96.12 v2(201.06,97.86)
  IN1 w0.152: 181.87,91.07 189.97,91.07 190.79,91.88 190.79,92.14 192.79,94.15 199.1,94.15 200.76,95.81 200.76,95.82
  BOTTOM w0.185: UV1.F21 v2(177.64,93.11) ; UV9.M2 v2(201.06,97.86)
FBC_D40: length 24.2
  IN1 w0.102: 184.46,98.09 184.42,98.13 182.41,98.13 181.99,97.71 179.89,97.71 179.11,96.93 178,96.93 v2(177.61,97.31)
  IN1 w0.152: 184.46,98.09 186.35,98.09 192.77,104.51 196.51,104.51 v2(197.06,105.06)
  BOTTOM w0.185: v2(177.61,97.31) 177.59,97.31 UV1.G27 ; v2(197.06,105.06) 197.46,105.46 UV9.U11
FBC_D41: length 22.8
  IN1 w0.102: 184.46,98.99 184.08,98.6 182.23,98.6 181.78,98.15 179.33,98.15 v2(179.29,98.11) ; v2(197.06,107.46) 196.57,106.97 196,106.97
  IN1 w0.152: 184.46,98.99 184.68,99.2 185.79,99.2 193.56,106.97 196,106.97
  BOTTOM w0.185: UV9.U13 197.46,107.07 v2(197.06,107.46) ; UV1.D27 v2(179.29,98.11)
FBC_D42: length 26.1
  IN1 w0.102: v2(176.79,97.31) 177.21,97.73 179.51,97.73 179.71,97.93 181.86,97.93 182.33,98.4 184.22,98.4 184.46,98.65 ; 196.38,105.91 196.73,106.26 197.46,106.26 v2(197.86,105.86)
  IN1 w0.152: 184.46,98.65 186.02,98.65 193.15,105.78 196.25,105.78 196.38,105.91
  BOTTOM w0.185: UV9.T11 198.26,105.47 v2(197.86,105.86) ; UV1.G26 v2(176.79,97.31)
FBC_D43: length 25.1
  IN1 w0.102: 195.79,107.58 196.3,107.58 196.58,107.86 197.46,107.86 v2(197.86,107.46) ; v2(178.45,98.21) 178.49,98.26 178.89,98.26 179.12,98.49 179.56,98.49 179.65,98.4 181.64,98.4 182.11,98.86 182.11,99.12 182.38,99.39 183.35,99.39 184.11,100.14 184.46,100.14
  IN1 w0.152: 184.46,100.14 185.93,100.14 193.38,107.58 195.79,107.58
  BOTTOM w0.185: v2(197.86,107.46) 198.26,107.07 UV9.T13 ; v2(178.45,98.21) 178.89,97.77 UV1.E27
FBC_D44: length 30.9
  IN1 w0.102: 195.87,109.36 196.22,109.36 196.66,109.79 198.92,109.79 199.46,109.25 199.46,108.16 199.86,107.76 199.86,106.26 v2(200.26,105.86) ; v2(178.46,98.98) 178.55,99.07 178.55,99.32 178.85,99.62 178.85,99.91 179.19,100.24 181.05,100.24 182.31,101.51 183.44,101.51 183.99,102.05 184.46,102.05
  IN1 w0.152: 184.46,102.05 185.47,102.05 192.78,109.36 195.87,109.36
  BOTTOM w0.185: v2(200.26,105.86) 200.66,105.47 UV9.N11 ; UV1.E29 v2(178.46,98.98)
FBC_D45: length 36.8
  IN1 w0.102: 183.25,103.77 182.48,103.77 181.4,102.69 181.05,102.69 180.73,102.69 180.51,102.47 180.51,102.18 180.23,101.89 179.88,101.89 179.64,101.66 179.64,101.31 179.44,101.11 179.09,101.11 178.84,100.86 178.84,100.51 178.55,100.22 178.55,99.97 v2(178.46,99.88) ; v2(200.26,106.66) 200.26,106.41 200.66,106.01 200.66,105.66 200.85,105.47 201.22,105.47 201.46,105.71 201.46,106.86 201.71,107.11 201.71,108.01 201.86,108.16 201.86,109.56 201.65,109.77
  IN1 w0.152: 201.65,109.77 200.7,110.72 200.23,111.19 192.24,111.19 184.82,103.77 183.25,103.77
  BOTTOM w0.185: UV1.F29 v2(178.46,99.88) ; v2(200.26,106.66) 200.66,107.06 UV9.N13
FBC_D46: length 32.1
  IN1 w0.102: v2(179.29,100.71) 179.49,100.71 179.83,101.05 180.17,101.05 180.51,101.39 180.51,101.64 180.78,101.91 181.1,101.91 181.85,102.66 183.44,102.66 183.95,103.17 184.46,103.17 ; v2(201.06,105.86) 200.92,106.01 200.92,106.16 200.68,106.4 200.68,106.82 200.9,107.04 201.18,107.04 201.44,107.31 201.44,107.78 201.06,108.16 201.06,109.56 200.85,109.77
  IN1 w0.152: 184.46,103.17 185.01,103.17 192.47,110.63 199.99,110.63 200.85,109.77
  BOTTOM w0.185: UV1.E30 v2(179.29,100.71) ; UV9.M11 v2(201.06,105.86)
FBC_D47: length 27.9
  IN1 w0.102: 184.46,102.61 184.04,102.61 183.78,102.36 182.03,102.36 181.29,101.62 181.29,101.34 181.03,101.08 180.71,101.08 180.27,100.63 v2(180.09,100.63) ; 196.58,110.07 199.47,110.07 200.26,109.29 200.26,108.26 v2(201.06,107.46)
  IN1 w0.152: 184.46,102.61 185.24,102.61 192.7,110.07 196.58,110.07
  BOTTOM w0.185: v2(180.09,100.63) 180.09,100.61 UV1.D30 ; UV9.M13 v2(201.06,107.46)
FBC_D48: length 35.7
  IN4 w0.102: v2(209.86,105.86) 209.44,106.28 209.44,106.82 209.22,107.04 208.94,107.04 208.68,107.31 208.68,107.73 209.04,108.1 209.04,109.22 208.74,109.52
  IN4 w0.152: v2(182.64,101.91) 182.64,102.1 183.07,102.53 183.77,102.53 183.92,102.68 184.95,102.68 191.78,109.51 198.87,109.51 199.68,110.33 207.94,110.33 208.74,109.52
  BOTTOM w0.185: UV9.A11 v2(209.86,105.86) ; UV1.A32 v2(182.64,101.91)
FBC_D49: length 38.8
  IN4 w0.102: v2(209.86,107.46) 210.64,108.25 210.64,109.98 210.3,110.33 ; v2(180.89,101.48) 182.05,102.64 182.05,103.21 182.33,103.49 182.8,103.49 182.8,103.5 182.89,103.5 182.89,103.5
  IN4 w0.152: 182.89,103.5 183.06,103.67 183.06,103.67 183.19,103.8 184.29,103.8 191.12,110.63 198,110.63 198.81,111.45 209.18,111.45 210.3,110.33
  BOTTOM w0.185: UV1.C31 180.89,101.46 v2(180.89,101.48) ; UV9.A13 v2(209.86,107.46)
FBC_D50: length 42.1
  IN4 w0.102: 182.35,103.75 182.3,103.75 181.16,102.6 181.16,102.58 v2(180.89,102.31)
  IN4 w0.152: v2(209.86,105.06) 211.47,106.67 211.47,109.95 209.41,112 198.41,112 197.6,111.19 190.87,111.19 184.03,104.36 182.96,104.36 182.35,103.75
  BOTTOM w0.185: v2(209.86,105.06) 209.46,105.46 UV9.B11 ; UV1.C32 v2(180.89,102.31)
FBC_D51: length 36.1
  IN4 w0.102: 209.5,110.33 209.84,109.98 209.84,108.25 v2(209.06,107.46)
  IN4 w0.152: v2(183.29,103.11) 183.56,103.11 183.69,103.24 184.67,103.24 191.5,110.07 198.41,110.07 199.22,110.89 208.94,110.89 209.5,110.33
  BOTTOM w0.185: UV1.B32 181.69,102.31 182.49,102.31 v2(183.29,103.11) ; UV9.B13 v2(209.06,107.46)
FBC_D52: length 33.7
  IN4 w0.102: 205.69,102.66 207.05,104.01 207.05,105.5 207.41,105.86 v2(207.46,105.86) ; v2(180.09,99.81) 180.2,99.81 180.47,99.54 180.47,98.67 180.81,98.34 183.91,98.34 184.36,98.8 184.36,99.02 184.41,99.08
  IN4 w0.152: 184.41,99.08 184.52,99.18 186.72,99.18 188.73,101.19 194.65,101.19 196.12,102.66 205.69,102.66
  BOTTOM w0.185: UV9.E11 v2(207.46,105.86) ; UV1.D29 v2(180.09,99.81)
FBC_D53: length 28.8
  IN4 w0.102: v2(183.09,99.81) 183.11,99.81 183.63,100.32 184.29,100.32 184.41,100.45 ; 205.47,105.5 205.47,106.11 205.62,106.26 206.36,106.26 206.66,106.56 v2(206.66,106.66)
  IN4 w0.152: 205.47,105.5 204.77,104.8 203.86,104.8 203.52,104.47 203.47,104.47 203.27,104.27 203.27,103.98 203.01,103.72 202.44,103.72 202.32,103.85 194.65,103.85 193.1,102.3 188.27,102.3 186.41,100.45 184.41,100.45
  BOTTOM w0.102: v2(183.09,99.81) 182.69,99.41 UV1.A29
  BOTTOM w0.185: UV9.E13 v2(206.66,106.66)
FBC_D54: length 30.7
  IN4 w0.102: 206.26,103.95 206.26,105.25 206.66,105.65 v2(206.66,105.86) ; v2(180.89,98.98) 181.31,99.41 183.75,99.41 184.16,99.81
  IN4 w0.152: 184.16,99.81 184.17,99.81 184.19,99.79 186.54,99.79 188.5,101.75 193.81,101.75 195.29,103.22 205.52,103.22 206.26,103.95
  BOTTOM w0.185: UV1.C29 180.89,99.01 v2(180.89,98.98) ; UV9.F11 v2(206.66,105.86)
FBC_D55: length 29.2
  IN4 w0.102: 184.41,101.01 184.18,101.01 183.83,100.65 182.53,100.65 v2(181.69,99.81) ; 202.93,105.48 204.48,105.48 204.66,105.65 204.66,106.85 204.89,107.08 205.45,107.08 205.83,107.46 v2(205.86,107.46)
  IN4 w0.152: 202.93,105.48 201.95,104.49 189.5,104.49 186.01,101.01 184.41,101.01
  BOTTOM w0.185: UV9.F13 v2(205.86,107.46) ; UV1.B29 v2(181.69,99.81)
FBC_D56: length 37.7
  IN4 w0.102: v2(210.66,100.26) 210.28,99.88 210.28,98.51 210.5,98.28 210.78,98.28 211.04,98.02 211.04,97.55 210.66,97.16 210.66,95.88
  IN4 w0.152: 210.66,95.88 210.66,95.71 208.52,93.57 194.32,93.57 192.51,91.75 183.86,91.75 182.49,93.12 v2(182.49,93.13)
  BOTTOM w0.185: UV9.A4 210.26,99.86 v2(210.66,100.26) ; UV1.B21 181.54,92.71 182.01,93.18 182.44,93.18 v2(182.49,93.13)
FBC_D57: length 38.9
  IN4 w0.152: v2(210.66,98.66) 211.22,98.66 211.59,98.29 211.59,95.43 209.17,93.01 194.55,93.01 192.74,91.19 183.63,91.19 180.89,93.93 v2(180.89,93.98)
  BOTTOM w0.185: UV9.A2 210.26,98.26 v2(210.66,98.66) ; v2(180.89,93.98) 180.89,94.19 180.67,94.41 UV1.C23
FBC_D58: length 34.1
  IN4 w0.102: v2(209.86,99.46) 209.48,99.08 209.48,98.51 209.74,98.24 210.02,98.24 210.24,98.02 210.24,97.6 209.86,97.21 209.86,95.88
  IN4 w0.152: v2(183.69,93.13) 191.55,93.13 192.54,94.12 207.23,94.12 208.59,95.49 209.56,95.49 209.86,95.79 209.86,95.88
  BOTTOM w0.185: v2(209.86,99.46) 209.46,99.86 UV9.B4 ; UV1.A21 183.27,92.71 v2(183.69,93.13)
FBC_D59: length 32.8
  IN4 w0.102: v2(209.86,97.86) 209.35,97.35 208.61,97.35 208.26,97.01 208.26,96.08 208.06,95.88
  IN4 w0.152: 208.06,95.88 208.06,95.77 206.97,94.68 192.26,94.68 191.44,93.86 184.42,93.86 v2(184.29,93.98)
  BOTTOM w0.185: v2(184.29,93.98) 183.87,93.56 181.94,93.56 181.49,93.11 180.89,93.11 UV1.C21 ; UV9.B2 209.46,98.26 v2(209.86,97.86)
FBC_D60: length 28.1
  IN4 w0.102: v2(206.66,99.46) 206.24,99.05 206.24,98.51 206.02,98.28 196.88,98.28 196.86,98.26 ; 184.86,96.19 182.25,96.19 v2(181.69,95.63)
  IN4 w0.152: 184.86,96.19 190.61,96.19 192.43,98.01 196.61,98.01 196.86,98.26
  BOTTOM w0.185: v2(181.69,95.63) 181.69,95.44 181.46,95.21 UV1.B24 ; UV9.E4 v2(206.66,99.46)
FBC_D61: length 28.4
  IN4 w0.152: v2(206.66,97.86) 206.44,97.86 205.93,97.35 192.56,97.35 190.84,95.63 v2(184.29,95.63)
  BOTTOM w0.185: UV9.E2 v2(206.66,97.86) ; UV1.C24 180.89,94.81 183.89,94.81 184.29,95.21 v2(184.29,95.63)
FBC_D62: length 26.9
  IN4 w0.102: v2(205.86,100.26) 205.08,100.26 204.68,99.86 196.86,99.86 ; v2(183.29,96.91) 183.68,97.3 184.41,97.3
  IN4 w0.152: 184.41,97.3 184.44,97.3 184.57,97.42 190.16,97.42 192.11,99.38 196.07,99.38 196.56,99.86 196.86,99.86
  BOTTOM w0.185: UV1.B26 181.44,96.91 181.84,96.51 182.44,96.51 182.84,96.91 v2(183.29,96.91) ; UV9.F4 206.26,99.86 v2(205.86,100.26)
FBC_D63: length 27.6
  IN4 w0.102: v2(205.86,98.66) 205.45,99.08 196.86,99.08
  IN4 w0.152: 196.86,99.08 196.76,99.08 196.4,98.72 192.35,98.72 190.49,96.87 v2(184.52,96.87)
  BOTTOM w0.185: v2(184.52,96.87) 184.52,96.74 184,96.22 181.72,96.22 181.43,96.51 180.89,96.51 UV1.C26 ; v2(205.86,98.66) 206.26,98.26 UV9.F2
FBC_DBI0#: length 24.3
  IN1 w0.102: 195.92,87.04 196.55,87.66 198.88,87.66 v2(199.46,87.08) ; 182.71,84.88 180.67,84.88 180.36,85.19 179.93,85.19 179.69,84.95 179.69,84.67 179.43,84.41 UV1.E11 v2(178.46,83.98)
  IN1 w0.152: 182.71,84.88 193.77,84.88 195.92,87.04
  BOTTOM w0.185: v2(199.46,87.08) 199.86,86.68 UV8.D2 ; UV1.E11 v2(178.46,83.98)
FBC_DBI1#: length 24
  IN1 w0.102: 184.85,75.66 184.26,76.24 184.26,76.58 183.91,76.93 180.68,76.93 180.3,77.31 v2(179.22,77.31) ; v2(199.46,77.48) 198.66,76.68 198.66,75.74 198.17,75.25 196.91,75.25
  IN1 w0.152: 196.91,75.25 196.76,75.1 189.57,75.1 189.01,75.66 184.85,75.66
  BOTTOM w0.185: UV1.E3 178.81,77.71 v2(179.22,77.31) ; UV8.D13 v2(199.46,77.48)
FBC_DBI2#: length 28.5
  IN4 w0.102: v2(207.46,77.48) 207.46,77.42 206.68,76.64 206.68,75.76 206.35,75.43
  IN4 w0.152: v2(183.79,76.51) 184.15,76.15 193.85,76.15 193.85,76.15 194.31,76.15 194.61,76.15 195.33,75.44 202.77,75.44 202.78,75.43 206.35,75.43
  BOTTOM w0.185: v2(183.79,76.51) 183.79,76.94 183.49,77.24 183.05,77.24 182.59,77.71 UV1.A3 ; UV8.P13 v2(207.46,77.48)
FBC_DBI3#: length 32.8
  IN4 w0.102: v2(180.06,83.13) 180.45,82.75 182.72,82.75 184.03,84.06 ; v2(207.46,87.08) 206.66,87.88 206.66,88.86 206.64,88.89
  IN4 w0.152: 206.64,88.89 206.41,89.12 196.61,89.12 192.92,85.44 187.25,85.44 186.14,84.32 184.29,84.32 184.03,84.06
  BOTTOM w0.185: UV8.P2 v2(207.46,87.08) ; v2(180.06,83.13) UV1.C9
FBC_DBI4#: length 26.2
  IN1 w0.102: 198.51,95.93 198.64,96.06 198.64,97.07 199.07,97.5 199.07,98.27 v2(199.46,98.66) ; v2(178.46,93.98) 178.91,93.54 180.26,93.54 180.47,93.33
  IN1 w0.152: 180.47,93.33 180.74,93.06 181.95,93.06 182.28,92.73 183.86,92.73 183.96,92.83 185.22,92.83 185.68,93.28 187.94,93.28 190.49,95.83 198.41,95.83 198.51,95.93
  BOTTOM w0.185: UV9.P2 199.86,98.27 v2(199.46,98.66) ; UV1.F23 v2(178.46,93.98)
FBC_DBI5#: length 29.6
  IN1 w0.102: 184.46,101.49 184.06,101.49 183.52,100.95 183.3,100.73 183.3,100.73 183.18,100.61 181.95,100.61 181.31,99.97 181.31,99.69 181.05,99.43 179.19,99.43 178.89,99.12 178.89,98.87 178.62,98.6 178.08,98.6 v2(177.61,98.13) ; 195.79,108.8 196.05,108.8 196.78,109.54 198.56,109.54 198.66,109.44 198.66,108.26 v2(199.46,107.46)
  IN1 w0.152: 195.79,108.8 193.02,108.8 185.71,101.49 184.46,101.49
  BOTTOM w0.185: v2(199.46,107.46) 199.86,107.07 UV9.P13 ; UV1.F27 v2(177.61,98.13)
FBC_DBI6#: length 34.1
  IN4 w0.102: v2(180.89,100.63) 181.34,101.08 181.92,101.08 182.34,101.51 183.45,101.51 183.5,101.55 ; 207.17,109.5 207.46,109.2 v2(207.46,107.46)
  IN4 w0.152: 183.5,101.55 183.67,101.73 183.67,101.84 183.8,101.97 184.01,101.97 184.16,102.12 185.42,102.12 191.18,107.89 203.56,107.89 204.09,108.42 204.09,109.44 204.35,109.69 206.97,109.69 207.17,109.5
  BOTTOM w0.185: v2(180.89,100.63) 180.49,100.23 UV1.C30 ; UV9.D13 v2(207.46,107.46)
FBC_DBI7#: length 29.1
  IN4 w0.102: 206.66,96.05 206.66,97.33 207.04,97.71 207.04,98.25 v2(207.46,98.66)
  IN4 w0.152: v2(183.09,95.63) 183.65,95.07 191.07,95.07 191.82,95.82 206.43,95.82 206.66,96.05
  BOTTOM w0.185: UV9.D2 207.86,98.26 v2(207.46,98.66) ; UV1.A24 182.98,95.21 183.09,95.31 v2(183.09,95.63)
FBC_EDC0: length 23.4
  IN1 w0.102: 196.26,86.57 196.26,86.81 196.9,87.46 198.02,87.46 198.25,87.23 198.25,86.69 v2(198.66,86.28) ; 180.48,84.36 179.79,84.36 179.41,83.98 v2(179.26,83.98)
  IN1 w0.152: 196.26,86.57 196.26,86.28 193.99,84.01 193,84.01 192.69,84.32 183.33,84.32 183.26,84.39 180.5,84.39 180.48,84.36
  BOTTOM w0.185: UV8.C2 199.06,86.68 v2(198.66,86.28) ; UV1.D10 v2(179.26,83.98)
FBC_EDC1: length 23.3
  IN1 w0.102: 184.85,76.29 183.44,77.7 180.5,77.7 v2(180.09,78.11) ; 196.24,75.92 196.24,76.4 196.82,76.98 197.9,76.98 198.25,77.33 198.25,77.87 v2(198.66,78.28)
  IN1 w0.152: 184.85,76.29 184.92,76.22 189.34,76.22 189.9,75.66 195.97,75.66 196.24,75.92
  BOTTOM w0.185: v2(198.66,78.28) 199.06,77.88 UV8.C13 ; v2(180.09,78.11) 180.09,79.01 UV1.D5
FBC_EDC2: length 32.3
  IN4 w0.102: 207.17,75.45 207.48,75.76 207.48,76.75 207.88,77.15 207.88,77.9 v2(208.26,78.28) ; v2(180.89,77.31) 181.24,76.96 181.24,76.42 181.56,76.1 182.71,76.1
  IN4 w0.152: 207.17,75.45 206.6,74.88 194.79,74.88 194.08,75.59 183.22,75.59 182.92,75.89 182.79,76.02 182.71,76.1
  BOTTOM w0.185: UV8.R13 v2(208.26,78.28) ; UV1.C3 v2(180.89,77.31)
FBC_EDC3: length 33.1
  IN4 w0.102: 206.6,89.68 207.48,88.8 207.48,87.82 207.86,87.44 207.86,86.68 v2(208.26,86.28) ; v2(181.69,83.13) 182.12,83.56 183.22,83.56 183.5,83.84 183.5,84.17 183.91,84.57
  IN4 w0.152: 183.91,84.57 184.21,84.88 185.43,84.88 188.43,87.87 194.47,87.87 196.28,89.68 206.6,89.68
  BOTTOM w0.185: UV8.R2 v2(208.26,86.28) ; UV1.B9 181.29,82.73 v2(181.69,83.13)
FBC_EDC4: length 23
  IN1 w0.102: v2(179.29,93.98) 179.67,94.36 180.25,94.36 180.5,94.11 180.5,93.83 180.78,93.56 184.46,93.56
  IN1 w0.152: v2(198.66,97.86) 198.11,97.31 191.18,97.31 187.71,93.84 184.75,93.84 184.46,93.56
  BOTTOM w0.185: UV1.E23 179.29,94.01 v2(179.29,93.98) ; UV9.R2 v2(198.66,97.86)
FBC_EDC5: length 26
  IN1 w0.102: 196,108.24 196.53,108.24 196.71,108.07 197.8,108.07 198.26,107.61 198.26,107.07 v2(198.66,106.66) ; v2(179.29,98.98) 179.41,98.98 179.79,98.6 181.05,98.6 181.31,98.86 181.31,99.14 181.58,99.41 181.83,99.41 182.11,99.69 182.11,99.97 182.36,100.22 183.42,100.22 184.06,100.85
  IN1 w0.152: 196,108.24 193.25,108.24 185.86,100.85 184.06,100.85
  BOTTOM w0.185: v2(179.29,98.98) 179.29,98.96 UV1.E28 ; UV9.R13 199.06,107.06 v2(198.66,106.66)
FBC_EDC6: length 31.5
  IN4 w0.102: v2(208.26,106.66) 207.84,107.08 207.3,107.08 207.08,107.31 207.08,107.58 206.6,108.07 204.53,108.07 203.54,107.08 196.86,107.08 ; v2(183.14,101.11) 183.74,101.11 183.82,101.18
  IN4 w0.152: 196.86,107.08 191.25,107.08 185.74,101.56 184.18,101.56 183.86,101.24 183.86,101.22 183.82,101.18
  BOTTOM w0.185: UV9.C13 v2(208.26,106.66) ; v2(183.14,101.11) 182.64,100.61 181.69,100.61 UV1.B30
FBC_EDC7: length 29.1
  IN4 w0.102: 207.3,95.88 207.45,96.03 207.45,97.05 v2(208.26,97.86)
  IN4 w0.152: 207.3,95.88 206.68,95.26 192.05,95.26 191.2,94.41 183.51,94.41 183.09,93.99 v2(183.09,93.98)
  BOTTOM w0.185: UV1.A23 182.67,94.41 v2(183.09,93.98) ; UV9.C2 v2(208.26,97.86)
FBC_MA0_MA10_H: length 35.3
  TOP w0.102: v2(179.29,88.98) 179.39,88.98 179.77,88.6 181.23,88.6 181.48,88.85 ; v2(203.46,100.26) 203.34,100.38 203.34,101.37 203.07,101.64 200.98,101.64 v3(200.87,101.54) 200.64,101.31 200.64,100.9 200.39,100.65 200.11,100.65 199.84,100.38 199.84,98.51 199.59,98.25 196.9,98.25 196.61,97.97 196.61,97.81 196.35,97.55 196.35,97.3 196.07,97.02 196.07,96.58 195.8,96.3
  TOP w0.185: 195.8,96.3 195.55,96.05 195.55,93.66 195.14,93.26 192.47,90.58 191.15,90.58 189.78,89.21 184.52,89.21 184.32,89.02 181.65,89.02 181.48,88.85
  BOTTOM w0.185: v2(179.29,88.98) 179.29,88.96 UV1.D16 ; v2(203.46,100.26) 203.06,99.86 UV9.K4
FBC_MA0_MA10_L: length 26
  TOP w0.102: v2(202.66,84.68) 202.66,84.87 202.28,85.25 202.28,85.6 201.98,85.9 196.88,85.9 195.86,86.92 195.53,86.92 195.21,87.24
  TOP w0.185: v2(192.67,87.04) 192.87,87.24 195.21,87.24
  BOTTOM w0.185: UV8.H4 v2(202.66,84.68) ; UV1.D15 180.09,88.11 182.49,88.11 182.69,88.31 185.29,88.31 185.55,88.05 187.87,88.05 188.2,88.38 191.33,88.38 v2(192.67,87.04)
FBC_MA1_MA9_H: length 30
  TOP w0.102: 198.51,97.44 198.52,97.45 201.19,97.45 201.44,97.71 201.44,99.58 201.72,99.86 202,99.86 202.91,100.78 v2(202.91,101.26)
  TOP w0.185: v2(195.78,92.01) 195.78,92.38 196.27,92.87 196.27,95.8 196.41,95.93 196.41,97.01 196.84,97.44 198.51,97.44
  BOTTOM w0.185: v2(202.91,101.26) 203.06,101.11 UV9.K5 ; v2(195.78,92.01) 193.1,92.01 192.24,91.15 188.87,91.15 188.58,90.86 184.92,90.86 184.71,90.64 182.84,90.64 182.4,90.21 UV1.A18
FBC_MA1_MA9_L: length 24.6
  TOP w0.102: v2(202.86,83.68) 202.86,83.94 202.28,84.52 202.28,84.8 202,85.08 v3(200.77,85.08) 196.86,85.08 196.57,85.37 196.57,85.43 196.48,85.52 196.48,85.92 196.01,86.39
  TOP w0.185: v2(191.39,86.99) 191.39,86.96 191.8,86.54 195.86,86.54 196.01,86.39
  BOTTOM w0.185: v2(191.39,86.99) 191.39,86.35 191,85.97 185.23,85.97 184.57,86.63 182.37,86.63 UV1.A14 ; v2(202.86,83.68) 203.06,83.88 UV8.H5
FBC_MA2_BA0_H: length 34.2
  TOP w0.102: v2(178.46,90.63) 178.88,90.22 179.48,90.22 179.65,90.05 180.83,90.05
  TOP w0.185: v2(203.46,105.06) 203.46,104.64 203.28,104.46 203.28,103.98 203.04,103.73 197.52,103.73 196.96,103.16 195.79,103.16 v4(195.34,102.71) 193.52,100.89 193.12,100.89 190.69,98.46 190.69,96.68 185.06,91.05 184.54,91.05 183.54,90.05 180.83,90.05
  BOTTOM w0.185: v2(203.46,105.06) 203.06,105.46 UV9.K11 ; UV1.F18 178.04,90.26 178.41,90.63 v2(178.46,90.63)
FBC_MA2_BA0_L: length 31.2
  TOP w0.102: v2(177.61,87.31) 178,87.69 178.66,87.69 179.03,87.32 180.17,87.32 180.56,86.93 182.59,86.93 182.94,86.58 ; 196.83,80.98 202.13,80.98 202.33,81.18 203.02,81.18 203.31,80.89 203.31,80.03 v2(203.46,79.88)
  TOP w0.185: 182.94,86.58 185.04,86.58 188.42,83.2 188.42,82.96 190.4,80.98 v3(196.21,80.98) 196.82,80.98 196.83,80.98
  BOTTOM w0.185: UV1.F14 177.64,87.31 v2(177.61,87.31) ; UV8.H11 v2(203.46,79.88)
FBC_MA3_BA3_H: length 31.7
  TOP w0.102: v2(179.26,90.63) 179.52,90.63 179.9,90.25 180.54,90.25 180.68,90.39 180.76,90.39
  TOP w0.185: v2(202.86,104.15) 197.24,104.15 196.94,103.85 195.5,103.85 193.23,101.58 192.83,101.58 v4(191.72,100.47) 189.85,98.6 189.85,96.82 183.44,90.41 180.78,90.41 180.76,90.39
  BOTTOM w0.185: UV1.E18 179.26,90.58 v2(179.26,90.63) ; UV9.K10 202.86,104.46 v2(202.86,104.15)
FBC_MA3_BA3_L: length 28.9
  TOP w0.102: 182.79,85.89 182.2,86.48 181.74,86.48 181.53,86.69 180.46,86.69 180.24,86.91 178.86,86.91 v2(178.46,87.31) ; 196.86,80.31 202.38,80.31 v2(202.86,80.8)
  TOP w0.185: 182.79,85.89 v4(183.82,85.89) 184.74,85.89 187.72,82.91 187.72,82.67 190.11,80.28 195.67,80.28 195.68,80.28 195.71,80.31 196.86,80.31
  BOTTOM w0.185: UV8.H10 203.06,80.6 v2(202.86,80.8) ; UV1.E14 178.49,87.31 v2(178.46,87.31)
FBC_MA4_BA2_H: length 30
  TOP w0.185: v2(187.33,92.29) 187.33,92.34 191.39,96.4 v4(191.39,97.36) 191.39,98.17 193.41,100.19 193.8,100.19 196.08,102.47 196.92,102.47 197.83,103.37 203.87,103.37 203.89,103.38 203.91,103.38 v2(204.21,103.68)
  BOTTOM w0.185: v2(204.21,103.68) 204.21,104.5 204.23,104.51 204.23,105.03 UV9.H11 ; v2(187.33,92.29) 184.43,92.29 184.04,91.91 UV1.A20
