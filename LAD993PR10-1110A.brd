# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N132584577: length 8.4
  BOTTOM w0.114: UV1.AB8 164.64,81.79 164.2,81.35 164.2,80.84 164.17,80.8 164.17,75.8 164.04,75.67 164.04,74.86 TV106.1
N132618344: length 1.4
  TOP w0.102: v2(180.89,85.63) 181.29,85.23 RV604.1
  BOTTOM w0.185: v2(180.89,85.63) 180.89,85.61 UV1.C12
N132880980: length 3.4
  BOTTOM w0.114: v3(130.9,129.4) 131.68,129.4 PR1530.2
  BOTTOM w0.254: PR1530.2 131.84,128.51 132.85,127.5 PU1503.1
N132881948: length 0.8
  TOP w0.508: PR1531.2 132.85,128.77 v2(133.11,128.51)
  vias: v3(132.64,128.31)
N132883328: length 1.8
  BOTTOM w0.254: PR1532.1 130.95,127.37 131.82,126.49 PU1503.12
N132883570: length 1.4
  TOP w0.114: v2(131.33,126.23) v3(131.87,126.23)
  TOP w0.508: PR1533.2 130.82,126.74 v2(131.33,126.23)
N132883768: length 0.9
  BOTTOM w0.114: 134.6,130.85 v4(134.6,131.7)
N132883846:
  vias: v2(134.88,128.34)
N132883854: length 1.1
  TOP w0.114: v4(133.68,127.26) 134.29,127.87 v2(134.29,128.09)
N133233549: length 2.6
  TOP w0.114: v3(16.76,34.48) PR303.1
  TOP w0.508: PR303.1 17.69,35.54 17.85,35.7 v2(17.85,36.05)
N133233615: length 3.2
  TOP w0.114: PQ306.4 22.49,35.42 v3(22.11,35.04)
  TOP w0.508: PR325.1 23.73,36.31 PQ306.4
N133325166: length 1.9
  TOP w0.102: RV605.1 180.89,92.08 v2(180.89,91.48) v3(180.5,91.1)
  BOTTOM w0.185: UV1.C20 180.89,91.51 v2(180.89,91.48)
N134039053: length 3.9
  TOP w0.114: v3(200.21,59.54) 199.59,58.92 RV606.1 199.51,58.6 199.51,56.89 UV21.1
N134039285: length 3.4
  TOP w0.114: QV3.2 148.36,79.87 147.97,80.26 147.97,80.81 RV56.1 146.96,81.31 v3(146.49,80.84)
N134040693: length 2.3
  TOP w0.114: RZ9.2 148.5,106.05 v3(149.13,105.41) 149.77,105.41 QZ8.3
N134041170: length 3.1
  TOP w0.114: RZ104.2 154.95,75.63 CV921.1 155.84,77.31 QZ7.6 QZ7.5
N134041902: length 2.5
  TOP w0.114: v3(152.26,82.2) 151.91,81.86 RZ11.2 151.91,80.66 QZ12.3
N134042310: length 6.7
  TOP w0.114: v3(156.98,83.87) 156.98,83.1 RZ105.2 156.14,82.26 QZ10.5 QZ10.6 155.49,81.52 155.65,81.36 156.97,81.36 157.39,80.94 157.39,80.41 CV922.1
N134042900: length 5.4
  TOP w0.114: QZ7.3 157.87,78.85 157.99,78.73 157.99,77.35 157.69,77.05 157.24,77.05 157.08,76.9 157.08,75.83 v3(156.99,75.75) 156.54,75.29 RZ10.2
N134045472: length 9
  TOP w0.114: RZ33.2 141.49,17.88 v3(141.12,18.25) 140.82,18.55 140.02,18.55 138.34,16.87 138.34,14.37 138.07,14.1 137.29,14.1 UE4.3
N134170652: length 2.8
  BOTTOM w0.114: QV88.6 QV88.5 150.44,79.29 RV609.2 151.42,79.57 v3(151.62,79.36)
N134170665: length 1.1
  BOTTOM w0.114: RV614.2 150.1,75.78 150.44,76.13 QV88.2
N134170915: length 2.7
  BOTTOM w0.114: RV616.2 148.41,78.31 RV615.2 148.92,78.06 149.49,78.06 149.79,78.36 QV88.4
N134234965: length 3
  TOP w0.114: v3(209.59,60.52) RZ109.2 207.6,60.52 QV92.2 QV92.3
N134312093: length 7.9
  TOP w0.114: R5.1 32.01,37.96 31.12,38.85 QZ13.2 QZ13.3 31.77,39.6 31.54,39.83 30.25,39.83 30.06,39.64 v3(30.06,37.97) 30.28,37.75 30.28,36.61 R1.2
N134312858: length 4.4
  TOP w0.114: v3(32.95,40.34) 31.52,40.34 31.12,40.73 QZ13.5 31.12,41.61 R4.1 R3.2
N134404381: length 8.2
  BOTTOM w0.114: PR113.2 209.46,56.48 210.25,56.48 PR115.1 211.22,56.96 v3(211.66,57.4) 212,57.74 212,61.62 211.82,61.8 PQ103.5
N134410660: length 5.1
  BOTTOM w0.254: PQ203.3 46.09,39.38 45.83,39.63 45.83,40.39 PR209.2 45.22,40.51 v3(45.22,39.8) 45.22,38.93 PR214.1 45.75,38.8 45.83,38.73 PQ203.2
N134534683: length 1.7
  TOP w0.114: v3(27.27,41.57) 27.76,41.07 R2.1
N134535293: length 1.3
  BOTTOM w0.114: RV611.1 230.07,18.84 QV93.2
N201821498: length 2.9
  TOP w0.203: v2(281.42,20.58) 281.51,20.68 HDA1.19
  BOTTOM w0.114: v2(281.42,20.58) 281.33,20.49 281,20.49 v3(280.9,20.39)
  BOTTOM w0.203: CA23.1 281.63,20.79 v2(281.42,20.58)
N201821507: length 2.4
  TOP w0.203: 285.58,26.86 285.58,26.84 v3(285.45,26.7) 284.9,26.15 HDA1.34
  TOP w0.254: CA15.2 285.63,26.91 285.58,26.86
N201821575: length 3.5
  TOP w0.114: v3(286.83,24.46) CA16.2
  TOP w0.203: CA16.2 286.8,23.54 285.44,23.54 285.22,23.76 HDA1.28
N201821604: length 2.5
  TOP w0.114: HDA1.7 277.66,24.55 277.61,24.5 v1(277.07,24.5) 276.3,24.5 CA27.1
N201821615: length 2.8
  TOP w0.203: v2(285,27.37) 285.11,27.26 285.11,26.9 284.77,26.55 HDA1.35
  BOTTOM w0.114: v2(285,27.37) v3(284.53,26.91)
  BOTTOM w0.203: v2(285,27.37) 285.16,27.54 CA20.2
N201821733: length 2.8
  TOP w0.203: HDA1.37 283.51,28.22 283.98,28.69 v2(284.11,28.69)
  BOTTOM w0.203: v2(284.11,28.69) 284.11,28.69 284.35,28.45 v3(284.63,28.45) CA20.1
N201821740: length 3.9
  TOP w0.203: HDA1.27 285.19,23.36 285.37,23.18 v3(285.57,23.18) 285.87,23.18 CA19.2
  TOP w0.254: CA19.2 286.95,22.1 RA11.2
N1211736753: length 3.7
  BOTTOM w0.114: T91.1 155.79,38.29 156.94,37.15 156.94,37.12 157.32,36.74 UH2.R44
N1211736758: length 3.9
  BOTTOM w0.114: T94.1 156.32,37.44 156.71,37.05 156.71,37.02 157.17,36.56 157.17,36.55 157.29,36.44 157.87,36.44 158.25,36.06 158.25,35.91 UH2.U42
N1331773500: length 1.7
  TOP w0.114: CA34.2 RA36.1 269.99,23.83 v3(269.59,24.22)
N1331775041: length 0.7
  TOP w0.114: RA37.1 CA35.2
N1336984400: length 3.8
  BOTTOM w0.114: UH2.AL42 158.43,28.76 158.17,29.02 155.13,29.02 T120.1
N12117367569: length 1.3
  TOP w0.114: v2(162.47,30.57) 162.47,30.63 T182.1
  BOTTOM w0.089: v2(162.47,30.57) 162.11,30.93 UH2.AG35

## Copper pours and planes (outline as drawn)
1.2V_VCCPLL_OC on TOP (solid shape): 72.43,47.84 72.43,46.73 72.3,46.6 70.44,46.6 70.33,46.71 70.33,47.83 70.42,47.92 72.35,47.92
1V8_GFX_RUN on BOTTOM (solid shape): 150.44,109.95 152.4,109.95 152.66,109.69 152.66,108.91 152.51,108.76 149.78,108.76 149.43,109.11 149.43,109.93 149.5,110.01 150.38,110.01
3VS on TOP (solid shape): 212.83,16.08 213.69,16.08 213.88,15.89 213.88,13.71 213.82,13.64 212.76,13.64 211.91,14.49 211.33,14.49 211.22,14.6 211.22,16.42 211.33,16.53 212.38,16.53
5VS on TOP (solid shape): 213.88,12.18 213.88,11.57 213.78,11.48 213.78,10.15 213.66,10.02 211.62,10.02 211.55,10.09 211.55,11.9 211.69,12.04 212.01,12.04 212.14,12.16 212.98,12.16 213.05,12.23 213.64,12.23 213.65,12.24 213.82,12.24
+0.6VS on TOP (solid shape): 137.76,23.36 137.76,22.27 137.93,22.1 138.15,22.1 138.25,22.01 138.25,19.5 137.51,18.77 136.05,18.77 135.98,18.84 135.98,23.31 136.23,23.57 137.55,23.57
+0.6VS on TOP (solid shape): 106.94,15.42 108.8,15.42 109.07,15.15 109.07,14.08 108.7,13.71 106.39,13.71 105.22,14.87 105.22,16 105.33,16.12 106.25,16.12
+0.6VS on TOP (solid shape): 137.51,31.71 137.67,31.71 137.94,31.53 138.24,31.65 138.32,31.69 138.39,31.66 138.44,31.61 138.44,29.75 138.31,29.63 138.31,29.26 138.12,29.06 138.12,28.07 138.05,28.01 137.29,28.01 137.28,28.02 137,28.02 136.91,28.11 136.91,28.97 136.72,29.16 136.72,29.21 136.29,29.64 136.29,29.82 136.4,30.14 136.29,30.46 136.29,30.53 136.4,30.85 136.29,31.17 136.29,31.7 136.3,31.71 137.51,31.71
+0.6VS on BOTTOM (solid shape): 137.7,22.58 137.7,22.03 137.08,21.41 137.08,19.14 137.02,19.08 136.81,19.08 136.74,19.14 136.74,20.89 136.46,21.17 136.46,22.2 137.02,22.76 137.53,22.76
+0.6VS on BOTTOM (solid shape): 137.06,33.57 137.06,31.8 137.2,31.66 137.43,31.66 137.6,31.49 137.6,30.55 137.39,30.33 136.99,30.33 136.75,30.58 136.75,33.54 136.84,33.64 136.99,33.64
+0.6VS on BOTTOM (solid shape): 106.11,16.42 106.11,16.19 106.12,16.18 106.12,16.09 106.2,16.09 106.23,16.08 106.27,16.04 106.31,15.99 106.33,15.96 106.33,15.71 106.23,15.61 106.05,15.61 105.98,15.53 105.95,15.53 105.61,15.19 104.91,15.19 104.91,15.66 104.9,15.68 104.9,15.75 104.85,15.75 104.85,15.98 104.9,15.98 104.9,16.41 105.06,16.58 105.95,16.58
+0.6VSP on BOTTOM (solid shape): 104.76,16.12 104.3,16.12 104.23,16.04 104.23,15.69 104.28,15.64 104.76,15.64 104.78,15.61 104.78,15.2 104.49,15.2 104.49,15.19 104.4,15.1 104.38,15.1 103.58,14.3 102.51,14.3 101.72,13.52 101.72,13.11 101.73,13.08 101.73,12.63 101.66,12.56 101.08,12.56 101,12.64 101,15.94 101.1,16.04 103.57,16.04 103.89,16.37 104.75,16.37 104.76,16.37
+0.95VSP on TOP (solid shape): 77.01,72.59 77.01,70.94 77.01,70.91 77,69.98 77.23,69.08 77.35,68.83 77.48,68.58 77.48,65.22 77.44,65.18 77.44,61.93 76.66,61.15 73.5,61.15 73.5,60.61 73.01,60.61 73.01,61.15 72.3,61.15 72.3,60.61 71.81,60.61 71.81,61.15 71,61.15 71,61.59 72.65,63.24 72.65,65.82 72.78,66.16 72.65,66.49 72.65,67.09 72.78,67.42 72.67,67.75 72.65,67.76 72.65,67.88 72.16,68.38 72.16,72.52 72.78,73.14 76.46,73.14
+0.95VSP on BOTTOM (solid shape): 76.97,72.89 76.97,72.33 76.48,70.4 76.97,68.47 76.97,65.96 76.53,65.52 73.02,65.52 72.66,65.89 72.66,67.62 72.53,67.74 72.53,72.89 72.86,73.22 76.64,73.22
+1.0VSP on TOP (solid shape): 214,44.41 214,40.76 213.88,40.63 212.1,40.63 211.46,41.27 211.46,44.41 211.71,44.67 213.74,44.67
+1.0VSP on BOTTOM (solid shape): 215.78,47.32 215.78,43.68 215.66,43.55 214.77,43.55 214.13,42.92 214.13,40.76 211.66,40.76 211.43,40.98 211.43,42.35 210.89,42.35 210.89,42.79 211.43,42.79 211.43,43.55 210.89,43.55 210.89,43.99 211.43,43.99 211.43,45.3 213.62,47.49 215.61,47.49
+1.2V_DDR on TOP (solid shape): 103.04,53.83 95.04,53.83 95.04,61.83 103.04,61.83
+1.2V_DDR on TOP (solid shape): 132.38,45.21 117.38,45.21 117.38,55.21 132.38,55.21
+1.2V_DDR on TOP (solid shape): outline of 25927 points within 72.65,15.97 144.07,82.41
+1.2V_DDR on BOTTOM (solid shape): 110.23,77.07 110.23,76.28 110.09,76.14 109.08,76.14 109.01,76.22 109.01,76.4 109.5,76.89 109.62,76.89 109.88,77.15 110.14,77.15 110.15,77.15
+1.2V_DDR on BOTTOM (solid shape): 99.71,77.54 99.72,77.54 99.77,77.47 99.84,77.42 99.85,77.41 100.14,77.12 100.14,77.11 100.14,76.88 99.62,76.35 99.45,76.35 98.94,76.87 98.94,77.19 99.34,77.59 99.67,77.59
+1.2V_DDR on BOTTOM (solid shape): 115.26,77.07 115.26,76.86 114.94,76.55 114.9,76.52 114.87,76.47 114.73,76.34 114.52,76.34 114.43,76.43 114.42,76.44 114.37,76.52 114.3,76.57 114.29,76.57 114.05,76.81 114.05,77.01 114.24,77.2 115.13,77.2
+1.2V_DDR on BOTTOM (solid shape): 144.72,32.57 145.24,32.57 145.25,32.56 147.12,32.56 147.54,32.14 147.54,31.34 147.11,30.91 144.16,30.91 143.99,30.97 143.82,30.94 143.7,30.95 143.59,30.93 143.58,30.93 143.42,31.09 143.42,32.92 143.62,33.12 144.17,33.12
+1.2V_DDR on BOTTOM (solid shape): 102.4,81.49 102.41,81.47 102.48,81.34 102.62,81.26 102.63,81.26 102.83,81.06 102.84,81.05 102.84,80.82 102.31,80.3 102.14,80.3 101.63,80.81 101.63,81.13 101.75,81.25 101.77,81.25 101.96,81.32 102.06,81.49 102.07,81.53 102.36,81.53
+1.2V_DDR on BOTTOM (solid shape): 103.8,77.76 103.8,77.21 103.22,76.62 102.44,76.62 102.35,76.53 102.2,76.38 101.96,76.38 101.79,76.56 101.79,76.71 101.98,76.9 102.15,76.9 102.18,76.93 102.2,76.94 102.33,77.01 102.42,77.14 102.43,77.18 102.88,77.18 103.53,77.83 103.73,77.83
+1.2V_DDR on BOTTOM (solid shape): 122.24,81.17 122.27,81.17 122.69,81.17 122.74,81.16 122.76,81.18 123.07,81.18 123.43,80.83 123.43,80.54 123.31,80.42 122.99,80.42 122.68,80.73 122.61,80.73 122.32,80.9 122.03,80.73 121.8,80.73 121.7,80.82 121.7,81.01 121.87,81.18 122.2,81.18
+1.2V_DDR on BOTTOM (solid shape): 113,18.8 113,18.54 113.01,18.53 113.01,18.43 113.17,18.28 114.12,18.28 114.49,17.92 115.17,17.92 115.39,17.7 115.39,15.55 114.72,14.87 113.55,14.87 113.51,14.88 113.51,15.4 112.81,15.4 112.81,14.88 112.74,14.88 112.74,14.87 112.38,14.87 112.36,14.89 112.31,14.89 112.31,15.4 111.61,15.4 111.61,14.91 111.57,14.87 110.78,14.87 109.86,15.79 109.86,18.58 110.14,18.86 112.2,18.86 112.25,18.91 112.89,18.91
+1.2V_DDR on BOTTOM (solid shape): 122.83,77.18 123.7,77.18 124.1,76.79 124.1,76.55 123.91,76.36 123.74,76.36 123.56,76.18 123.3,76.18 122.68,76.81 122.47,76.81 122.45,76.83 122.17,77 121.89,76.85 121.86,76.81 121.69,76.81 121.6,76.9 121.6,77.08 121.85,77.33 122.68,77.33
+1.2V_DDR on BOTTOM (solid shape): 107.92,80.8 107.95,80.76 107.95,80.5 107.82,80.37 107.61,80.37 107.49,80.49 107.37,80.49 107.36,80.5 107.26,80.51 107.17,80.5 107.16,80.49 107.11,80.49 106.95,80.33 106.82,80.33 106.69,80.33 106.58,80.23 106.55,80.19 106.43,80.07 106.22,80.07 106.14,80.15 106.14,80.37 106.41,80.64 106.43,80.64 106.54,80.71 106.6,80.82 106.61,80.83 106.92,81.14 107.59,81.14
+1.2V_DDR on BOTTOM (solid shape): 117.98,78.92 117.98,78.91 118,78.84 118.04,78.78 118.04,78.47 117.98,78.3 118.04,78.13 118.04,77.82 117.99,77.57 118.17,77.4 118.19,77.39 118.35,77.23 118.45,77.23 118.59,77.08 118.59,76.89 118.47,76.76 117.63,76.76 117.26,76.39 116.98,76.39 116.95,76.42 116.94,76.43 116.9,76.5 116.85,76.55 116.85,76.75 116.88,76.76 116.96,76.83 117.01,76.94 117.01,76.95 117.54,77.49 117.54,77.52 117.55,77.53 117.57,77.65 117.55,77.76 117.54,77.77 117.54,78.17 117.55,78.18 117.57,78.3 117.55,78.41 117.54,78.42 117.54,78.57 117.52,78.59 117.52,78.79 117.55,78.83 117.69,78.98 117.93,78.98
+1.2V_DDR on IN2 (solid shape): outline of 1723 points within 73.09,16.5 127.8,20.31
+1.2V_DDR on IN2 (solid shape): outline of 31069 points within 69.2,20.79 142.81,81.85
+1.2V_DDRP on BOTTOM (solid shape): 110.5,14.7 111.72,14.7 111.74,14.72 111.74,15.18 111.82,15.26 112.1,15.26 112.15,15.2 112.15,14.72 112.18,14.7 112.91,14.7 112.94,14.73 112.94,15.21 113,15.27 113.33,15.27 113.34,15.26 113.34,14.78 113.4,14.72 114.22,14.72 114.36,14.58 114.36,10.28 113.69,9.6 111.3,9.6 110.93,9.24 107.66,9.24 107.66,12.13 106.82,12.97 103.18,12.97 102.78,12.56 101.94,12.56 101.85,12.65 101.85,13.08 101.85,13.12 101.85,13.46 102.56,14.18 103.63,14.18 104.43,14.98 105.6,14.98 106.11,15.48 109.71,15.48
+1.2V_RTM on BOTTOM (solid shape): outline of 124 points within 262.85,30.27 273.23,40.88
+1.2V_VCCPLL_OC on BOTTOM (solid shape): 264.07,41.01 264.07,40.14 263.95,40.01 261.99,40.01 261.76,40.25 261.76,40.88 262.14,41.27 263.81,41.27
+1.2V_VCCPLL_OC on IN2 (solid shape): 263.03,40.88 263.03,40.12 262.77,39.87 260.99,39.87 260.74,40.12 260.74,40.88 260.99,41.14 262.77,41.14
+1.2V_VCCPLL_OC on IN2 (solid shape): outline of 625 points within 123.73,77.36 129.65,82.11
+1.2V_VCCPLL_OC on IN2 (solid shape): outline of 1213 points within 147.32,18.38 189.11,24.16
+1.2V_VCCPLL_OC on IN4 (solid shape): outline of 4309 points within 92.21,76.19 130.41,82.79
+1.8V_AVDD on TOP (solid shape): 283.4,30.01 283.4,29.2 282.66,29.2 282.46,29 282.46,28.74 282.27,28.74 282.27,29.1 282.41,29.23 282.41,29.94 282.56,30.09 283.32,30.09
+1.8V_DVDD on TOP (solid shape): 285.92,28.82 285.92,28.21 285.81,28.11 285.29,28.11 285.05,27.87 284.86,27.87 284.59,27.6 284.59,27.24 284.79,27.04 284.79,26.91 284.72,26.84 283.98,26.84 283.78,27.04 283.78,27.93 284.19,28.35 284.36,28.44 284.45,28.61 284.53,28.68 284.99,28.68 285.23,28.92 285.81,28.92
+1.8V_GFX_AON on TOP (solid shape): 160.91,73.42 160.91,71.83 160.72,71.64 159.75,71.64 159.55,71.85 159.55,73.65 159.68,73.78 160.55,73.78
+1.8V_GFX_AON on TOP (solid shape): 174.97,72.94 176.03,72.94 176.11,72.86 176.11,72.28 175.3,71.47 173.86,71.47 173.78,71.54 173.12,71.54 172.88,71.78 172.88,72.46 173.42,72.99 174.91,72.99
+1.8V_GFX_AON on TOP (solid shape): 191.25,133.64 191.25,133.12 190.98,132.86 190.87,132.86 190.48,132.48 189.16,132.48 189.13,132.51 189.13,132.62 188.88,132.86 188.88,133.34 189.04,133.49 189.14,133.49 189.37,133.72 190.54,133.72 190.61,133.8 191.09,133.8
+1.8V_GFX_AON on TOP (solid shape): 148.37,109.49 148.37,108.92 148.27,108.82 148.02,108.82 148,108.83 147.8,108.83 147.7,108.73 147.63,108.68 147.56,108.68 147.56,108.61 147.4,108.45 146.25,108.45 146.11,108.31 145.73,108.31 145.53,108.51 145.53,109.08 145.6,109.16 146.19,109.16 146.3,109.27 146.3,109.82 146.48,110 147.86,110
+1.8V_GFX_AON on TOP (solid shape): 153.71,132.55 152.74,131.59 150.73,131.59 150.4,131.92 150.4,132.45 152.31,132.45 152.31,132.4 152.32,132.35 152.34,132.3 152.37,132.25 152.4,132.21 152.44,132.17 152.49,132.14 152.53,132.12 152.58,132.1 152.64,132.1 152.69,132.1 152.74,132.1 152.79,132.12 152.84,132.14 152.89,132.17 152.93,132.21 152.96,132.25 152.99,132.3 153,132.35 153.02,132.4 153.02,132.45 153.02,132.5 153,132.56 152.99,132.61 152.96,132.65 152.93,132.69 152.89,132.73 152.84,132.76 152.79,132.78 152.74,132.8 152.69,132.81 152.64,132.81 152.58,132.8 152.53,132.78 152.49,132.76 152.44,132.73 152.4,132.69 152.37,132.65 152.34,132.61 152.32,132.56 152.31,132.5 152.31,132.45 150.4,132.45 150.4,133.24 150.78,133.62 152.18,133.62 152.21,133.64 153.71,133.64
+1.8V_GFX_AON on TOP (solid shape): 175.5,83.12 175.5,81.83 175.3,81.63 175.3,81.22 175.52,80.99 175.52,80.15 175.44,80.07 174.39,80.07 174.05,80.4 174.05,80.53 174.69,80.53 174.69,80.48 174.69,80.43 174.71,80.38 174.73,80.33 174.76,80.29 174.8,80.26 174.84,80.23 174.89,80.2 174.94,80.19 174.99,80.18 175.04,80.18 175.09,80.19 175.14,80.2 175.19,80.23 175.23,80.26 175.27,80.29 175.3,80.33 175.32,80.38 175.34,80.43 175.35,80.48 175.35,80.53 175.34,80.59 175.32,80.63 175.3,80.68 175.27,80.72 175.23,80.76 175.19,80.79 175.14,80.81 175.09,80.83 175.04,80.84 174.99,80.84 174.94,80.83 174.89,80.81 174.84,80.79 174.8,80.76 174.76,80.72 174.73,80.68 174.71,80.63 174.69,80.59 174.69,80.53 174.05,80.53 174.05,81.3 174.74,81.98 174.74,82.46 174.84,82.57 174.84,83.02 175.02,83.2 175.42,83.2
+1.8V_GFX_AON on TOP (solid shape): 172.1,82.39 172.1,80.8 172.02,80.72 172.02,80.28 171.97,80.23 171.74,80.23 171.61,80.1 171.61,79.47 171.82,79.26 172.15,79.26 172.28,79.13 172.28,79.05 172.25,78.91 172.28,78.76 172.28,78.53 172.09,78.35 171.11,78.35 171.08,78.37 171,78.45 170.97,78.54 171.03,78.61 171.19,79 170.84,79.24 170.52,79.24 170.3,79.45 170.3,79.49 170.35,79.55 170.38,79.59 170.47,79.64 170.56,79.59 171.18,79.75 170.56,79.9 170.47,79.85 170.38,79.9 170.34,79.96 170.29,80.01 170.29,80.3 170.38,80.39 170.63,80.39 171.03,80.32 171.2,80.69 171.19,80.72 171.33,80.86 171.33,80.87 171.48,81.02 171.48,81.57 171.48,81.57 171.48,82.36 171.67,82.55 171.94,82.55
+1.8V_GFX_AON on BOTTOM (solid shape): 148.03,109.93 148.03,108.75 147.6,108.32 145.21,108.32 145.06,108.47 145.06,109.54 145.49,109.98 146.84,109.98 146.88,110.01 147.94,110.01
+1.8V_GFX_AON on BOTTOM (solid shape): 194.17,122.49 194.17,122.09 193.63,122.09 193.61,122.06 193.61,121.55 193.65,121.55 193.65,121.55 194.15,121.55 194.19,121.5 194.19,121.3 193.63,121.3 193.61,121.28 193.61,120.77 193.63,120.74 194.17,120.74 194.17,120.21 193.79,119.83 192.47,119.83 192.39,119.9 192.39,122.49 192.47,122.57 194.09,122.57
+1.8V_GFX_AON on BOTTOM (solid shape): 166.79,73.22 170.06,73.22 170.22,73.07 171.82,73.07 172.04,72.84 172.04,72.58 172.34,72.28 172.76,72.28 172.99,72.51 174.03,72.51 174.15,72.39 174.15,71.51 173.85,71.22 167.95,71.22 167.29,71.88 160.83,71.88 160.57,71.62 159.65,71.62 159.47,71.8 159.47,72.49 159.59,72.61 161.29,72.61 161.29,72.61 163.21,72.61 163.79,73.18 165.61,73.18 165.97,73.54 166.32,73.54 166.34,73.56 166.44,73.56
+1.8V_GFX_AON on IN1 (solid shape): 147.92,109.6 147.92,108.77 147.58,108.42 146.43,108.42 145.89,108.96 145.89,110.23 146.3,110.63 146.9,110.63
+1.8V_GFX_AON on IN1 (solid shape): 152.18,132.3 152.18,131.26 151.95,131.03 151.17,131.03 150.58,131.61 150.45,131.74 150.45,132.63 150.46,132.64 150.46,132.77 150.52,132.83 151.65,132.83
+1.8V_GFX_AON on IN1 (solid shape): 163.59,74.65 163.91,74.65 164.12,74.44 165.22,74.44 166.35,73.31 166.35,73.09 166.18,72.91 165.8,72.91 165.44,73.27 162.98,73.27 162.89,73.31 162.89,73.41 162.56,73.9 162.23,73.41 162.22,73.31 162.14,73.27 159.62,73.27 159.57,73.32 159.57,73.74 159.73,73.9 160.51,73.9 160.89,74.29 160.92,74.29 161.29,74.66 163.59,74.66
+1.8V_GFX_AON on IN2 (solid shape): 152.19,133.21 152.19,132.42 151.16,131.39 150.56,131.39 150.1,131.85 150.1,132.86 150.78,133.54 151.86,133.54
+1.8V_GFX_AON on IN2 (solid shape): 191.22,133.68 191.22,130.37 190.95,130.1 190.95,127.39 194.2,124.15 194.2,120.32 193.58,119.7 192.55,119.7 191.9,120.35 191.9,123.05 192.06,123.05 192.06,123 192.07,122.95 192.09,122.9 192.12,122.85 192.15,122.81 192.19,122.77 192.24,122.74 192.28,122.72 192.34,122.71 192.39,122.7 192.44,122.7 192.49,122.71 192.55,122.72 192.59,122.74 192.64,122.77 192.68,122.81 192.71,122.85 192.74,122.9 192.76,122.95 192.77,123 192.77,123.05 192.77,123.11 192.76,123.16 192.74,123.21 192.71,123.25 192.68,123.3 192.64,123.33 192.59,123.36 192.55,123.39 192.49,123.4 192.44,123.41 192.39,123.41 192.34,123.4 192.28,123.39 192.24,123.36 192.19,123.33 192.15,123.3 192.12,123.25 192.09,123.21 192.07,123.16 192.06,123.11 192.06,123.05 191.9,123.05 191.9,124.06 189.32,126.65 189.32,132.73 188.88,133.16 188.88,133.59 189.04,133.75 190.64,133.75 190.69,133.8 191.11,133.8
+1.8V_GFX_AON on IN2 (solid shape): outline of 454 points within 148.33,71.67 161.1,75.53
+1.8V_GFX_AON on IN4 (solid shape): outline of 326 points within 143.49,98.34 147.7,109.85
+1.8V_GFX_AON on IN1: 148.1,85.8 148.1,84.73 150.99,81.85 150.99,79.84 150.67,79.52 150.67,75.9 149.72,74.95 149.72,74.91 149.51,74.71 149.51,72.48 149.26,72.23 148.57,72.23 148.29,72.5 148.29,74.91 148.07,75.14 148.07,75.15 147.56,75.66 147.56,76.54 147.66,76.95 147.3,77.17 147.3,77.32 147.28,77.34 147.28,78.13 147.28,80.49 147.28,80.79 147.63,81.14 147.63,82.98 146.94,83.68 145.83,83.68 144.64,84.87 144.64,97.31 144.64,99 144.87,99.23 146.11,99.23 146.47,98.87 146.47,98.67 146.47,87.43
+1.8V_GFX_AON on VCC: 151.25,133.72 191.09,133.72 191.25,133.57 191.25,133.05 190.68,132.48 189.7,132.48 189.16,133.01 152.6,133.01 152.06,132.47 152.06,131.97 152.05,131.97 152.05,131.78 153.11,130.72 153.11,123.69 150.53,121.11 148.35,121.11 146.87,119.64 146.87,117.63 147.1,117.4 147.1,113.6 146.23,112.73 146.23,110.89 147.63,109.48 147.63,108.46 147.55,108.37 146.23,108.37 145.3,109.3 145.3,113.16 146.14,114 146.14,117.05 145.92,117.26 145.92,120.08 147.89,122.05 150.2,122.05 152.11,123.95 152.11,130.27 150.3,132.07 150.3,132.77
+1.8V_GFX_RUN on TOP (solid shape): 160.5,75.86 160.5,74.73 160.29,74.52 159.53,74.52 159.25,74.8 159.25,75.17 159.61,75.53 159.62,75.53 159.64,75.54 159.64,75.86 159.74,75.96 160.4,75.96
+1.8V_GFX_RUN on TOP (solid shape): 160.24,97.25 160.24,96.34 160.16,96.26 159.8,96.26 159.66,96.39 159.66,96.77 159.57,96.85 159.01,96.85 158.98,96.89 158.98,97.34 159.06,97.42 160.06,97.42
+1.8V_GFX_RUN on TOP (solid shape): 160.26,90.78 160.26,90.59 160.98,89.87 160.98,89.78 161.02,89.75 161.02,89.65 161.11,89.65 161.12,89.65 161.95,89.65 162.14,89.46 162.14,85.58 162.06,85.5 162.02,85.5 162.02,85.5 161.52,85.5 161.45,85.56 161.45,85.96 161.27,86.14 160.73,86.14 160.53,86.35 160.53,88.33 160.74,88.54 160.89,88.54 161.14,88.79 161.14,89.14 160.88,89.41 160.78,89.41 160.77,89.42 160.64,89.42 159.72,90.34 159.72,90.81 159.82,90.91 160.13,90.91
+1.8V_GFX_RUN on TOP (solid shape): 148.03,104.89 148.18,104.89 149.27,103.8 149.33,103.75 149.33,101.47 149.85,100.94 149.85,99.49 149.72,99.36 149.32,99.36 148.82,99.86 147.93,99.86 147.47,100.32 147.99,100.32 147.99,100.27 148,100.21 148.02,100.17 148.05,100.12 148.08,100.08 148.12,100.04 148.17,100.01 148.22,99.99 148.27,99.97 148.32,99.96 148.37,99.96 148.43,99.97 148.48,99.99 148.52,100.01 148.57,100.04 148.61,100.08 148.64,100.12 148.67,100.17 148.69,100.21 148.7,100.27 148.7,100.32 148.7,100.37 148.69,100.43 148.67,100.47 148.64,100.52 148.61,100.56 148.57,100.6 148.52,100.63 148.48,100.65 148.43,100.67 148.37,100.68 148.32,100.68 148.27,100.67 148.22,100.65 148.17,100.63 148.12,100.6 148.08,100.56 148.05,100.52 148.02,100.47 148,100.43 147.99,100.37 147.99,100.32 147.47,100.32 147.23,100.56 147.23,104.53 147.59,104.89 148.03,104.89
+1.8V_GFX_RUN on BOTTOM (solid shape): 156.19,99.06 156.2,99.06 156.35,98.91 156.35,98.8 156.93,98.21 157.04,98.21 157.04,98.21 159.53,98.21 159.99,97.76 159.99,96.84 160.34,96.49 160.34,96.35 160.58,96.12 160.58,95.99 160.46,95.88 160.28,95.88 159.79,96.37 159.48,96.37 159.34,96.23 159.04,96.23 158.94,96.33 158.94,96.56 159.17,96.79 159.17,96.99 158.65,97.51 157.03,97.51 156.83,97.71 156.83,97.78 156.42,98.19 155.94,98.19 155.79,98.34 155.53,98.34 155.33,98.54 155.33,98.7 155.84,99.21 156.04,99.21
+1.8V_GFX_RUN on BOTTOM (solid shape): 160.39,90.55 160.39,90.48 160.62,90.25 161.42,90.25 161.69,89.98 161.69,86.08 161.45,85.84 160.34,85.84 160.19,85.99 160.19,86.19 160.72,86.72 160.72,87.11 160.19,87.64 159.97,87.65 159.75,87.64 159.62,87.52 159.52,87.52 159.42,87.62 159.42,87.85 160.31,88.74 160.48,88.74 160.85,88.66 161.05,88.98 161,89.17 160.85,89.3 160.82,89.31 160.82,89.45 160.49,89.78 159.72,89.78 159.39,90.1 159.39,90.36 159.88,90.85 160.09,90.85
+1.8V_GFX_RUN on BOTTOM (solid shape): outline of 162 points within 145.16,102.35 152.4,108.61
+1.8V_GFX_RUN on IN2 (solid shape): outline of 925 points within 157.34,74.78 163.01,86.81
+1.8V_GFX_RUN on IN4 (solid shape): outline of 3711 points within 147.13,79.09 174.41,105.88
+1.8V_PLLVDD on TOP (solid shape): outline of 403 points within 158.26,75.47 165.53,81.83
+1.8VS on TOP (solid shape): 291.22,34.92 291.22,31.36 291.09,31.23 288.05,31.23 287.92,31.36 287.92,32.25 288.05,32.38 289.19,32.38 289.49,32.68 289.49,35.22 289.57,35.3 290.84,35.3
+1.8VSP on TOP (solid shape): 197.77,122.19 197.77,120.64 197.39,120.26 195.39,120.26 195,120.65 195,120.77 195.03,121.8 195.05,121.81 195.05,121.93 195.26,122.14 196.89,122.14 197.14,122.39 197.57,122.39
+1.8VSP on BOTTOM (solid shape): 199.88,122.53 199.88,120.56 199.88,120.56 199.88,120.33 199.6,120.06 196.56,120.06 196.38,120.23 194.32,120.23 194.32,120.87 193.81,120.87 193.79,120.89 193.79,121.12 194.32,121.12 194.32,121.56 194.32,121.68 193.79,121.68 193.76,121.71 193.76,121.94 194.32,121.94 194.32,122.52 194.77,122.52 194.82,122.52 194.87,122.52 197.09,122.52 197.39,122.82 199.59,122.82
+1.35VS_VGA on TOP (solid shape): 183.09,106.82 183.09,105.41 182.93,105.25 182.18,105.25 182.03,105.4 182.03,106.24 181.77,106.49 180.86,106.49 180.71,106.34 180.71,105.4 180.55,105.25 179.92,105.25 179.71,105.45 179.71,106.11 179.08,106.75 177.86,106.75 177.66,106.95 176.54,106.95 176.49,107 176.49,107.51 176.51,107.53 182.38,107.53
+1.35VS_VGA on TOP (solid shape): outline of 88 points within 162.41,82.78 177.28,97.91
+1.35VS_VGA on TOP (solid shape): outline of 346 points within 143.9,111.17 156.09,131.38
+1.35VS_VGA on BOTTOM (solid shape): 204.8,78.88 204.84,78.83 204.9,78.79 205.57,78.12 205.63,78.05 205.7,77.99 206.37,77.32 206.43,77.25 206.5,77.19 206.64,77.05 206.64,75.4 207.07,74.97 207.07,74.23 207.15,74.16 207.88,74.16 207.93,74.21 207.93,75.22 207.53,75.63 207.53,77.05 207.73,77.26 207.96,77.26 208.19,77.03 208.19,75.78 208.49,75.48 208.9,75.48 209.03,75.61 209.03,76.9 209.36,77.23 209.59,77.23 209.75,77.06 209.75,75.67 209.92,75.51 209.92,73.75 209.43,73.27 206.21,73.27 206.13,73.35 206.13,73.95 206.33,74.16 206.33,74.84 205.55,75.63 205.55,76.14 205.09,76.6 205.09,77.08 204.97,77.2 204.97,77.2 204.84,77.33 204.84,77.54 205.01,77.71 205.01,78.07 204.45,78.63 204.45,78.73 204.61,78.88
+1.35VS_VGA on BOTTOM (solid shape): 154.52,131.26 156.19,131.26 156.45,131 156.45,130.75 156.22,130.52 155,130.52 154.75,130.27 154.75,129.96 155.05,129.66 156.17,129.66 156.45,129.38 156.45,129.2 156.26,129.01 154.92,129.01 154.35,129.58 154.35,129.58 154.26,129.66 153.47,129.66 153.28,129.48 153.28,128.8 153.59,128.5 153.99,128.5 154.51,127.98 155.31,127.98 155.38,128.06 156.19,128.06 156.45,127.8 156.45,127.52 156.32,127.4 156.32,127.17 156.58,126.91 156.85,126.91 157.82,127.88 158.02,127.88 158.94,126.96 158.94,126.79 158.79,126.63 158.61,126.63 158.53,126.72 158.47,126.77 158.07,127.17 157.77,127.17 157.52,126.91 157.52,126.81 158.02,126.31 158.06,126.25 158.12,126.2 158.12,126 157.97,125.85 157.79,125.85 157.73,125.92 157.67,125.97 157.19,126.46 157.08,126.46 157.02,126.39 156.97,126.39 156.8,126.23 156.58,126.23 156.42,126.39 156.39,126.39 156.17,126.61 155.91,126.61 155.87,126.65 155.6,126.65 155.6,127.1 155.31,127.4 154.68,127.4 154.27,127.8 154.09,127.8 154.01,127.88 153.02,127.88 152.51,128.39 152.51,131.54 152.74,131.77 154.01,131.77
+1.35VS_VGA on BOTTOM (solid shape): 158.02,124.7 158.06,124.65 158.15,124.58 158.15,124.39 158.04,124.3 157.98,124.19 157.98,124.17 157.52,123.71 157.52,123.66 157.74,123.43 157.79,123.43 157.8,123.43 157.9,123.41 157.99,123.43 158,123.43 158.1,123.43 158.48,123.81 158.53,123.85 158.57,123.91 158.61,123.94 158.71,123.94 158.89,123.76 158.89,123.55 158.82,123.47 158.78,123.39 158.78,123.37 158.21,122.81 158.2,122.81 158.11,122.76 158.04,122.7 157.77,122.7 157.34,123.13 157.23,123.13 157.22,123.13 157.1,123.16 156.98,123.13 156.97,123.13 156.88,123.13 156.52,122.77 156.46,122.72 156.41,122.66 156.35,122.6 155.31,122.6 155.31,122.6 154.01,122.6 154.01,122.6 153.65,122.6 153.45,122.8 153.45,123.61 153.5,123.66 154.34,123.66 154.67,123.99 156.3,123.99 156.58,123.71 156.78,123.71 156.88,123.81 156.93,123.85 156.97,123.91 157.68,124.61 157.73,124.65 157.77,124.7
+1.35VS_VGA on BOTTOM (solid shape): outline of 85 points within 183.35,118.89 190.41,124.7
+1.35VS_VGA on BOTTOM (solid shape): outline of 118 points within 160.19,81.62 177.06,98.07
+1.35VS_VGA on BOTTOM (solid shape): outline of 3195 points within 143.82,77.82 211.9,133.72
+1.35VS_VGA on IN2 (solid shape): outline of 37113 points within 143.84,74.95 212.24,132.7
+1.35VS_VGA on IN3 (solid shape): outline of 23201 points within 143.88,73.03 212.58,133.01
+1.35VS_VGA on IN4 (solid shape): outline of 4944 points within 162.19,81.61 182.84,103.61
+1.35VS_VGAP on TOP (solid shape): 150.38,125.19 150.38,120.06 150.48,120.06 150.48,120.04 150.97,120.04 150.98,120.03 150.98,119.59 150.48,119.59 150.48,119.57 150.46,119.57 150.46,118.87 151,118.87 151,118.37 150.46,118.37 150.46,117.75 150.38,117.67 147.94,117.67 147.91,117.7 144.23,117.7 144.05,117.87 144.05,121.91 144.59,122.44 144.59,125.01 145.07,125.49 150.07,125.49
+1.35VS_VGAP on BOTTOM (solid shape): 153.25,124.78 153.25,118.43 152.51,117.69 144.62,117.69 144.62,117.72 144.31,117.72 144.13,117.9 144.13,122.02 144.85,122.74 144.85,125.12 145.22,125.49 152.54,125.49
+1.35VS_VGAP_B+ on TOP (solid shape): 142.17,122.55 142.17,117.87 141.56,117.26 139.66,117.26 139.66,117.74 139.1,117.74 139.1,117.97 139.13,118 139.61,118 139.64,118.03 139.66,118.05 139.66,118.53 139.13,118.53 139.1,118.56 139.1,118.79 139.13,118.81 139.63,118.81 139.66,118.84 139.66,122.7 139.76,122.8 141.92,122.8
+1.35VS_VGAP_B+ on BOTTOM (solid shape): 143.46,125.45 143.46,124.68 143.32,124.54 142.85,124.54 142.55,124.24 142.55,122.44 143.6,121.4 143.6,119.17 143.12,118.69 142.59,118.69 142.41,118.51 142.41,118.25 142.41,118.25 142.41,117.98 142.02,117.59 140.04,117.59 139.91,117.72 139.91,120.21 139.56,120.56 139.56,122.98 139.56,123.13 139.05,123.64 139.05,125.22 139.31,125.48 143.43,125.48
+1V_MPHY on TOP (solid shape): 148.27,32.56 148.27,29.28 147.85,28.86 147.85,28.38 147.85,27.82 147.85,27.61 147.71,27.47 146.57,27.47 146.42,27.62 146.42,28.45 145.5,29.38 145.5,33.97 145.63,34.1 146.73,34.1
+1V_MPHY on TOP (solid shape): 168.16,37.07 168.16,36.16 168.63,35.69 168.63,35.38 168.41,35.17 166.89,35.17 166.81,35.1 166.8,35.09 166.62,35 166.52,34.81 166.51,34.8 166.13,34.41 165.11,34.41 164.98,34.53 164.98,34.92 165.11,35.04 165.31,35.04 165.68,35.42 165.68,37.12 165.99,37.43 167.81,37.43
+1V_MPHY on BOTTOM (solid shape): 168.84,36.06 168.95,35.95 168.95,35.77 168.9,35.71 168.86,35.64 168.5,35.28 168.24,35.28 168.19,35.34 168.14,35.34 168.13,35.35 168,35.38 167.87,35.35 167.86,35.34 167.82,35.34 167.75,35.27 167.51,35.27 167.43,35.35 167.34,35.35 167.33,35.36 167.22,35.38 167.12,35.36 167.11,35.35 167.02,35.35 166.69,35.02 166.63,34.98 166.59,34.92 166.16,34.5 165.9,34.5 165.8,34.59 165.77,34.59 165.76,34.59 165.68,34.61 165.59,34.59 165.56,34.59 165.5,34.54 165.47,34.51 165.16,34.51 165.03,34.64 165.03,34.9 165.08,34.94 165.12,35 165.31,35.19 165.32,35.19 165.51,35.28 165.6,35.46 165.6,35.48 165.8,35.68 165.86,35.72 165.9,35.77 166.2,36.07 168.84,36.07
+1V_MPHY on IN1 (solid shape): outline of 961 points within 150.5,33.01 168.63,38.73
+1V_MPHY on IN3 (solid shape): outline of 2390 points within 145.31,32.25 169.17,42.03
+1V_MPHY_MPHYPLL on TOP (solid shape): 155.84,46.35 155.84,45.66 155.89,45.66 155.9,45.65 155.9,44.17 156.44,43.63 156.42,43.6 156.73,43.07 157.04,43.6 157.02,43.63 157.24,43.85 157.24,44.27 157.08,44.42 157.08,44.54 157.11,44.57 157.11,46.35 159.14,46.35 159.14,45.47 159.13,45.46 159.13,44.3 158.51,43.68 158.49,43.68 157.21,42.41 156.8,42.41 156.79,42.41 156.65,42.44 156.51,42.41 156.5,42.41 155.46,42.41 155.25,42.61 155.25,43 155.2,43.05 155.2,43.3 154.82,43.68 154.82,44.29 155.12,44.58 155.12,46.26 155.29,46.44 155.75,46.44
+1V_MPHY_MPHYPLL on BOTTOM (solid shape): 158.41,44.17 158.41,43.87 158.27,43.73 158.27,43.51 158.45,43.33 158.45,42.59 158.31,42.44 157.53,42.44 157.37,42.6 155.69,42.6 155.46,42.82 155.46,44.23 156.37,44.23 156.37,43.32 156.48,43.21 156.51,43.17 156.53,43.16 156.69,43 157.3,43 157.45,42.85 157.68,42.85 157.8,42.85 157.94,42.99 157.94,43.26 157.93,43.26 157.83,43.37 157.83,43.76 157.61,43.98 157.17,44.42 156.56,44.42 156.37,44.23 155.46,44.23 155.46,44.69 155.97,45.19 157.39,45.19
+1V_PCH on TOP (solid shape): outline of 132 points within 168.56,34.33 172.5,38.59
+1V_PCH on IN1 (solid shape): outline of 1020 points within 167.82,28.18 173.62,37.49
+1V_PCH_AZPLL on TOP (solid shape): outline of 155 points within 169.98,27.56 174.25,28.82
+1V_PCH_CLK5 on BOTTOM (solid shape): 178.65,39.2 178.99,39.2 179.05,39.26 179.81,39.26 179.81,39.26 180.61,39.26 180.71,39.16 184.03,39.16 184.46,38.73 185.32,38.73 185.4,38.65 185.4,38.15 185.32,38.08 180.25,38.08 180.09,38.24 180.08,38.25 180,38.4 179.85,38.49 179.79,38.5 179.72,38.51 179.66,38.53 179.62,38.59 179.59,38.68 179.54,38.76 179.51,38.79 179.33,38.89 179.12,38.86 179.11,38.85 178,38.85 177.79,39.06 177.79,39.19 177.95,39.34 178.51,39.34
+1V_PCH_PRIM on TOP (solid shape): outline of 1583 points within 164.68,28.64 178.7,38.22
+1V_PCH_PRIM on BOTTOM (solid shape): 168.63,30.21 168.92,30.21 169.05,30.34 169.27,30.34 169.59,30.02 169.62,29.93 169.64,29.9 169.69,29.85 169.74,29.81 169.74,29.62 169.66,29.54 167.14,29.54 167.05,29.64 167.05,29.82 167.13,29.92 167.18,30.04 167.18,30.06 167.44,30.32 167.72,30.32 167.79,30.25 167.83,30.21 168.12,30.21 168.25,30.34 168.49,30.34
+1V_PCH_PRIM on BOTTOM (solid shape): 167.37,34.52 167.61,34.41 167.86,34.52 168.08,34.52 168.18,34.42 168.18,34.17 168.07,33.92 168.18,33.68 168.18,33.47 168.11,33.4 167.87,33.4 167.51,33.76 167.4,33.76 167.09,33.79 166.98,33.5 166.98,33.49 166.98,33.39 167.09,33.28 167.09,33.02 166.97,32.81 167.08,32.59 167.13,32.54 167.46,32.54 167.89,32.97 168.06,32.97 168.18,32.85 168.18,32.68 168.09,32.56 168.06,32.4 168.09,32.25 168.18,32.13 168.18,31.93 168.07,31.82 167.84,31.82 167.45,32.22 167.44,32.22 167.38,32.29 167.1,32.29 166.96,32.15 166.96,32.14 166.67,31.86 166.27,31.86 165.66,32.47 165.65,32.48 165.6,32.59 165.52,32.67 165.52,32.93 165.67,33.21 165.52,33.49 165.52,33.66 165.59,33.73 165.84,33.73 166.06,33.64 166.28,33.71 166.35,33.77 167.03,34.45 167.07,34.48 167.11,34.52
+1V_PCH_PRIM on IN2 (solid shape): outline of 1492 points within 165.78,29.76 178.85,37.81
+1V_PCH_USBPLL on BOTTOM (solid shape): 176.98,29.9 176.98,28.63 176.75,28.39 176.75,28.04 176.65,27.95 176.2,27.95 176.06,28.1 176.06,28.33 176.37,28.64 176.37,29.13 176.63,29.4 176.63,29.88 176.74,29.98 176.9,29.98
+1V_VCCDSW on TOP (solid shape): outline of 143 points within 165.52,24.98 168.01,28.39
+1VALW on TOP (solid shape): 134.69,100.81 134.69,98.17 133.71,97.2 132.61,97.2 132.34,96.94 129.93,96.94 129.89,96.98 129.89,98.54 129.93,98.57 131.07,98.57 131.27,98.76 131.27,100.89 131.44,101.07 134.43,101.07
+1VALW on TOP (solid shape): 160.92,46.35 160.92,44.95 160.8,44.83 160.78,44.83 160.51,44.72 160.41,44.44 160.41,44.08 160.06,43.73 159.5,43.73 159.39,43.83 159.39,44.39 159.4,44.39 159.4,44.82 159.9,45.33 159.9,46.31 160.03,46.44 160.83,46.44
+1VALW on TOP (solid shape): outline of 182 points within 146.31,27.49 151.08,36.16
+1VALW on TOP (solid shape): outline of 1426 points within 170.08,35.26 186.8,47.77
+1VALW on BOTTOM (solid shape): 134.92,102.34 134.92,98.61 134.5,98.19 132.2,98.19 131.99,98.4 131.99,100.52 132.47,101.01 132.99,101.01 133.23,101.24 133.23,102.33 133.3,102.4 134.86,102.4
+1VALW on BOTTOM (solid shape): 232.46,15.98 232.88,15.98 232.97,16.07 233.69,16.07 233.99,15.77 233.99,14.15 233.47,14.15 233.47,13.45 233.99,13.45 233.99,12.95 233.47,12.95 233.47,12.25 233.99,12.25 233.99,11.69 233.08,10.79 229.3,10.79 228.64,11.45 228.64,13.23 230.26,14.85 230.26,15.61 230.72,16.07 232.37,16.07
+1VALW on IN2 (solid shape): outline of 94 points within 131.58,82.72 135.26,99.94
+1VALW on IN2 (solid shape): outline of 342 points within 204.31,24.93 214.3,28.96
+1VALW on IN2 (solid shape): outline of 6719 points within 139.49,27.49 186.02,45.14
+1VALW on IN3 (solid shape): outline of 190 points within 204.87,26.55 213.34,28.77
+1VALW on VCC: outline of 111 points within 131.58,39.92 145.15,99.81
+1VALW on VCC: outline of 257 points within 171.46,13.86 241.18,46.09
+1VALWP on TOP (solid shape): 238.9,14.98 238.9,12.28 238.54,11.93 234.96,11.93 234.45,12.44 234.45,14.95 234.61,15.1 238.77,15.1
+1VALWP on BOTTOM (solid shape): 241.01,15.99 241.01,12.36 240.26,11.61 234.22,11.61 234.15,11.69 234.15,12.37 233.6,12.37 233.6,12.82 234.14,12.82 234.14,13.58 233.6,13.58 233.6,14.02 233.81,14.02 233.82,14.01 234.12,14.01 234.12,15.92 234.58,16.37 240.62,16.37
+1VS_GFX on TOP (solid shape): 161.36,97.68 161.36,97.25 161.67,96.94 161.67,96.23 162.14,95.76 162.14,90.38 162.01,90.25 162.01,89.86 161.91,89.75 161.16,89.75 161.09,89.83 161.09,91.24 161.15,91.3 161.15,91.74 161.12,91.81 161.15,91.88 161.12,92.33 160.66,92.33 160.63,92.32 160.59,92.33 160.11,92.81 159.84,92.81 159.72,92.93 159.72,93.34 159.77,93.39 159.78,93.39 159.9,93.51 160.96,93.51 161.17,93.72 161.17,94.35 160.49,95.03 160.18,95.03 159.72,95.49 159.72,95.9 159.81,95.99 160.14,95.99 160.47,96.32 160.47,97.63 160.66,97.83 161.22,97.83
+1VS_GFX on BOTTOM (solid shape): 149.81,85.14 149.81,84.16 149.72,84.06 146.07,84.06 145.96,84.17 145.96,85.11 146.18,85.33 149.62,85.33
+1VS_GFX on BOTTOM (solid shape): 211.28,45.25 211.28,44.15 210.73,44.15 210.73,43.39 211.28,43.39 211.28,42.95 210.73,42.95 210.73,42.19 211.28,42.19 211.28,41.7 209.18,41.7 208.92,41.95 208.92,45.06 209.28,45.41 211.12,45.41
+1VS_GFX on BOTTOM (solid shape): 161.69,95.92 161.69,90.68 161.41,90.4 160.63,90.4 160.49,90.54 160.49,90.69 160.2,90.98 160.2,91.16 160.31,91.27 160.46,91.27 160.91,91.21 161,91.65 160.99,91.73 161.04,91.79 161.13,92.32 160.6,92.24 160.59,92.23 160.2,92.23 160,92.42 159.58,92.42 159.4,92.6 159.4,92.85 160.31,93.77 160.51,93.77 160.66,93.62 160.94,93.62 161.14,93.82 161.14,94.16 160.62,94.68 160.61,94.68 159.51,95.78 159.51,95.8 159.46,95.89 159.39,95.96 159.39,96.05 159.56,96.22 159.69,96.22 160.21,95.7 160.51,95.7 160.77,95.95 160.77,96.18 160.51,96.43 160.51,96.56 160.69,96.74 160.87,96.74
+1VS_GFX on IN2 (solid shape): outline of 7304 points within 132.62,41.29 219.44,97.27
+2.5V_MEM on TOP (solid shape): 143.19,27.82 143.19,26.48 143.05,26.34 142.3,26.34 142.11,26.15 142.11,25.95 141.92,25.76 138.83,25.76 138.57,26.03 138.57,26.42 138.57,26.45 138.57,27.97 138.65,28.06 142.95,28.06
+2.5V_MEM on TOP (solid shape): 139.14,41.93 139.14,41.62 139.14,41.62 139.14,41.42 139.05,41.34 139.05,39.89 139.59,39.35 139.59,38.63 139.5,38.54 138.04,38.54 137.87,38.71 137.87,40.74 137.72,40.89 136.75,40.89 136.65,40.98 136.65,41.98 136.74,42.06 139.01,42.06
+2.5V_MEM on BOTTOM (solid shape): 139.14,41.94 139.14,40.26 138.95,40.06 136.61,40.06 136.49,40.18 136.49,41.81 136.7,42.02 136.71,42.02 136.76,42.08 139.01,42.08
+2.5V_MEM on BOTTOM (solid shape): 138.72,29.07 138.82,29.06 138.92,29.07 139.47,29.07 139.78,28.77 139.78,26.52 139.66,26.41 137.49,26.41 136.49,27.41 136.49,28.96 136.6,29.07
+3.3VDX_SSD on BOTTOM (solid shape): outline of 373 points within 214.23,15.48 220.48,39.79
+3V_DVDD on TOP (solid shape): 276.44,27.9 277.4,27.9 278.04,27.27 278.5,27.27 278.67,27.09 278.67,26.91 278.6,26.84 277.53,26.84 277.15,27.22 275.22,27.22 275.07,27.37 275.07,28.53 275.18,28.64 275.7,28.64
+3V_DVDD on TOP (solid shape): 277.88,23.87 278.65,23.87 278.71,23.81 278.71,23.69 278.65,23.62 276.8,23.62 276.59,23.41 276.59,22.97 276.83,22.72 277.27,22.72 278.04,21.96 278.04,21.23 277.76,20.95 276.62,20.95 276.2,20.53 276.2,18.13 276.09,18.02 274.93,18.02 274.79,18.16 274.79,18.87 274.96,19.04 274.96,23.1 275.09,23.23 275.65,23.23 276.54,24.12 277.63,24.12
+3V_DVDD on IN3 (solid shape): 277.15,29.17 277.15,28.34 276.74,27.93 276.74,25.89 276.71,25.88 276.53,25.66 276.56,25.38 276.57,25.31 276.52,25.24 276.35,24.84 276.69,24.58 276.73,24.56 276.74,24.53 276.74,23.55 276.6,23.27 276.74,22.99 276.74,22.85 277.63,21.96 277.89,21.96 278.01,21.83 278.01,21.07 277.89,20.95 275.73,20.95 274.74,21.94 274.74,26.66 275.19,27.12 275.19,28.77 276.11,29.68 276.64,29.68
+3V_PCH_SPI on BOTTOM (solid shape): 153.81,22.47 155.71,22.47 156.73,21.45 157.54,21.45 157.62,21.45 157.88,21.71 157.88,22.08 157.94,22.14 158.27,22.14 158.29,22.16 159.13,22.16 159.2,22.09 159.2,21.93 159.19,21.93 159.19,21.82 159.16,21.81 158.92,21.58 158.95,21.26 158.95,20.76 158.63,20.44 155.61,20.44 155.42,20.44 154.79,21.07 152.54,21.07 152.02,21.59 152.02,22.09 151.77,22.34 151.77,23.1 151.9,23.23 153.04,23.23
+3V_RTM on TOP (solid shape): 272.96,41.31 272.96,38.5 272.55,38.08 271.83,38.08 271.83,38.08 271,38.08 270.95,38.03 270.2,38.03 270.14,38.09 270.14,38.34 270.37,38.57 271.76,38.57 272.04,38.85 272.04,39.87 271.87,40.05 271.18,40.05 271.07,40.16 271.07,41.32 271.21,41.46 272.8,41.46
+3V_RTM on IN2 (solid shape): outline of 245 points within 266.2,39.74 271.92,45.58
+3VALW on TOP (solid shape): 178.98,21.88 178.98,21.31 178.95,21.28 178.3,21.28 178.26,21.33 177.3,21.33 177.17,21.45 177.17,21.83 177.3,21.96 178.9,21.96
+3VALW on TOP (solid shape): 226.2,11.67 226.2,11.04 225.94,10.79 223.07,10.79 222.95,10.91 222.95,11.67 223.07,11.8 226.07,11.8
+3VALW on TOP (solid shape): 234.85,36.81 234.85,35.77 234.72,35.64 232.39,35.64 231.95,36.08 231.95,37.32 232.14,37.51 234.15,37.51
+3VALW on TOP (solid shape): 68.6,66.25 69.59,66.25 69.91,65.93 69.91,64.75 70.28,64.38 70.66,64.38 70.77,64.26 70.77,63.79 70.68,63.7 69.34,63.7 69.27,63.76 69.27,64.7 68.82,65.15 68.71,65.15 68.33,65.54 68.33,66.1 68.26,66.17 68.26,66.31 68.34,66.39 68.46,66.39
+3VALW on TOP (solid shape): 216.04,27.25 216.04,26.71 216.26,26.49 216.79,26.49 216.92,26.36 216.92,26.08 216.76,25.92 216.29,25.92 215.95,25.58 215.95,23.97 215.78,23.8 215.11,23.8 214.93,23.98 214.93,25.63 215.17,25.87 215.17,27.13 215.37,27.33 215.96,27.33
+3VALW on TOP (solid shape): 67.45,38.73 67.85,38.73 68.16,38.42 68.16,36.81 68,36.65 66.24,36.65 66.09,36.81 66.09,37.35 65.93,37.51 65.57,37.66 65.24,37.44 65.24,37.43 64.5,36.69 63.54,36.69 63.41,36.82 63.41,37.71 64.62,38.92 67.25,38.92
+3VALW on TOP (solid shape): 219.1,15.99 219.1,15 219.48,14.63 219.48,13.69 219.55,13.62 220.22,13.62 220.39,13.46 220.39,12.73 220.27,12.62 217.47,12.62 217.27,12.82 217.27,12.98 217.17,13.08 217.17,13.09 217.11,13.17 217.03,13.22 217.02,13.23 216.67,13.58 216.04,13.58 215.97,13.65 215.2,13.65 215.15,13.71 215.15,15.74 215.28,15.87 216.07,15.87 216.32,16.12 218.97,16.12
+3VALW on BOTTOM (solid shape): 234.16,46.97 234.16,46.45 233.97,46.27 232.96,46.27 232.88,46.35 232.88,46.97 233.01,47.11 234.02,47.11
+3VALW on BOTTOM (solid shape): 68.06,38.52 68.06,37.73 67.68,37.35 65.11,37.35 64.55,36.79 64.02,36.79 63.81,37 63.81,38.22 64.32,38.73 67.85,38.73
+3VALW on BOTTOM (solid shape): 249.69,14.44 249.69,13.45 249.21,12.97 249.21,12.03 249.16,11.98 248.69,11.98 248.69,12.42 248.51,12.6 248.51,13.03 248.55,13.07 248.55,13.07 249.41,13.93 249.41,14.44 249.49,14.52 249.62,14.52
+3VALW on BOTTOM (solid shape): 153.57,36.3 153.57,34.67 154.26,33.98 154.26,32.48 154.16,32.38 153.15,32.38 152.93,32.6 152.93,32.88 153.01,32.96 153.01,33.53 151.83,34.71 151.83,35.07 152.19,35.42 152.19,35.86 152.7,36.37 153.5,36.37
+3VALW on BOTTOM (solid shape): 222.39,42.47 222.39,41.52 221.78,40.91 220.68,40.91 220.58,41.01 220.13,41.01 220.02,41.11 220.02,41.51 220.21,41.7 220.49,41.7 220.51,41.68 220.57,41.68 220.66,41.59 221.14,41.59 221.58,42.03 221.68,42.03 222.2,42.55 222.31,42.55
+3VALW on BOTTOM (solid shape): 157.33,23.94 157.33,23.5 157.57,23.26 158.41,23.26 158.92,22.75 158.92,22.56 158.87,22.51 158.6,22.51 158.35,22.77 157.33,22.77 157.25,22.68 156.05,22.68 156.02,22.72 155.23,22.72 154.98,22.98 154.98,23.36 155.31,23.69 156.67,23.69 156.99,24.01 157.26,24.01
+3VALW on BOTTOM (solid shape): 178.01,22.57 178.01,22.32 178.19,22.15 178.19,21.72 178.29,21.62 178.29,21.31 178.16,21.18 177.31,21.18 177.17,21.31 177.17,21.7 177.31,21.84 177.31,22.04 177.42,22.16 177.48,22.2 177.52,22.26 177.6,22.34 177.6,22.56 177.7,22.66 177.92,22.66
+3VALW on BOTTOM (solid shape): 71.3,18.13 82.81,18.13 82.97,17.97 82.97,14.29 82.57,13.89 79.83,13.89 79.83,14.41 79.1,14.41 79.1,13.89 78.65,13.89 78.65,14.41 77.93,14.41 77.93,13.89 77.35,13.89 76.72,14.52 76.72,15.46 76.11,16.07 69.33,16.07 69.16,16.24 69.16,18.79 69.41,19.04 70.38,19.04
+3VALW on BOTTOM (solid shape): 159.61,29.55 159.61,28.79 159.59,28.7 159.61,28.62 159.61,28.27 159.31,27.97 158.67,27.97 158.5,28.14 158.5,28.2 158.5,28.42 158.64,28.56 158.65,28.57 158.75,28.62 158.8,28.71 158.8,28.73 158.93,28.85 158.93,29.9 159.01,29.99 159.17,29.99
+3VALW on BOTTOM (solid shape): outline of 87 points within 274.42,34.43 281.31,52.54
+3VALW on IN1 (solid shape): 223.04,12.44 224.1,12.44 224.3,12.24 224.3,10.8 224.03,10.53 221.86,10.53 220.42,11.97 217.48,11.97 217.27,12.18 217.27,13.82 217.54,14.09 221.39,14.09
+3VALW on IN1 (solid shape): outline of 524 points within 61.99,17.74 71.08,38.93
+3VALW on IN2 (solid shape): 178.5,22.71 178.5,21.57 178.25,21.33 177.27,21.33 177.15,21.44 177.15,21.76 177.89,22.5 177.89,22.71 177.99,22.8 178.4,22.8
+3VALW on IN2 (solid shape): outline of 3219 points within 76.08,6.59 158.12,16.27
+3VALW on IN3 (solid shape): outline of 5753 points within 216.42,10.05 278.04,38.81
+3VALW on IN4 (solid shape): outline of 2034 points within 76.08,6.59 157.59,16.14
+3VALW on VCC: outline of 290 points within 151.27,10.66 223.02,46.09
+3VALW on VCC: outline of 120 points within 220.48,18.41 254.87,50.12
+3VALW_EC on TOP (solid shape): 239.31,20.76 239.31,19.82 239.17,19.69 239.17,19.43 239.6,19.01 239.6,18.96 239.66,18.89 239.66,18.67 239.43,18.44 239.24,18.44 239.07,18.28 239.07,17.74 238.72,17.39 235.06,17.39 235.01,17.44 235.01,17.8 235.05,17.83 236.01,17.83 236.02,17.85 236.84,17.85 237.22,18.23 237.99,18.23 238.02,18.25 238.21,18.25 238.37,18.41 238.37,18.6 238.4,18.64 238.4,20.31 238.94,20.84 239.23,20.84
+3VALW_EC on BOTTOM: 225.96,17.72 226.4,17.72 226.45,17.67 226.45,16.77 226.34,16.65 225.31,16.65 225.26,16.6 225.26,15.62 225.12,15.48 224.61,15.48 224.44,15.32 224.44,14.43 223.68,13.67 223.11,13.67 222.98,13.79 222.98,14.07 223.78,14.87 223.78,16.11 224.74,17.06 225.33,17.06 225.84,17.57 225.84,17.6
+3VALWP on BOTTOM (solid shape): 76.97,13.76 78.05,13.76 78.05,14.28 78.5,14.28 78.5,13.73 79.25,13.73 79.25,14.28 79.69,14.28 79.69,13.76 81.11,13.76 81.29,13.58 81.29,9.03 80.96,8.7 72.25,8.7 71.99,8.96 71.99,9.87 72.02,9.9 72.02,14.34 72.4,14.72 76.01,14.72
+3VLP on BOTTOM (solid shape): 152.46,16.23 152.89,16.23 152.89,16.35 152.91,16.35 152.91,16.77 153.44,16.77 153.44,15.45 153.26,15.26 152.02,15.26 151.94,15.34 151.94,16.69 152.02,16.77 152.46,16.77
+3VS on TOP (solid shape): 274.38,18.71 274.38,18.01 273.78,17.41 273.27,17.41 273.18,17.5 273.18,18.66 273.3,18.78 274.31,18.78
+3VS on TOP (solid shape): 218.73,39.33 219.19,39.33 219.75,38.78 219.75,37.28 219.42,36.95 218.21,36.95 217.9,37.26 217.9,38.96 218.3,39.36 218.7,39.36
+3VS on TOP (solid shape): 274.2,43.04 274.2,41.99 274.01,41.8 273.67,41.8 273.44,42.03 273.01,42.03 272.81,42.23 271.65,42.23 271.5,42.38 271.5,43.17 271.72,43.39 273.86,43.39
+3VS on TOP (solid shape): 161.12,20.03 161.12,18.32 161.13,18.31 161.13,18.16 160.91,17.94 160.91,17.1 161.11,16.91 161.11,16.18 160.82,15.89 157.38,15.89 157.37,15.9 157.23,15.9 157.07,16.06 157.07,16.97 157.22,17.12 158.19,17.12 159.01,17.95 159.52,17.95 160.33,18.76 160.33,19.98 160.46,20.11 161.04,20.11
+3VS on TOP (solid shape): 10.55,40.35 10.55,40.02 11.49,39.08 13.37,39.08 14.28,38.17 14.28,36.16 14.11,35.98 11.2,35.98 10.53,36.66 9.73,36.66 9.71,36.64 9.51,36.64 9.42,36.73 9.42,37.32 9.52,37.42 11.02,37.42 11.62,36.82 13.19,36.82 13.27,36.9 13.27,37.02 13.19,37.1 11.77,37.1 11.11,37.76 10.22,37.76 8.72,39.26 8.72,40.27 9,40.55 10.35,40.55
+3VS on TOP (solid shape): outline of 94 points within 238.47,32.25 242.2,37.04
+3VS on TOP (solid shape): outline of 956 points within 198.85,14.69 216.93,32.38
+3VS on BOTTOM (solid shape): 161.3,17.39 161.3,16.08 161.11,15.89 156.84,15.89 156.54,16.2 156.54,17.33 156.7,17.48 161.2,17.48
+3VS on BOTTOM (solid shape): 138.58,22.63 138.58,21.63 137.8,20.84 137.8,19.18 137.69,19.08 137.36,19.08 137.26,19.18 137.26,21.34 137.91,22 137.91,22.62 138.04,22.75 138.46,22.75
+3VS on BOTTOM (solid shape): 219.57,39.66 219.57,39.62 219.85,39.34 219.85,37.2 219.59,36.95 218.6,36.95 218.03,37.52 218.03,38.76 218.56,38.76 218.56,39.2 218.03,39.2 218.03,39.6 218.17,39.74 219.49,39.74
+3VS on BOTTOM (solid shape): 169.54,17.72 169.54,17.46 169.45,17.38 169.45,16.96 169.54,16.87 169.54,16.68 169.34,16.48 169.09,16.48 168.95,16.62 168.53,16.62 168.39,16.48 167.92,16.48 167.78,16.62 167.78,17.73 167.86,17.8 169.46,17.8
+3VS on BOTTOM (solid shape): 247.69,32.15 247.69,21.88 247.02,21.22 245.91,21.22 245.81,21.33 245.81,23.15 246.67,24.02 246.67,26.58 246.56,26.7 246.56,31.34 246.36,31.54 246.36,32.6 246.47,32.71 247.13,32.71
+3VS on IN1 (solid shape): outline of 1330 points within 245.86,11.39 275.19,22.67
+3VS on IN2 (solid shape): 213.95,30.29 213.95,29.73 214.33,29.36 214.33,29.28 214.03,28.98 213.92,28.98 213.27,29.63 213.27,30.34 213.42,30.5 213.75,30.5
+3VS on IN2 (solid shape): outline of 476 points within 272.3,17.38 275.98,43.3
+3VS on IN2 (solid shape): outline of 1295 points within 238.11,20.92 248.9,34.15
+3VS on IN3 (solid shape): 242.28,33.75 242.28,32.73 242.16,32.62 241.27,32.62 240.62,33.26 240.62,33.8 240.73,33.9 242.12,33.9
