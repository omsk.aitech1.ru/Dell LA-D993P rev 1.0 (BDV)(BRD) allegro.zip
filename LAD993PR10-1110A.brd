# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_CLK_DDR#1: length 52
  IN4 w0.094: v2(107.08,71.01) 107.08,70.94 106.87,70.73 106.64,70.73 106.49,70.88 106.49,73.23 106.24,73.47 105.77,73.47 105.52,73.23 105.52,70.44 106.11,69.86 106.11,66.69 106.36,66.43 106.36,49.42 105.37,48.43 105.37,41.04 104.45,40.13 104.45,36.11 104.91,35.66 105.32,35.66 v2(105.46,35.51)
  BOTTOM w0.076: v2(107.08,71.01) 107.08,70.86 106.91,70.69 106.78,70.69 106.65,70.82 106.65,72.14 106.36,72.43 106.36,73.89 106.45,73.98 106.57,73.98 106.65,73.9 UH1.AK1
  BOTTOM w0.114: JDIMM1.140 105.4,33.61 105.24,33.77 105.24,34.46 104.94,34.76 104.94,35.67 105.07,35.8 105.18,35.8 v2(105.46,35.51)
M_CLK_DDR#2: length 65
  IN1 w0.076: v2(104.97,78.65) 104.97,78.88 105.08,78.99 105.21,78.99 105.37,78.82 105.37,77.67 105.8,77.24 106.4,77.24 106.7,76.94 106.7,75.41 106.45,75.16 106.45,67.72 106.45,67.72 106.45,67.68 106.42,67.65 106.42,67.64
  IN1 w0.094: 106.42,67.64 106.42,65.28 108.39,63.31 108.39,55.52 108.6,55.3 108.84,55.3 108.94,55.21 108.94,54.83 108.84,54.74 108.6,54.74 108.39,54.53 108.39,54.09 105.77,51.48 105.77,40.35 104.83,39.41 104.83,34.08 104.33,33.57 104.33,33.13 104.57,32.89 104.71,32.89 104.84,32.76 104.84,32.46 104.71,32.33 104.54,32.33 104.33,32.12 104.33,29.27 106.08,27.52 106.08,25.62 105.95,25.49 105.69,25.49 105.57,25.62 v2(105.57,25.91)
  BOTTOM w0.076: UH1.AN9 104.63,79.06 104.73,79.06 104.97,78.83 v2(104.97,78.65)
  BOTTOM w0.114: JDIMM2.139 105.16,27.28 105.01,27.13 105.01,26.81 104.72,26.52 104.72,25.99 105.21,25.49 105.42,25.49 105.57,25.64 v2(105.57,25.91)
M_CLK_DDR#3: length 66.4
  IN1 w0.076: v2(105.89,78.62) 106.07,78.44 106.25,78.44 107.34,77.35 107.34,75.4 107.72,75.01 107.72,73.02 107.73,73.01 107.73,73 107.74,73 107.75,73.01 107.75,72.99
  IN1 w0.094: 107.75,72.99 107.75,65.25 109.84,63.16 109.84,57.31 109.46,56.93 109.46,56.33 109.84,55.95 109.84,53.41 109.11,52.68 108.81,52.68 108.63,52.86 108.45,52.86 108.24,52.64 108.24,52.46 108.42,52.28 108.42,51.98 107.78,51.34 107.48,51.34 107.29,51.53 107.16,51.53 106.89,51.27 106.89,51.13 107.08,50.94 107.08,50.65 106.67,50.24 106.67,39.8 106.08,39.21 106.08,33.69 105.87,33.48 105.87,29.45 106.98,28.34 106.98,25.2 106.36,24.57 106.36,22.49 106.16,22.29 105.86,22.29 v2(105.69,22.12)
  BOTTOM w0.076: UH1.AM8 v2(105.89,78.62)
  BOTTOM w0.114: JDIMM2.140 105.41,20.86 105.21,21.05 105.21,22.19 105.33,22.31 105.5,22.31 v2(105.69,22.12)
M_ODT0: length 52.3
  IN4 w0.152: v2(113.44,38.94) 113.35,38.94 113.33,38.91 112.89,38.91 112.71,39.09 112.71,39.87 112.89,40.05 113.27,40.05 113.45,40.23 113.45,40.58 113.27,40.76 112.89,40.76 112.71,40.94 112.71,41.49 113.23,42.01 113.23,43.03 113.41,43.21 113.96,43.21 114.14,43.39 114.14,43.74 113.96,43.92 113.41,43.92 113.23,44.1 113.23,44.45 113.41,44.63 113.96,44.63 114.14,44.81 114.14,45.16 113.96,45.34 113.41,45.34 113.23,45.52 113.23,46.54 114.1,47.42 114.1,54.62 114.77,55.28 114.77,55.7 114.59,55.88 114.28,55.88 114.1,56.06 114.1,56.41 114.28,56.59 114.59,56.59 114.77,56.77 114.77,57.32 114.58,57.51 113.51,57.51 113.33,57.69 113.33,58.27 113.51,58.45 114.25,58.45 114.42,58.63 114.42,59.02 114.08,59.36 v2(113.13,59.36)
  BOTTOM w0.076: 112.15,68.95 112.15,74.03 111.96,74.22 111.96,74.75 UH1.AD3
  BOTTOM w0.185: v2(113.13,59.36) 113.26,59.36 114.31,60.42 114.31,63.38 112.25,65.44 112.25,68.82 112.15,68.92 112.15,68.95 ; v2(113.44,38.94) 113.39,38.89 113.27,38.89 112.97,38.59 112.97,38.3 112.8,38.13 112.46,38.13 112.29,38.3 112.29,38.74 112.12,38.91 111.72,38.91 111.55,39.08 111.55,39.27 111.15,39.67 JDIMM1.155
M_ODT1: length 52.5
  IN4 w0.152: v2(113.16,63.58) 116.35,60.39 116.35,50.74 115.66,50.05 115.66,42.26 114.99,41.59 114.99,35.94 114.05,34.99 113.79,34.99 113.66,35.13 v2(113.45,35.13)
  BOTTOM w0.076: 111.59,69 111.59,69.38 111.96,69.75 111.96,73.86 111.73,74.1 111.57,74.1 111.39,74.27 111.39,74.57 111.22,74.74 111.22,75.4 UH1.AE4
  BOTTOM w0.185: v2(113.45,35.13) 114.48,36.15 114.48,39.25 113.85,39.87 113.01,39.87 112.67,40.22 112.67,40.96 JDIMM1.161 ; 111.59,69 111.59,65.15 v2(113.16,63.58)
M_ODT2: length 66.8
  IN1 w0.076: 112.01,69.71 112.01,71.75 111.67,72.09 111.67,74.17 110.8,75.04 110.8,77.65 v2(110.46,78)
  IN1 w0.152: 112.01,69.71 117.77,63.95 117.77,50.49 117.57,50.29 117.57,50.01 117.73,49.85 117.73,49.58 117.46,49.3 117.18,49.3 116.98,49.5 116.65,49.5 116.36,49.21 116.36,49.03 116.7,48.7 116.7,48.42 116.42,48.15 116.15,48.15 115.93,48.38 115.3,48.38 115.1,48.18 115.1,47.87 115.43,47.54 115.43,47.1 115.1,46.78 115.1,40.34 113.95,39.19 113.95,31.92 114.08,31.79 114.08,25.06 v2(113.95,24.93)
  BOTTOM w0.076: UH1.AF7 110.11,77.65 v2(110.46,78)
  BOTTOM w0.185: v2(113.95,24.93) 113.9,24.88 113.57,24.88 113.19,24.5 112.18,24.5 111.88,24.79 111.88,26.22 111.16,26.94 JDIMM2.155
M_ODT3: length 66.6
  IN1 w0.076: 112.49,70.08 112.49,76.38 111.69,77.17 111.69,77.52 111.35,77.86 v2(111.35,78.02)
  IN1 w0.152: 112.49,70.08 118.76,63.8 118.76,49.08 116.1,46.41 116.1,39.93 114.94,38.78 114.94,38.41 115.14,38.22 115.53,38.22 115.73,38.03 115.73,37.64 115.53,37.45 115.14,37.45 114.94,37.26 114.94,36.87 115.14,36.68 115.47,36.68 115.67,36.48 115.67,36.1 115.47,35.9 115.14,35.9 114.94,35.71 114.94,35.33 115.14,35.13 115.53,35.13 115.73,34.94 115.73,34.55 115.53,34.36 115.14,34.36 114.94,34.17 114.94,32.33 115.07,32.2 115.07,25.06 v2(115.28,24.85)
  BOTTOM w0.076: UH1.AE8 111.08,78.3 v2(111.35,78.02)
  BOTTOM w0.185: JDIMM2.161 112.66,27.18 113.16,26.68 113.88,26.68 115.28,25.28 v2(115.28,24.85)
MAINPWON: length 4.8
  BOTTOM w0.114: v3(56.97,45.18) 58,46.21 RT3.2 58.68,47.16 58.68,48 58.42,48.26 UT1.7
MCARD_PCIE#_SATA: length 68.3
  TOP w0.114: RH68.1 155.26,32.79 155.26,32.56 155.7,32.12 156.69,32.12 157.53,31.28 159.16,31.28 159.26,31.18 v3(160.8,31.18) 161.09,31.18 v2(161.7,30.57)
  IN3 w0.127: v2(205.01,23.92) 204.43,24.5 191.34,24.5 186.5,19.66 182.92,19.66 181.77,18.52 178.3,18.52 177.68,19.13 174.68,19.13 174.41,19.4 171.93,19.4 171.74,19.21 171.74,19.21 171.7,19.17 170.04,19.17 169.7,19.51 167.54,19.51 167.23,19.81 167.23,20 166.77,20.46 166.77,21.31 166.34,21.74 164.98,21.74 162.89,23.83 162.89,24.49 162.97,24.57 162.97,28.55 162.63,28.88 162.63,29.64 v2(161.7,30.57)
  BOTTOM w0.089: UH2.AG36 161.35,30.93 v2(161.7,30.57)
  BOTTOM w0.114: v2(205.01,23.92) 205.01,21.26 204.23,20.48 RD58.1
MCT0: length 2.6
  TOP w0.114: v2(303.41,91.35) v3(303.41,91.98)
  TOP w0.508: RL19.1 v2(303.41,91.35)
  BOTTOM w0.508: v2(303.41,91.35) 303.41,92.61 TL2.24
MCT1: length 3.4
  TOP w0.114: v2(301.1,91.15) 301.11,91.15 v3(301.57,91.61)
  TOP w0.508: RL20.1 300.57,90.62 v2(301.1,91.15)
  BOTTOM w0.508: v2(301.1,91.15) 301.1,91.2 300.43,91.88 TL2.21
MCT2: length 3
  TOP w0.114: v2(297.17,91.35) v3(296.44,91.35)
  TOP w0.508: v2(297.17,91.35) 297.17,90.89 RL39.1
  BOTTOM w0.508: v2(297.17,91.35) 297.17,91.55 297.46,91.84 TL2.18
MCT3: length 2.8
  TOP w0.114: v2(294.49,91.34) 294.49,91.35 v3(293.98,91.86)
  TOP w0.508: RL40.1 294.52,91.3 v2(294.49,91.34)
  BOTTOM w0.508: TL2.15 v2(294.49,91.34)
MDI0+: length 40.8
  IN4 w0.089: v2(284.59,49.16) 284.74,49.31 284.74,50.17 285.25,50.68 285.25,59.51 290.13,64.39 290.13,66.17 291.02,67.06 291.02,70.81 292.82,72.62 292.82,81.57 v2(292.62,81.78)
  BOTTOM w0.089: v2(292.62,81.78) 292.9,82.06 292.9,82.36 292.51,82.75 TL2.12 ; v2(284.59,49.16) 284.77,48.99 284.77,48.3 284.68,48.21 284.68,47.29 284.61,47.22 UL1.1
MDI0-: length 40.8
  IN4 w0.089: 285.14,49.25 285.14,49.25 ; 285.14,49.25 285.07,49.32 285.07,50.03 285.58,50.54 285.58,59.37 290.46,64.25 290.46,66.03 291.35,66.92 291.35,70.68 293.15,72.48 293.15,81.55 v2(293.38,81.78) ; 285.14,49.25 v2(285.23,49.16)
  BOTTOM w0.089: v2(285.23,49.16) 285.01,48.95 285.01,48.2 284.92,48.11 284.92,47.32 285.01,47.23 UL1.2 ; TL2.11 293.5,82.68 293.14,82.33 293.14,82.02 v2(293.38,81.78)
MDI1+: length 41.5
  IN4 w0.089: v2(295.67,81.27) 295.86,81.08 295.86,80.51 294.8,79.46 294.8,72.93 292.29,70.41 292.29,66.3 291.31,65.32 291.31,63.77 287.6,60.06 287.6,59.08 287.6,51.3 285.86,49.56 285.86,48.54 v2(285.71,48.39)
  BOTTOM w0.089: v2(295.67,81.27) 295.87,81.48 295.87,82.34 295.48,82.74 TL2.9 ; v2(285.71,48.39) 285.89,48.21 285.89,47.31 285.81,47.24 UL1.4
MDI1-: length 41.5
  IN4 w0.089: v2(296.3,81.27) 296.19,81.16 296.19,80.38 295.14,79.32 295.14,72.79 292.62,70.27 292.62,66.16 291.64,65.18 291.64,63.63 287.93,59.92 287.93,59.91 287.93,51.16 286.19,49.43 286.19,48.54 v2(286.34,48.39)
  BOTTOM w0.089: v2(286.34,48.39) 286.13,48.17 286.13,47.31 286.21,47.22 UL1.5 ; TL2.8 296.47,82.71 296.11,82.35 296.11,81.46 v2(296.3,81.27)
MDI2+: length 45.8
  IN4 w0.089: v2(298.59,85.33) 298.76,85.16 298.76,83.6 297.43,82.27 297.43,69.76 294.08,66.41 294.08,65.72 292.49,64.14 292.49,63.28 288.78,59.57 288.78,50.46 286.77,48.45 286.77,48 v2(286.61,47.84)
  BOTTOM w0.089: v2(298.59,85.33) 298.83,85.09 298.83,84.89 298.45,84.51 TL2.6 ; UL1.6 286.61,47.19 286.77,47.34 286.77,47.68 v2(286.61,47.84)
MDI2-: length 45.8
  IN4 w0.089: v2(287.28,47.84) 287.11,48.02 287.11,48.31 289.12,50.32 289.12,59.43 292.83,63.14 292.83,64 294.41,65.58 294.41,66.27 297.76,69.62 297.76,82.13 299.09,83.47 299.09,85.26 v2(299.2,85.36)
  BOTTOM w0.089: v2(287.28,47.84) 287.17,47.84 287.01,47.69 UL1.7 ; TL2.5 299.44,84.54 299.07,84.9 299.07,85.23 v2(299.2,85.36)
MDI3+: length 49.1
  IN4 w0.089: v2(289.94,49.3) 290.11,49.13 290.33,49.13 290.46,49.26 290.46,58.75 291.59,59.89 292.35,59.89 296.04,63.58 296.04,66.63 298.61,69.19 298.61,81.72 301.86,84.97 301.86,85.28 301.81,85.33 v2(301.51,85.33)
  BOTTOM w0.089: UL1.9 288.49,46.09 288.55,46.03 288.77,46.03 288.91,46.17 288.91,48.68 289.36,49.13 289.77,49.13 v2(289.94,49.3) ; v2(301.51,85.33) 301.76,85.33 301.88,85.22 301.88,84.93 301.42,84.47 TL2.3
MDI3-: length 49.1
  IN4 w0.089: v2(289.93,48.68) 290.05,48.8 290.47,48.8 290.79,49.12 290.79,58.61 291.73,59.55 292.49,59.55 296.38,63.44 296.38,66.49 298.95,69.06 298.95,81.58 302.2,84.83 302.2,85.26 v2(302.27,85.33)
  BOTTOM w0.089: UL1.10 288.49,45.69 288.58,45.79 288.87,45.79 289.15,46.07 289.15,48.58 289.46,48.89 289.79,48.89 289.93,48.74 v2(289.93,48.68) ; TL2.2 302.41,84.59 302.12,84.88 302.12,85.18 v2(302.27,85.33)
MDO0+: length 20.7
  BOTTOM w0.254: JLAN.1 294.48,108.4 293.25,108.4 292.05,107.19 292.05,106.31 v1(291.14,105.41) 290.13,104.4 290.13,100.21 292.51,97.83 TL2.13
MDO0-: length 20.7
  BOTTOM w0.254: TL2.14 293.5,93.73 293.29,93.93 293.09,93.93 292.88,94.14 292.88,97.98 v1(291.42,99.44) 290.5,100.36 290.5,104.24 292.41,106.16 292.41,107.04 293.41,108.03 294.33,108.03 294.52,107.84 294.52,106.54 JLAN.2
MDO1+: length 17.3
  BOTTOM w0.254: TL2.16 295.48,93.51 293.91,95.07 293.91,98.8 291.51,101.2 v1(291.51,103.3) 291.51,103.63 292.67,104.79 293.28,104.79 293.86,105.37 JLAN.3
MDO1-: length 17.3
  BOTTOM w0.254: JLAN.6 293.43,103.25 293.43,104.17 293.18,104.42 292.82,104.42 291.88,103.48 v1(291.88,101.64) 291.88,101.36 294.28,98.96 294.28,95.23 295.77,93.74 296.21,93.74 296.47,93.48 TL2.17
MDO2+: length 20.4
  TOP w0.254: v2(298.45,91.3) 298.73,91.58 298.73,92.08 298.24,92.56 295.4,92.56 293.2,94.76 293.2,98.31 292.24,99.27 292.24,102.49 293.34,103.58 293.99,103.58 294.37,103.96 JLAN.4
  BOTTOM w0.254: TL2.19 298.45,92.15 298.75,91.85 298.75,91.61 v2(298.45,91.3)
MDO2-: length 20.4
  TOP w0.254: v2(299.44,91.3) 299.09,91.64 299.09,92.23 298.39,92.93 295.55,92.93 293.57,94.91 v1(293.57,96.41) 293.57,98.47 292.61,99.42 292.61,102.33 293.49,103.21 294.14,103.21 294.26,103.33 JLAN.5
  BOTTOM w0.254: v2(299.44,91.3) 299.12,91.62 299.12,91.82 299.44,92.13 TL2.20
MDO3+: length 16.6
  TOP w0.254: JLAN.7 295.37,101.19 295.37,98.35 294.99,97.97 294.99,95.45 296.12,94.31 298.97,94.31 300.01,93.27 301.71,93.27 301.9,93.46 301.9,93.78 301.58,94.1 v2(301.51,94.1)
  BOTTOM w0.254: TL2.22 301.42,93.17 301.83,93.58 301.83,93.88 301.61,94.1 v2(301.51,94.1)
MDO3-: length 16.6
  TOP w0.254: JLAN.8 295.01,99.63 295.01,98.51 294.62,98.13 294.62,95.29 295.97,93.94 v1(297.38,93.94) 298.81,93.94 299.86,92.9 301.86,92.9 302.27,93.31 v2(302.27,94.1)
  BOTTOM w0.254: TL2.23 302.41,93.17 302.19,93.38 302.19,94.02 v2(302.27,94.1)
ME_EN: length 2.1
  TOP w0.114: RH18.1 RH47.1 188.67,14.52 v3(188.85,14.34)
ME_FWP_EC: length 62.1
  TOP w0.114: UE1.80 237.6,23.74 238.24,24.37 238.24,25.31 RE21.1 238.44,26.28 v2(238.24,26.48) ; v2(188.97,18.07) 188.97,16.58 v4(188.98,16.57) RH47.2
  IN3 w0.127: v2(238.24,26.48) 237.61,25.86 236.58,25.86 236.25,26.19 231.9,26.19 231.72,26.01 230.33,26.01 229.73,25.41 229.73,24.91 229.24,24.42 227.64,24.42 227.09,23.88 225.25,23.88 224.77,23.4 223.9,23.4 222.05,21.55 216.66,21.55 215.9,20.79 214.23,20.79 212.61,19.17 211.54,19.17 211.54,19.17 210.38,19.17 209.87,19.68 206.06,19.68 205.8,19.42 196.71,19.42 194.95,17.67 189.38,17.67 v2(188.97,18.07)
ME_SUS_PWR_ACK: length 68.1
  TOP w0.114: v2(226.15,20.62) 226.15,18.43 225.64,17.93 225.64,17.22 225.45,17.02 UE1.42 ; v2(169.55,20.98) 169.54,20.96 v3(169.54,19.81) 169.54,19.01 RH67.1
  IN1 w0.094: v2(226.15,20.62) 226.08,20.68 223.3,20.68 222.93,21.05 213.97,21.05 213.26,21.76 206.11,21.76 205.96,21.91 199.83,21.91 198.94,21.02 192.73,21.02 192.37,21.39 188.54,21.39 187.89,20.74 187.44,20.74 186.37,19.68 181.43,19.68 180.5,20.6 178.66,20.6 178.47,20.42 175.14,20.42 174.61,20.94 173.48,20.94 172.84,20.3 171.72,20.3 170.98,21.04 169.61,21.04 v2(169.55,20.98)
  BOTTOM w0.076: UH2.BD19 169.78,22.27 169.78,21.21 v2(169.55,20.98)
MEC_XTAL1: length 2.8
  TOP w0.114: Y1.1 223.38,36.83 222.69,36.13 CE102.1 RE66.2
MEC_XTAL1_R: length 3.2
  TOP w0.114: UE1.123 223.85,32.59 223.63,32.8 223.53,32.8 223.28,33.05 223.28,33.49 v3(223.37,33.58) 223.37,34.3 RE66.1
MEC_XTAL2: length 6.2
  TOP w0.114: UE1.125 223.05,32.65 v3(222.08,33.62) 221.7,34 RE106.2 CE101.1 221.7,35.75 220.88,36.57 Y1.2
MEM_VDD_CTL: length 57.6
  TOP w0.114: v2(143.27,108.75) 143.29,108.73 PR908.1 144.94,108.37 v3(145.6,107.71)
  IN1 w0.094: v2(143.27,108.75) 143.27,106.89 149.87,100.28 149.87,88.01 152.62,85.26 152.62,84.76 154.74,82.63 159.1,82.63 159.48,83.02 160.66,83.02 160.79,83.15 162.91,83.15 164,82.06 165.14,82.06 165.49,82.41 169.07,82.41 169.69,83.03 170.37,83.03 170.95,82.44 170.95,82.05 171.91,81.09 171.91,80.39 172.23,80.07 172.23,78.75 172.48,78.5 172.98,78.5 v2(173.36,78.11)
  BOTTOM w0.114: v2(173.36,78.11) 173.76,77.71 UV1.L3
MEM_VREF: length 102.1
  IN1 w0.406: v2(174.41,75.49) 174.9,75.49 175.24,75.15 175.24,74.74 175.65,74.34 v2(178.55,74.34)
  IN1 w0.508: v2(193.01,117.55) 197.66,117.55 200.67,114.54 201.43,114.54 203.97,112 204.1,112 204.48,111.62 209.94,111.62 211.97,109.59 211.97,74.67 210.45,73.14 202.7,73.14 201.77,72.21 v2(201.08,72.21)
  BOTTOM w0.254: v2(174.41,75.49) 174.41,75.7 174,76.11 UV1.L1
  BOTTOM w0.381: RV27.1 173.64,74.97 174.16,75.49 v2(174.41,75.49)
  BOTTOM w0.406: v2(178.55,74.34) 179.61,74.34 180.19,73.76 v4(187.33,73.76) QV21.2
  BOTTOM w0.508: QV20.2 v2(193.01,117.55) ; QV21.2 193.98,73.76 194.78,72.96 200.32,72.96 v2(201.08,72.21)
MIC2_VREFO: length 8.1
  TOP w0.203: HDA1.29 285.47,24.15 v2(285.63,23.99)
  BOTTOM w0.508: v2(285.63,23.99) 285.63,23.74 v4(287.45,21.92) 287.49,21.88 RA42.1 287.54,20.06 288.05,19.55 288.73,19.55 288.99,19.8 RA43.1
MSATA_DEVSLP: length 79.5
  TOP w0.114: v2(158.76,30.56) v3(158.1,30.56)
  IN3 w0.127: v2(158.76,30.56) 158.75,30.57 158.75,30.57 158.73,30.59 157.38,30.59 156.85,30.06 156.27,30.06 155.15,28.95 155.15,26.81 155.99,25.97 157.78,25.97 159.26,24.49 159.91,24.49 162.6,21.8 162.97,21.8 165.99,18.77 169.22,18.77 169.51,18.48 170.8,18.48 171.45,17.83 178.01,17.83 178.64,17.2 181.45,17.2 183.22,18.98 186.92,18.98 188.07,20.13 192.48,20.13 192.95,20.6 193.59,20.6 196.6,23.61 203.83,23.61 204.41,23.03 211.81,23.03 214.36,25.57 217.64,25.57 v2(218.17,26.1)
  BOTTOM w0.089: UH2.AG42 158.76,30.59 v2(158.76,30.56)
  BOTTOM w0.114: RD59.2 218.35,26.28 v2(218.17,26.1)
MSCLK: length 3.3
  BOTTOM w0.114: JDEG1.6 251.72,34.09 252.49,33.31 v3(252.61,33.31) 252.73,33.31 253.26,32.78 253.55,32.78 RE63.2
MSDATA: length 4
  BOTTOM w0.114: RE65.2 254.13,33.22 v3(253.92,33.22) 253.17,33.22 252.75,33.65 252.48,33.65 252.22,33.91 JDEG1.7
NRB_BIT: length 3.9
  TOP w0.114: v2(165.39,19.98) 165.21,19.98 RH92.2
  BOTTOM w0.076: v2(165.39,19.98) 165.62,20.21 v3(165.62,20.5) 165.03,21.08 165.03,21.48 165.27,21.72 165.27,22.3 UH2.BD28
NVVDD_EN: length 40.1
  TOP w0.114: v2(156.72,78.1) 156.82,78.2 QZ7.2
  IN1 w0.094: v2(156.72,78.1) 156.59,78.1 156.29,77.8 156.29,75.16 158.89,72.55 165.93,72.55 167.17,71.31 v2(167.17,70.84)
  BOTTOM w0.114: RV608.1 174.51,58.46 174.13,58.84 174.13,61.04 175.38,62.3 175.38,63.35 175.21,63.53 175.21,64.3 174.98,64.53 UV23.4 173.67,64.53 172.83,65.37 172.83,70.07 172.62,70.28 167.73,70.28 v2(167.17,70.84)
  BOTTOM w0.203: v3(175.64,57.59) PU1600.3
  BOTTOM w0.254: v3(175.64,57.59) 175.64,58.37 CV919.1 175.55,58.46 RV608.1
NVVDD_PGOOD: length 3
  TOP w0.114: v2(175.73,52.39) v3(175.36,52.76)
  TOP w0.254: v2(175.73,52.39) 175.55,52.21 PR1624.1
  BOTTOM w0.203: PU1600.13 175.64,52.84 175.73,52.75 v2(175.73,52.39) 175.55,52.22 PR1619.1
NVVDD_PWM_VID: length 26.6
  IN1 w0.094: v2(174.23,67.44) 173.57,68.1 173.57,71 170.69,73.89 170.69,74.53 171.33,75.17 171.33,79.26 v2(170.85,79.75)
  BOTTOM w0.114: PR1603.1 178.78,60.67 177.33,62.11 v4(177.33,63.66) 177.7,64.02 177.7,66.49 177.31,66.87 174.95,66.87 174.38,67.44 v2(174.23,67.44) ; UV1.P6 171.21,80.16 170.85,79.8 v2(170.85,79.75)
NVVDD_VID: length 4.5
  BOTTOM w0.114: v3(179.78,58.51) PR1603.2
  BOTTOM w0.203: PR1603.2 178.19,57.93 177.28,57.93 176.44,57.09 PU1600.5
NVVDDS_EN: length 190.9
  TOP w0.114: v2(200.92,55.86) 200.62,55.86 199.53,54.77 198.13,54.77 197.86,55.03 197.86,55.41 197.6,55.68 195.02,55.68 188.64,49.3 v4(169.22,49.3) 165.96,49.3 165.74,49.52 151.93,49.52 147.74,45.33 145.08,45.33 v2(144.93,45.18) ; QZ8.2 149.41,106.38 148.96,106.83 147.22,106.83 146.16,105.76 146.16,101.55 v2(144.42,99.81)
  TOP w0.203: PU1700.3 202.55,52.96
  TOP w0.254: v2(200.92,55.86) 200.92,55.45 UV21.4 201.25,55.12 CV918.1 RV607.1 201.62,53.37 202.03,52.96 202.55,52.96
  IN1 w0.094: v2(144.93,45.18) 143.22,45.18 141.76,46.63 141.76,61.75 144.32,64.31 144.32,66.47 147.83,69.98 147.99,69.98 148.24,70.23 148.24,71.44 147.53,72.16 147.53,72.99 146.75,73.77 146.75,74.9 145.46,76.2 145.46,79.37 145.89,79.8 145.89,80.18 145.23,80.84 145.23,81.36 145.58,81.71 145.58,82.9 143.49,84.99 143.49,99.06 144.24,99.81 v2(144.42,99.81)
  IN3 w0.127: v2(230.49,42.26) 230.08,41.85 230.08,41.67 229.18,40.77 219.9,40.77 219.22,40.08 216.34,40.08 215.68,39.42 209.61,39.42 207.39,41.64 207.39,44.2 205.64,45.95 205.64,46.88 200.92,51.59 v2(200.92,55.86)
  BOTTOM w0.114: PR806.1 229.37,38.27 229.37,39.14 231.12,40.9 231.12,41.62 v2(230.49,42.26)
NVVDDS_PSI: length 4.9
  TOP w0.114: PR1701.1 202.21,50.66 v3(202.59,51.04)
  TOP w0.203: PU1700.4 201.78,52.56 PR1702.1 201.69,52.46 201.69,51.58 PR1700.2 PR1701.1
NVVDDS_PWM_VID: length 53.5
  TOP w0.114: v2(199.83,50.54) 199.83,50.32 200.43,49.72 PR1703.1
  IN4 w0.094: v2(170.88,78.91) 171.71,78.08 171.71,77.54 172.39,76.86 173.27,76.86 173.74,76.39 174.48,76.39 175.32,75.55 175.32,74.81 175.61,74.52 177.03,74.52 177.67,73.88 179.49,73.88 180.29,73.08 180.29,68.74 179.64,68.09 178.84,68.09 178.46,67.71 178.46,65.25 181.71,62.01 189.33,62.01 199.07,52.26 200.1,52.26 200.34,52.02 200.34,51.04 v2(199.83,50.54)
  BOTTOM w0.114: v2(199.83,50.54) v4(200.64,50.54) ; v2(170.88,78.91) 171.28,79.31 UV1.P5
NVVDDS_VID: length 4
  TOP w0.203: PU1700.5 203.18,52.16 202.98,51.96 202.98,50.12 v3(202.63,49.77) 202.59,49.72 PR1703.2
P_SYS: length 78.8
  TOP w0.114: v2(47.25,49.9) 46.23,49.9 42.22,45.89 39.1,45.89 37.26,44.04 v4(35.38,44.04) 33.97,44.04 33.27,43.35 31.96,43.35 31.94,43.32 v2(31.05,43.32)
  IN3 w0.127: v2(47.25,49.9) 54.27,49.9 61.25,56.87 61.25,69.43 65.34,73.52 66.43,73.52 68.2,75.3 68.2,79.37 64.89,82.68 v2(64.89,84.13)
  BOTTOM w0.114: v2(31.05,43.32) 31,43.27 31,41.82 PR329.1 29.07,39.9 PU300.9 ; v2(64.89,84.13) 65.01,84.01 PR1100.2
  BOTTOM w0.203: 68.2,86.88 68.2,87.16 68.4,87.37 PU1100.1
  BOTTOM w0.254: PR1100.2 PC1100.2 66.43,84.39 68.2,86.16 68.2,86.88
PANEL_BKEN_EC: length 203.1
  TOP w0.114: v3(61.67,29.32) 61.76,29.32 62.19,28.89 62.19,28.76 62.47,28.48 63.35,28.48 63.71,28.84 RV566.1 63.88,28.95 64.27,28.95 v2(64.4,29.07) ; UE1.117 226.25,30.87 226.5,30.62 226.5,29.88 227.74,28.64 228.74,28.64 229.04,28.34 229.04,27.46 v2(228.22,26.63)
  IN3 w0.127: v2(228.22,26.63) 227.68,26.63 224.67,23.62 223.8,23.62 221.96,21.78 216.57,21.78 216.33,21.54 215.81,21.02 214.07,21.02 213.11,20.07 205.98,20.07 205.59,19.68 196.64,19.68 195.55,18.58 188.5,18.58 187.53,17.6 183.79,17.6 179.36,13.17 179.18,13.17 178.68,12.67 178.68,12.39 178.42,12.12 176.18,12.12 175.78,12.52 175.78,12.74 175.14,13.38 170.46,13.38 169.71,14.13 161.43,14.13 159.71,15.84 159.71,16.91 158.34,18.29 156.34,18.29 155.62,19.01 153.18,19.01 152.02,20.18 147.88,20.18 146.9,19.21 97.91,19.21 97.42,18.72 97.42,18.58 97.08,18.24 94.23,18.24 93.91,18.56 93.91,18.88 93.17,19.62 63.13,19.62 59.15,23.6 59.15,24.82 60.2,25.86 60.2,28.26 61.17,29.23 64.24,29.23 v2(64.4,29.07)
PBAT_CHG_SMBCLK: length 310.1
  TOP w0.114: UE1.9 221.02,26.94 221.19,27.12 221.4,27.12 v2(221.55,26.96)
  IN1 w0.094: v2(33.12,42.94) 32.78,42.59 32.78,42.19 32.53,41.95 22.41,41.95 21.79,42.57 13.26,42.57 11.14,40.45 11.14,36.7 10.59,36.15 10.59,21.12 17.1,14.61 17.1,13.12 17.56,12.66 18.2,12.66 18.32,12.79 18.32,12.92 v2(18.04,13.2) 18.1,13.26 18.1,13.76 18.52,14.18 19.03,14.18 19.03,14.18 20.45,14.18 27.31,7.32 81.87,7.32 88.09,13.54 98.8,13.54 99,13.35 102.93,13.35 103.91,14.33 114.03,14.33 118.26,10.09 159.92,10.09 160.03,10.21 160.14,10.32 161.68,11.85 166.78,11.85 171.01,7.62 182.79,7.62 185.7,10.53 195.63,10.53 196.99,11.89 198.98,11.89 201.25,14.16 210.29,14.16 212.78,11.66 220.06,11.66 v2(220.89,10.84)
  BOTTOM w0.114: v2(18.04,13.2) 18.13,13.29 18.13,14.33 18.13,14.51 19.05,15.42 21.28,15.42 21.46,15.42 21.91,14.97 21.91,14.82 21.92,14.81 21.92,14.35 PD101.2 21.15,13.8 20.81,14.14 20.66,14.14 20.48,13.96 20.48,13.38 20.74,13.12 21.4,13.12 21.55,12.97 22.62,12.97 23.02,12.56 23.76,12.56 23.96,12.77 23.96,12.89 PR108.2 ; RE44.1 222.83,26.52 221.99,26.52 v2(221.55,26.96) 221.75,27.17 221.75,27.3 221.65,27.4 221.32,27.4 221.04,27.12 221.04,25.11 220.38,24.45 220.38,22.65 221,22.02 221,16.77 220.74,16.5 220.74,14.72 220.94,14.52 220.94,12.1 220.74,11.9 220.74,10.98 v2(220.89,10.84) ; v2(33.12,42.94) 32.95,42.77 32.95,42.56 PR328.2
PBAT_CHG_SMBDAT: length 310.5
  TOP w0.114: v2(222.18,26.96) 221.78,27.37 221.14,27.37 221.11,27.34 UE1.8
  IN1 w0.094: v2(32.53,42.94) 32.53,42.29 32.43,42.19 22.54,42.19 21.96,42.78 13.15,42.78 10.93,40.55 10.93,36.77 10.4,36.24 10.4,20.97 16.91,14.46 16.91,13.36 16.91,13.36 16.91,12.99 17.43,12.47 18.28,12.47 18.56,12.75 18.56,13.08 v2(18.68,13.2) 18.3,13.58 18.3,13.68 18.6,13.99 20.3,13.99 27.16,7.13 82.02,7.13 88.23,13.35 98.72,13.35 98.91,13.15 103.01,13.15 103.99,14.14 113.94,14.14 118.18,9.9 160,9.9 160.23,10.13 160.34,10.24 160.34,10.24 161.76,11.66 166.67,11.66 170.9,7.42 182.87,7.42 185.78,10.34 197.77,10.34 201.39,13.96 210.14,13.96 212.68,11.42 219.72,11.42 v2(220.3,10.84)
  BOTTOM w0.114: RE43.1 222.64,26.74 222.41,26.74 v2(222.18,26.96) 221.97,27.18 221.97,27.38 221.73,27.63 221.24,27.63 221.23,27.61 220.83,27.21 220.81,27.19 220.81,25.24 220.15,24.58 220.15,22.55 220.79,21.92 220.79,16.86 220.52,16.59 220.52,14.63 220.72,14.43 220.72,12.19 220.52,11.99 220.52,11.06 v2(220.3,10.84) ; PR327.2 32.73,42.56 32.73,42.75 v2(32.53,42.94) ; PR109.2 24.18,13.13 24.18,12.68 23.85,12.35 23.11,12.35 23.11,12.35 22.93,12.35 22.53,12.75 21.64,12.75 21.46,12.75 21.31,12.9 20.65,12.9 20.39,13.16 20.27,13.29 20.27,13.47 20.27,14.13 20.51,14.37 20.93,14.37 PD101.3 21.15,14.28 21.27,14.17 21.43,14.17 21.7,14.44 21.7,14.88 21.37,15.2 19.14,15.2 18.35,14.42 18.35,13.53 v2(18.68,13.2)
PBAT_PRES#: length 338.4
  TOP w0.114: v2(244.31,21.94) 244.54,22.17 244.54,22.97 243.78,23.74 243.78,25.73 242.57,26.94 242.57,27.55 242.97,27.94 242.97,28.58 241.4,30.15 v4(241.4,30.83) 241.4,31.59 240.24,32.74 240.24,33.07 238.85,34.46 CE76.1 235.48,33.96 235.48,33.85 234.25,32.62 UE1.97
  IN1 w0.094: v2(244.31,21.94) 243.6,21.94 242.49,20.83 240.44,20.83 239.49,19.88 235.67,19.88 234.15,18.36 233.48,18.36 231.16,16.04 222.75,16.04 222.36,16.42 221.2,16.42 220.74,16.88 217.46,16.88 215.2,14.62 201.15,14.62 198.81,12.28 196.83,12.28 195.47,10.92 185.47,10.92 182.56,8.01 171.18,8.01 166.94,12.24 161.51,12.24 159.75,10.48 151.82,10.48 118.43,10.48 114.19,14.72 88.55,14.72 81.58,7.75 27.99,7.75 v2(25.18,10.56) 25.18,11.79 20.42,16.55 18.82,16.55 12,23.37 12,35.33 17.76,41.09 34.76,41.09 v2(36.56,42.89)
  IN3 w0.127: v2(36.56,42.89) 36.59,42.87 37.42,42.87 39.43,44.87 44.55,44.87 48.02,41.4 v2(48.83,41.4)
  BOTTOM w0.114: PD102.3 PD102.2 25.33,14.59 PR112.1 PR111.2 25.33,10.71 v2(25.18,10.56) ; PC203.1 PR208.2 49.86,41.28 48.96,41.28 v2(48.83,41.4) ; PR321.2 36.31,42.59 36.31,42.64 v2(36.56,42.89)
PCH_BATLOW#: length 7.9
  BOTTOM w0.076: 173.21,21.02 173.15,21.08 173.15,22.17 173.16,22.17 UH2.BD13
  BOTTOM w0.102: 173.21,21.02 173.21,19.85 172.67,19.31 172.67,18.46
  BOTTOM w0.114: RH81.1 170.53,16.48 170.53,16.59 171.36,17.41 171.99,17.41 v3(172.49,17.92) 172.67,18.09 172.67,18.46
PCH_CPU_BCLK_N: length 108.7
  IN4 w0.094: v2(135.79,96.07) 135.89,95.96 136.31,95.96 136.57,95.7 136.57,95.32 136.42,95.16 136.42,93.96 139.4,90.98 142.23,90.98 150.52,82.69 150.52,80.47 150.52,79.49 150.52,79.48 150.52,77.82 151.6,76.75 153.19,76.75 154.24,75.71 155,75.71 156.8,73.91 157.15,73.91 157.99,73.07 165.61,73.07 165.82,72.87 166.92,72.87 167.99,71.8 168.83,71.8 170.59,70.03 170.59,63.75 174.3,60.04 175.23,60.04 178.71,56.57 178.71,54.8 179.87,53.64 182.18,53.64 188.63,47.19 188.63,44.12 189.06,43.69 189.4,43.69 189.68,43.4 189.68,43.15 v2(189.86,42.97)
  BOTTOM w0.076: UH1.A32 128.12,96.61 128.02,96.71 128.02,96.83 128.11,96.92 128.34,96.92 128.53,96.73 128.53,96.68 128.64,96.57 130.25,96.57 130.64,96.18 130.68,96.18 130.69,96.17
  BOTTOM w0.114: UH2.H2 178.44,40.23 178.55,40.23 178.58,40.2 179.55,40.2 180.84,41.49 182.33,41.49 182.75,41.06 187.24,41.06 187.34,41.16 187.51,41.16 188.61,42.26 189.36,42.26 189.7,42.6 189.7,42.82 v2(189.86,42.97) ; v2(135.79,96.07) 135.58,95.86 131,95.86 130.69,96.17
PCH_CPU_BCLK_P: length 108.7
  IN4 w0.094: v2(189.11,42.97) 189.32,42.97 189.5,43.14 189.5,43.32 189.32,43.5 188.99,43.5 188.44,44.04 188.44,47.11 182.11,53.45 179.79,53.45 178.52,54.73 178.52,56.49 175.16,59.86 174.22,59.86 170.41,63.67 170.41,69.95 168.75,71.61 167.91,71.61 166.85,72.68 165.74,72.68 165.53,72.89 157.91,72.89 157.08,73.73 156.72,73.73 154.93,75.52 154.16,75.52 154.11,75.57 153.12,76.56 151.52,76.56 150.34,77.75 150.34,79.44 150.34,79.44 150.34,80.55 150.34,82.61 142.15,90.8 139.32,90.8 136.24,93.88 136.24,95.24 136.39,95.39 136.39,95.62 136.24,95.77 136.08,95.77 v2(135.79,95.48)
  BOTTOM w0.076: UH1.B31 127.71,96.31 128.44,96.31 128.53,96.4 130.18,96.4 130.52,96.06 130.52,96.02 130.53,96.01
  BOTTOM w0.114: v2(189.11,42.97) 189.31,42.97 189.48,42.8 189.48,42.7 189.26,42.48 188.52,42.48 187.42,41.38 187.25,41.38 187.15,41.28 182.85,41.28 182.42,41.71 180.74,41.71 179.46,40.43 178.67,40.43 178.36,40.74 UH2.G2 ; 130.53,96.01 130.9,95.64 135.63,95.64 v2(135.79,95.48)
PCH_CPU_PCIBCLK_N: length 116.1
  IN4 w0.094: v2(189.77,41.32) 189.61,41.48 189.61,41.94 189.04,42.52 188.3,42.52 188.05,42.78 188.05,46.95 184.1,50.9 181.62,50.9 178.05,54.47 178.05,54.72 176.62,56.14 176.62,57.79 174.96,59.46 174.05,59.46 170.01,63.5 170.01,69.77 168.61,71.16 167.79,71.16 166.67,72.28 165.58,72.28 165.37,72.49 157.75,72.49 157.49,72.74 156.02,72.74 155.59,73.17 155.59,73.51 152.96,76.14 151.38,76.14 149.94,77.58 149.94,79.35 149.94,79.35 149.94,80.02 139.99,89.96 138.22,89.96 134.33,93.85 134.33,100.22 132.65,101.9 129.19,101.9 v2(126.08,98.79)
  BOTTOM w0.076: v2(126.08,98.79) 126.09,98.81 126.75,98.81 UH1.C36
  BOTTOM w0.114: v2(189.77,41.32) 189.57,41.11 189.57,40.91 189.1,40.44 187.64,40.44 187.53,40.34 182.56,40.34 182.04,40.86 180.92,40.86 179.75,39.7 179.34,39.7 179.08,39.44 178.92,39.44 178.81,39.55 UH2.J1
PCH_CPU_PCIBCLK_P: length 116.1
  IN4 w0.094: v2(189.14,41.32) 189.22,41.32 189.43,41.52 189.43,41.87 188.96,42.33 188.23,42.33 187.86,42.7 187.86,46.87 184.02,50.71 181.54,50.71 177.86,54.4 177.86,54.64 176.44,56.06 176.44,57.72 174.88,59.27 173.98,59.27 169.82,63.43 169.82,69.69 168.54,70.98 167.71,70.98 166.59,72.09 165.5,72.09 165.29,72.3 157.67,72.3 157.42,72.56 155.94,72.56 155.41,73.1 155.41,73.43 152.89,75.95 151.3,75.95 149.75,77.51 149.75,79.3 149.75,79.3 149.75,79.94 139.91,89.78 138.14,89.78 134.15,93.77 134.15,100.14 132.57,101.72 129.27,101.72 126.5,98.95 126.5,98.7 v2(126.83,98.37)
  BOTTOM w0.076: UH1.D35 126.35,98.52 126.47,98.63 126.57,98.63 v2(126.83,98.37)
  BOTTOM w0.114: v2(189.14,41.32) 189.35,41.11 189.35,41 189.01,40.67 187.54,40.67 187.44,40.56 182.65,40.56 182.13,41.09 180.83,41.09 179.66,39.92 178.67,39.92 178.47,39.72 UH2.J2
PCH_DPWROK: length 6.6
  TOP w0.114: v2(174.58,25.66) 174.85,25.92 175.91,25.92 v4(177.02,27.03) 177.61,26.45 RH13.2 178.5,26.79 RH9.2
  BOTTOM w0.089: v2(174.58,25.66) 174.33,25.41 UH2.AV11
PCH_JTAG_TCK: length 16.4
  TOP w0.114: v4(181.45,27.4) 181.11,27.74 v2(180.88,27.74)
  BOTTOM w0.076: UH2.AN3 178.14,27.77 178.27,27.64 179.08,27.64 179.36,27.92 180.7,27.92 v2(180.88,27.74) 181.15,27.74 182.38,28.97 182.85,28.97
  BOTTOM w0.102: 182.85,28.97 184.22,30.34
  BOTTOM w0.114: 184.22,30.34 185.56,31.68 186.43,31.68 188.72,33.96 189.38,33.96 RH95.2
PCH_JTAG_TDI: length 192.6
  TOP w0.114: RH118.1 81.75,96.76 v2(81.11,97.4) ; RH100.2 182.12,32.15 182.12,31.72 182.05,31.65 v4(182.05,31.35) 182.05,28.93 182.74,28.25 v2(182.74,28.08)
  IN1 w0.094: v2(182.74,28.08) 182.23,28.08 181.21,27.07 179.25,27.07 178.53,27.78 175.85,27.78 175.78,27.86 171.16,27.86 170.92,27.62 168.23,27.62 167.46,28.39 167.46,28.98 166.93,29.52 165.31,29.52 164.74,30.09 164.74,30.95 163.12,32.57 158.35,32.57 157.21,33.71 154.76,33.71 153.51,34.95 152.89,34.95 141.37,46.47 141.37,61.91 143.93,64.48 143.93,66.63 145.64,68.34 145.64,69.84 147.13,71.33 147.13,72.84 146.2,73.77 145.63,73.77 145.17,74.23 145.17,74.93 144.78,75.33 144.78,79.61 v2(145.18,80.01)
  IN3 w0.127: v2(145.18,80.01) 145.18,82.26 144.77,82.67 143.8,82.67 142.12,84.34 142.12,84.53 142.12,84.53 142.12,97.67 132.41,107.38 90.12,107.38 81.11,98.37 v2(81.11,97.4)
  BOTTOM w0.076: UH2.AP2 178.45,27.21 178.74,26.91 180.86,26.91 182.03,28.08 v2(182.74,28.08)
PCH_JTAG_TDO: length 191
  TOP w0.114: RH115.1 84.65,94.35 v2(83.68,94.35) ; RH97.2 182.69,33.31 v2(182.74,33.26) 182.92,33.08 182.92,31.7 182.55,31.33 v4(182.55,29.47) 182.55,29.13 v2(183.22,28.46)
  IN3 w0.127: v2(83.68,94.35) 83.68,97.12 84.59,98.03 85.82,98.03 86.28,98.5 86.28,100.77 89.84,104.33 104.62,104.33 105.72,105.43 131.08,105.43 140.12,96.39 140.12,83.14 144.68,78.58 144.68,77.16 144.07,76.55 144.07,74.35 144.42,74 144.42,68.74 140.99,65.31 140.99,47.05 143.67,44.38 148.98,44.38 151.04,46.44 170.37,46.44 171.19,47.27 177.03,47.27 178.8,45.49 178.8,43.94 185.62,37.11 185.62,35.51 185.49,35.38 185.18,35.07 184.92,35.07 184.25,35.07 182.74,33.56 v2(182.74,33.26)
  BOTTOM w0.076: UH2.AP1 178.93,27.09 180.8,27.09 182.17,28.46 v2(183.22,28.46)
PCH_JTAG_TMS: length 10.7
  TOP w0.114: v4(184.48,27.64) 184.29,27.64 183.82,28.11 v2(183.82,28.46) 183.61,28.67 183.61,30.61 RH98.2 RH492.1
  BOTTOM w0.076: UH2.AR2 178.4,26.58 181.24,26.58 181.52,26.86 182.23,26.86 182.56,27.19 182.56,27.37
  BOTTOM w0.102: v2(183.82,28.46) 183.39,28.03 183.22,28.03 182.56,27.37
PCH_JTAGX: length 185.1
  IN1 w0.094: v2(182.03,27.22) 181.65,26.84 178.83,26.84 178.13,27.53 175.67,27.53 175.54,27.66 171.79,27.66 170.92,26.79 170.03,26.79 169.46,27.36 168.2,27.36 167.22,28.35 167.22,28.95 166.89,29.28 165.28,29.28 164.5,30.05 164.5,30.91 163.09,32.32 158.25,32.32 157.11,33.47 154.72,33.47 153.43,34.76 152.81,34.76 141.17,46.39 141.17,62.06 143.71,64.6 143.71,66.72 145.43,68.43 145.43,69.9 146.94,71.41 146.94,72.76 146.12,73.57 145.55,73.57 144.6,74.53 144.6,75.1 144.05,75.64 144.05,79.78 v2(144.68,80.41)
  IN3 w0.127: v2(83.72,92.16) 83.58,92.16 83.08,92.66 83.08,99.37 90.41,106.7 132.12,106.7 141.39,97.43 141.39,83.7 v2(144.68,80.41)
  BOTTOM w0.076: UH2.AR3 178.01,26.59 178.25,26.83 178.55,26.83 178.62,26.75 181.02,26.75 181.47,27.19 v3(181.53,27.19) 182,27.19 v2(182.03,27.22)
  BOTTOM w0.114: v2(83.72,92.16) 83.75,92.19 RH38.1
PCH_PCIE_WAKE#: length 12.7
  BOTTOM w0.076: 173.39,19.61 173.39,21.19 173.32,21.26 173.32,22.1 173.42,22.2 173.42,22.65 UH2.BC13
  BOTTOM w0.102: 173.39,19.61 v3(173.11,19.33) 172.97,19.19 172.97,18.43
  BOTTOM w0.114: RH114.1 173.49,13.33 172.6,14.21 171.84,14.21 171.59,14.47 171.59,15.81 RH17.1 171.96,17.2 172.26,17.2 172.97,17.91 172.97,18.43
PCH_PLTRST#: length 12
  BOTTOM w0.114: RH1.1 168.19,15.15 167.6,15.15 167.24,15.52 167.24,15.83 UH7.2 166.98,15.77 166.98,15.68 166.84,15.53 166.68,15.53 166.49,15.73 UH7.1 166.49,16.6 v3(166.8,16.91) 167.47,17.58 167.47,18.96 166.61,19.83 166.61,22.44 166.58,22.47 166.58,23.04 166.23,23.4 UH2.BB27
PCH_PLTRST#_EC: length 268.4
  TOP w0.114: UE1.56 231.05,16.95 230.72,17.29 230.72,17.66 230.36,18.01 229.32,18.01 228.71,18.62 v2(228.71,19.24) ; v2(197.46,26.74) 197.46,25.52 v4(197.79,25.19) 198.48,24.51 198.48,22.97 197.93,22.42 197.24,22.42 195.69,20.87 v2(195.69,20.56)
  IN1 w0.094: v2(228.71,19.24) 228.15,19.8 225.93,19.8 225.49,20.24 223.03,20.24 222.59,19.8 217.31,19.8 216.85,20.25 213.36,20.25 v2(212.86,20.75)
  IN3 w0.127: v2(287.36,41.32) 287.36,41.19 286.93,40.76 275.7,40.76 274.36,39.41 265.47,39.41 264.35,38.29 264.35,34.36 263.43,33.44 260.84,33.44 258.36,30.96 258.36,27.85 257.28,26.76 249.65,26.76 246.09,23.21 245.53,23.21 v2(245.37,23.36) ; v2(152.49,28.46) 152.89,28.06 153.67,28.06 154.22,27.51 154.22,24.93 155.58,23.57 156.79,23.57 158.31,22.05 159.95,22.05 164.48,17.52 168.91,17.52 169.68,16.75 v2(169.68,14.55) 170.6,13.63 179.17,13.63 183.6,18.06 187.32,18.06 188.48,19.22 195.39,19.22 195.69,19.52 v2(195.69,20.56) 196.75,21.62 212.05,21.62 212.86,20.81 v2(212.86,20.75)
  IN4 w0.094: v2(245.37,23.36) 244.13,23.36 243.33,22.56 238.41,22.56 238.03,22.19 236.86,22.19 236.41,21.73 235.9,21.73 234.15,19.98 229.44,19.98 v2(228.71,19.24)
  BOTTOM w0.114: v2(169.68,14.55) 169.68,14.54 169.68,13.53 RH77.1 168.89,13.52 168.79,13.62 RH1.2 168.4,14.03 UH7.4 ; UL1.19 286.61,42.2 287.36,41.46 v2(287.36,41.32) ; CE72.1 227.34,16.53 228.08,17.26 228.08,18.61 v2(228.71,19.24) ; JNGFF2.50 213.72,24.58 212.86,23.72 v2(212.86,20.75) ; v2(197.46,26.74) 197.46,28.01 197.06,28.42 JNGFF1.44 ; v2(245.37,23.36) 243.85,24.88 243.85,27.82 243.52,28.14 JLPDE1.8 ; v2(152.49,28.46) 151.66,29.29 149.29,29.29 148.6,29.97 143.49,29.97 142.95,30.52 142.95,32.9 144.36,34.31 144.36,42.9 141.36,45.91 141.36,52.31 140.47,53.19 140.47,64.13 135.65,68.95 135.65,72.79 137.88,75.02 138.85,75.02 139.62,75.78 142.58,75.78 142.91,76.11 142.91,76.67 142.63,76.95 UV14.2
PCH_PWROK: length 17.8
  TOP w0.114: v2(174.63,25.06) 174.34,25.06 v4(174.05,25.35) ; v2(187.04,25.77) 187.22,25.95 RH102.2 RH94.1 188.29,25.07 188.4,25.19 UH14.4
  IN4 w0.094: v2(174.63,25.06) 174.89,25.31 175.8,25.31 176.96,24.16 178.23,24.16 178.76,24.7 180.6,24.7 180.88,24.98 184.38,24.98 185.16,25.77 v2(187.04,25.77)
  BOTTOM w0.089: UH2.AW11 174.17,24.64 174.59,25.06 v2(174.63,25.06)
PCH_RSMRST#: length 84.4
  TOP w0.114: v2(179.15,12.55) 179.15,15.55 v4(180.05,16.46) 180.35,16.75 RH503.1 180.53,18.33 180.83,18.63 180.83,19.77 181.63,20.56 181.63,21.24 181.91,21.53 181.91,25.45 180.58,26.79 RH9.1 ; v2(237.65,25.26) 237.74,25.35 237.74,26.69 237.41,27.02 237.02,27.02 236.94,26.94 UE1.88
  IN3 w0.127: v2(237.65,25.26) 236.46,25.26 236.04,25.69 232.27,25.69 229.96,23.37 225.47,23.37 224.98,22.89 224.11,22.89 222.26,21.05 216.88,21.05 216.11,20.28 214.44,20.28 212.82,18.66 197.27,18.66 195.06,16.45 183.35,16.45 179.45,12.55 v2(179.15,12.55)
PCH_RSMRST#_R: length 11.4
  TOP w0.114: v2(174.63,24.48) 175.03,24.08 175.03,23.5 175.17,23.36 175.17,23.08 v3(175.6,22.66) 175.89,22.37 175.89,21.23 176.12,21 176.57,21 176.9,20.67 179.2,20.67 179.58,20.3 179.58,19.87 RH88.2 RH503.2
  BOTTOM w0.089: UH2.BA11 174.07,23.91 v2(174.63,24.48)
PCH_RTCRST#: length 20.1
  TOP w0.114: RH84.2 CH53.1 ; CH53.1 173.52,19.75 173.23,19.46 173.23,18.27 173.47,18.02 177.38,18.02 178.01,17.39 v4(178.01,14.8) 178.01,12.99 v2(177.6,12.58) 177.18,12.16 JAPS.9 ; CH53.1 174.51,20.21 174.21,20.5 v2(174.21,20.54)
  BOTTOM w0.076: v2(174.21,20.54) 174.2,20.55 174.2,21.14 174.2,22.24 174.2,22.25 174.2,22.74 UH2.BC10
  BOTTOM w0.114: v2(177.6,12.58) 177.6,12.87 176.77,13.7 CLRP1.1
PCH_RTCX1: length 7.6
  BOTTOM w0.076: 174.94,20.78 174.56,21.16 174.56,22.1 174.68,22.22 174.68,22.84 UH2.BC9
  BOTTOM w0.127: 174.94,20.78 v3(174.94,20.04) 174.94,19.57 RH70.1 175.48,19.03 CH45.1 175.48,17.43 176.27,16.65 YH1.1
PCH_RTCX2: length 6.5
  BOTTOM w0.076: UH2.BD10 174.39,22.33 174.39,21.06 174.61,20.84
  BOTTOM w0.089: 174.61,20.84 174.61,20.31
  BOTTOM w0.127: 174.61,20.31 174.56,20.26 RH70.2 174.56,18.13 CH46.1 174.62,17.67 173.77,16.82 173.77,16.37
PCH_SATA_LED#: length 122.8
  TOP w0.114: RH80.1 v2(151.9,30.47) ; QE21.2 255.63,27.82 255.15,27.35 255.15,26.96 254.31,26.13 v2(254.31,26.05) 254.31,25.67 254.72,25.26 RH502.2
  IN4 w0.094: v2(254.31,26.05) 253.37,25.1 250.33,25.1 245.95,29.49 241.98,29.49 241.98,29.49 241.52,29.49 241.07,29.03 236.24,29.03 234.76,27.56 232.91,27.56 232.88,27.54 229.97,27.54 229.78,27.72 229.41,27.72 223.96,27.72 223.48,27.24 222.76,27.24 222.29,27.71 221.21,27.71 221.14,27.78 218.47,27.78 217.56,28.69 216.47,28.69 214.11,31.05 205.5,31.05 204.56,31.99 199.04,31.99 196.8,34.24 187.83,34.24 187.59,34 181.21,34 179.6,32.39 177.42,32.39 177.33,32.3 176.12,32.3 176.02,32.2 175.69,32.2 175.61,32.27 171.69,32.27 171.36,31.95 163.96,31.95 163.57,32.34 157.25,32.34 157.06,32.15 155.21,32.15 153.97,30.91 152.35,30.91 v2(151.9,30.47)
  BOTTOM w0.114: UH2.AD44 157.46,32.05 156.78,32.05 156.59,31.87 155.94,31.87 155.76,32.05 154.3,32.05 v3(153.47,31.23) 152.71,30.47 v2(151.9,30.47)
PCH_SMBCLK: length 42.4
  TOP w0.114: RH27.2 153.4,21.37 QH4.1 152.13,21.37 v2(151.66,21.85)
  IN1 w0.094: v2(151.66,21.85) 149.74,21.85 148.66,22.93 141.45,22.93 140.93,23.46 v2(140.93,23.78) 140.93,24.74 140.73,24.94 140.73,31.37 141.26,31.89 141.28,31.89 141.28,31.89 v2(141.34,31.89)
  BOTTOM w0.114: JDIMM1.253 135.65,40.2 136.54,39.32 136.54,36.69 v2(141.34,31.89) ; JDIMM2.253 135.66,26.54 137.16,25.03 140.61,25.03 140.93,24.72 v2(140.93,23.78)
PCH_SMBDATA: length 34.1
  TOP w0.114: QH4.4 150.37,22.47 149.69,22.47 RH26.2 149.44,23.15 v2(149.23,23.36) ; v2(141.53,23.78) 141.21,23.46 v3(141.21,23.29)
  IN1 w0.094: v2(141.34,31.27) 141.34,25.19 141.53,24.99 v2(141.53,23.78) 141.77,23.54 149.06,23.54 v2(149.23,23.36)
  BOTTOM w0.114: v2(141.34,31.27) 141,31.27 138.43,33.85 136.1,33.85 135.9,33.65 JDIMM1.254 ; JDIMM2.254 135.91,22.29 136.8,23.18 140.93,23.18 v2(141.53,23.78)
PCH_SPI_CLK: length 4.9
  BOTTOM w0.076: UH2.BC31 164.06,22.79 164.29,22.56 164.29,22.26 164.21,22.17 164.21,20.96 163.94,20.69
  BOTTOM w0.102: 163.94,20.69 163.94,20.46 v3(163.24,19.76) 162.87,19.4 162.72,19.4 RH507.1
PCH_SPI_CLK_R: length 2.7
  BOTTOM w0.114: RE126.2 172.62,8.37 v3(173.14,8.9) 173.25,9.01 UH8.6
PCH_SPI_CS#: length 10.3
  BOTTOM w0.076: UH2.BD31 164.02,22.37 164.02,21.23 163.13,20.34 162.6,20.34 162.33,20.07
  BOTTOM w0.114: v3(161.67,13.6) RH101.1 RH74.2 161.91,15.81 161.91,16.59 161.68,16.82 161.68,19.42 162.33,20.07
PCH_SPI_HOLD#: length 6.5
  BOTTOM w0.076: v3(163.64,16.8) 163.64,18.43 RH104.1 163.2,19.23 164.37,20.39 164.37,22.04 164.68,22.35 UH2.BD30
PCH_SPI_HOLD#_R: length 2.8
  BOTTOM w0.114: RE71.2 172.55,10.28 v3(173.14,10.28) UH8.7
PCH_SPI_SI: length 4.8
  BOTTOM w0.076: UH2.BB29 165.22,23.23 164.91,22.93 164.91,21.86 164.7,21.65 164.7,20.58 164.87,20.41 164.87,19.45 164.98,19.33 RH509.1
PCH_SPI_SI_R: length 2.6
  BOTTOM w0.114: UH8.5 173.4,7.74 v3(173.16,7.5) 173.02,7.36 RE128.2
PCH_SPI_SO: length 3.4
  BOTTOM w0.076: UH2.BE30 164.54,21.84 164.54,19.8 v3(164.53,19.8) 164.09,19.36 RH508.1
PCH_SPI_SO_R: length 6
  TOP w0.114: v3(181.08,13.21) 181.08,13.16 v2(183.19,11.06)
  BOTTOM w0.114: RE127.2 183.27,11.14 v2(183.19,11.06) 183.19,10.65 182.81,10.28 UH8.2
PCH_SPI_WP#: length 5.7
  BOTTOM w0.076: v3(166.79,18.44) 166.37,18.86 RH510.1 165.03,19.7 165.03,20.5 164.87,20.67 164.87,21.57 165.09,21.79 165.09,22.51 165.24,22.66 UH2.BC29
PCH_SPI_WP#_R: length 3
  BOTTOM w0.114: RE129.2 v3(183.39,9.25) 183.14,9.01 UH8.3
PCH_SRTCRST#: length 6.2
  TOP w0.114: v2(174.62,23.88) 174.5,23.76 174.5,23.06 CH52.1 175.39,22.17 175.39,21.03 175.75,20.67 176.26,20.67 RH83.2
  BOTTOM w0.089: v2(174.62,23.88) 174.31,23.57 UH2.BB10
PCH_TRIGGER: length 116.8
  TOP w0.114: RH167.1 135,93.73 v2(135.77,93.73) 136.37,93.73 v3(136.51,93.59)
  IN3 w0.127: v2(181.06,29.18) 180.49,29.18 178.74,30.93 178.74,31.83 179.22,32.32 179.43,32.32 183.27,36.16 183.27,36.65 180.68,39.25 180.6,39.25 178.65,41.2 178.65,41.28 176.75,43.17 161.58,43.17 161.2,43.55 161.2,44.69 160.69,45.2 157.2,45.2 155.23,43.23 143.19,43.23 139.85,46.58 139.85,66.35 142.98,69.48 142.98,72.32 141.6,73.7 141.6,76.74 135.77,82.57 v2(135.77,93.73)
  BOTTOM w0.076: v2(181.06,29.18) 180.72,29.18 180.3,28.76 178.6,28.76 178.5,28.86 UH2.AL2
PCH_TRIGGER_R: length 13.5
  TOP w0.114: v2(132.55,92.01) 132.57,91.99 133.05,91.99 v3(133.42,92.36) 133.89,92.83 RH167.2
  IN1 w0.094: v2(132.55,92.01) 132.55,90.44 131.99,89.88 124.4,89.88 v2(123.98,89.47)
  BOTTOM w0.076: v2(123.98,89.47) 123.61,89.84 UH1.H23
PCIE_PRX_LANTX_N3_C: length 2.4
  BOTTOM w0.114: UL1.18 287.01,42.29 287.89,41.41 287.89,40.93 CL31.2
PCIE_PRX_LANTX_N5: length 135.8
  IN1 w0.094: v2(287.74,38.85) 287.97,38.85 288.1,38.73 288.1,38.51 287.94,38.35 286.94,38.35 285.4,39.89 281.79,39.89 279.38,37.48 275.73,37.48 275.17,36.92 274.14,36.92 272.48,35.26 271.28,35.26 270.61,34.6 270.61,33.41 269.5,32.3 266.28,32.3 263.48,29.5 263.48,29.44 263.09,29.05 253.49,29.05 253.24,29.3 235.28,29.3 234.8,28.82 230.94,28.82 230.61,29.15 218.04,29.15 217.69,28.79 213.6,28.79 213.01,29.39 209.6,29.39 208.14,30.85 205.51,30.85 204.38,31.98 199.32,31.98 196.25,28.92 189.33,28.92 187.8,30.45 187.8,32.13 186.03,33.9 182.34,33.9 180.74,35.5 178.8,35.5 178.49,35.8 174.26,35.8 173.84,36.22 173.84,37.62 172.94,38.53 172.17,38.53 171.16,39.55 170.61,39.55 v2(170.32,39.84)
  BOTTOM w0.102: v2(170.32,39.84) 170.16,39.84 UH2.K19
  BOTTOM w0.114: v2(287.74,38.85) 288.05,39.16 288.05,39.41 CL31.1
PCIE_PRX_LANTX_P3_C: length 2.4
  BOTTOM w0.114: UL1.17 287.41,42.2 288.12,41.5 288.12,41.14 CL30.2
PCIE_PRX_LANTX_P5: length 135.8
  IN1 w0.094: v2(288.5,38.85) 288.28,38.63 288.28,38.44 288.01,38.17 286.87,38.17 285.33,39.71 281.87,39.71 279.46,37.3 275.8,37.3 275.25,36.74 274.22,36.74 272.55,35.08 271.36,35.08 270.8,34.52 270.8,33.34 269.58,32.12 266.36,32.12 263.67,29.43 263.67,29.36 263.17,28.86 253.42,28.86 253.16,29.12 235.36,29.12 234.88,28.64 230.86,28.64 230.54,28.96 218.12,28.96 217.76,28.61 213.52,28.61 212.93,29.2 209.53,29.2 208.06,30.67 205.43,30.67 204.3,31.79 199.39,31.79 196.33,28.73 189.25,28.73 187.61,30.37 187.61,32.05 185.95,33.71 182.27,33.71 180.66,35.31 178.72,35.31 178.41,35.62 174.19,35.62 173.66,36.15 173.66,37.55 172.86,38.34 172.09,38.34 171.08,39.36 170.47,39.36 v2(170.32,39.21)
  BOTTOM w0.102: UH2.L19 169.77,38.71 170.27,39.21 v2(170.32,39.21)
  BOTTOM w0.114: v2(288.5,38.85) 288.27,39.08 288.27,39.51 CL30.1
PCIE_PRX_SSDTX_N10: length 61.6
  IN1 w0.094: v2(164.49,40.61) 164.49,40.65 164.75,40.91 164.93,40.91 165.08,40.76 165.08,38.14 165.49,37.73 166.56,37.73 166.78,37.95 170.61,37.95 170.77,37.79 170.77,36.61 172.95,34.43 177.95,34.43 178.28,34.1 178.28,33.7 178.7,33.28 178.7,32.71 179.11,32.29 180.63,32.29 180.98,31.94 180.98,31.42 182.23,30.17 186.16,30.17 188.94,27.39 189.79,27.39 190.33,26.85 196.06,26.85 198.41,29.2 204.03,29.2 205.04,28.18 207.71,28.18 208.36,27.53 210.36,27.53 210.58,27.74 v2(210.83,27.74)
  BOTTOM w0.102: v2(164.49,40.61) 164.86,40.98 UH2.G29
  BOTTOM w0.114: v2(210.83,27.74) 210.83,28.39 210.04,29.18 210.04,29.33 209.69,29.68 209.52,29.68 209.37,29.83 JNGFF2.29
PCIE_PRX_SSDTX_N11: length 54
  IN4 w0.094: v2(206.47,32.88) 206.43,32.83 203.88,32.83 201.22,35.49 187.07,35.49 186.85,35.27 181.92,35.27 180.03,37.16 179.57,37.16 179.51,37.23 178.5,37.23 177.71,38.01 176.13,38.01 172.15,42 163.89,42 162.8,40.91 162.8,39.54 162.7,39.44 162.7,38.95 163,38.64 163.17,38.64 v2(163.4,38.41)
  BOTTOM w0.089: UH2.L31 163.65,38.66 v2(163.4,38.41)
  BOTTOM w0.114: v2(206.47,32.88) 206.72,32.64 207.7,32.64 207.88,32.83 JNGFF2.17
PCIE_PRX_SSDTX_N12: length 58
  IN4 w0.094: v2(162.4,40.55) 162.4,40.36 162.21,40.17 162.08,40.17 161.82,40.44 161.82,41.44 162.11,41.74 162.77,41.74 164.03,43 171.92,43 175.17,39.76 178.74,39.76 180.36,38.14 180.6,38.14 181.59,37.14 185.01,37.14 186.22,35.93 194,35.93 196.36,38.28 203.83,38.28 204.28,38.73 204.28,39.06 204.46,39.24 v2(204.59,39.24)
  BOTTOM w0.089: UH2.G33 162.58,40.79 162.4,40.61 v2(162.4,40.55)
  BOTTOM w0.114: v2(204.59,39.24) 204.48,39.24 204.12,38.87 204.12,38.67 204.58,38.21 204.79,38.21 205.9,37.1 205.9,35.76 206.11,35.55 207.53,35.55 207.81,35.83 JNGFF2.5
PCIE_PRX_SSDTX_P10: length 61.6
  IN1 w0.094: v2(164.47,41.27) 164.65,41.09 165.01,41.09 165.27,40.83 165.27,38.22 165.57,37.92 166.48,37.92 166.7,38.14 170.69,38.14 170.96,37.87 170.96,36.69 173.03,34.62 178.02,34.62 178.47,34.17 178.47,33.77 178.88,33.36 178.88,32.78 179.19,32.48 180.71,32.48 181.16,32.02 181.16,31.5 182.31,30.36 186.24,30.36 189.02,27.57 189.86,27.57 190.4,27.04 195.98,27.04 198.33,29.38 204.11,29.38 205.12,28.37 207.78,28.37 208.44,27.71 210.29,27.71 210.4,27.82 210.4,28 210.24,28.16 v2(210.1,28.16)
  BOTTOM w0.102: UH2.E29 164.95,41.74 v2(164.47,41.27)
  BOTTOM w0.114: v2(210.1,28.16) 210.1,28.12 210.29,27.93 210.43,27.93 210.61,28.11 210.61,28.3 209.82,29.09 209.82,29.23 209.6,29.45 209.43,29.45 209.3,29.33 JNGFF2.31
PCIE_PRX_SSDTX_P11: length 54
  IN4 w0.094: v2(206.4,32.19) 206.4,32.36 206.11,32.65 203.8,32.65 201.15,35.3 187.14,35.3 186.93,35.08 181.84,35.08 179.95,36.97 179.5,36.97 179.43,37.04 178.42,37.04 177.63,37.83 176.06,37.83 172.07,41.82 163.97,41.82 162.99,40.84 162.99,39.46 162.88,39.36 162.88,39.02 163.08,38.83 163.38,38.83 163.51,38.95 163.51,39.11 163.41,39.21 v2(163.4,39.21)
  BOTTOM w0.089: UH2.K31 163.69,39.21 v2(163.4,39.21)
  BOTTOM w0.114: JNGFF2.19 207.83,32.33 207.74,32.42 206.62,32.42 v2(206.4,32.19)
PCIE_PRX_SSDTX_P12: length 58
  IN4 w0.094: v2(162.37,39.77) 162.16,39.99 162.01,39.99 161.63,40.36 161.63,41.52 162.04,41.93 162.69,41.93 163.95,43.19 172,43.19 175.24,39.94 178.82,39.94 180.44,38.32 180.68,38.32 181.23,37.77 181.67,37.33 185.08,37.33 186.29,36.12 193.93,36.12 196.28,38.47 203.76,38.47 204.1,38.81 204.1,39.03 v2(203.9,39.23)
  BOTTOM w0.089: v2(162.37,39.77) 162.63,40.03 UH2.H33
  BOTTOM w0.114: JNGFF2.7 206.01,35.33 205.67,35.66 205.67,37.01 204.7,37.99 204.49,37.99 203.9,38.58 v2(203.9,39.23)
PCIE_PRX_WLANTX_N6: length 41.3
  IN1 w0.094: v2(169.02,41.34) 168.62,40.94 168.62,39.28 169.13,38.78 170.88,38.78 173.02,36.64 173.02,35.96 173.77,35.2 178.27,35.2 179,34.47 180.68,34.47 182.46,32.69 185.49,32.69 187.11,31.07 187.11,30.31 189.09,28.33 194.83,28.33 195.06,28.1 195.06,27.69 195.2,27.55 v2(195.21,27.55)
  BOTTOM w0.102: UH2.G22 168.67,41.06 168.95,41.34 v2(169.02,41.34)
  BOTTOM w0.114: JNGFF1.35 194.81,22.8 194.66,22.95 194.66,24.6 195.08,25.02 195.08,27.42 v2(195.21,27.55)
PCIE_PRX_WLANTX_P6: length 41.3
  IN1 w0.094: v2(168.31,41.37) 168.44,41.24 168.44,39.21 169.05,38.59 170.81,38.59 172.83,36.57 172.83,36.03 172.83,35.88 173.33,35.39 173.69,35.02 178.19,35.02 178.93,34.28 180.6,34.28 182.38,32.5 185.42,32.5 186.92,31 186.92,30.24 189.01,28.15 194.75,28.15 194.87,28.03 194.87,27.85 v2(194.57,27.55)
  BOTTOM w0.102: UH2.E22 168.63,41.74 168.31,41.42 v2(168.31,41.37)
  BOTTOM w0.114: v2(194.57,27.55) 194.86,27.26 194.86,25.12 194.44,24.7 194.44,22.93 194.31,22.8 JNGFF1.33
PCIE_PTX_LANRX_N5: length 136.9
  IN1 w0.094: v2(169.38,44.14) 169.6,44.36 169.76,44.36 169.89,44.49 170.69,44.49 171.41,43.77 173.36,43.77 174.1,43.04 178.39,43.04 178.91,42.52 179.63,42.52 182.6,39.56 183.18,39.56 184.01,38.72 188.17,38.72 189.24,37.65 189.92,37.65 192.44,35.13 201.11,35.13 201.58,34.66 206.3,34.66 208.19,32.77 210.32,32.77 211.72,31.38 211.91,31.38 211.91,31.38 244.47,31.38 244.65,31.2 260.44,31.2 262.82,33.59 263.87,33.59 264.76,34.48 268.68,34.48 268.97,34.78 268.97,35.59 269.36,35.98 269.84,35.98 272.02,38.16 274.51,38.16 274.99,38.64 278.93,38.64 282.92,42.63 287.84,42.63 289.27,44.06 291.07,44.06 v2(291.27,43.86)
  BOTTOM w0.076: UH2.D22 168.55,42.24 168.81,42.89 168.81,43.81 168.98,43.99 168.98,44.12 169.07,44.21 169.3,44.21 v2(169.38,44.14)
  BOTTOM w0.114: v2(291.27,43.86) 291,44.13 290.86,44.13 CL48.1
PCIE_PTX_LANRX_N5_C: length 1.8
  BOTTOM w0.114: UL1.14 288.59,44.09 288.68,44.18 289.24,44.18 CL48.2
PCIE_PTX_LANRX_P5: length 136.9
  IN1 w0.094: v2(291.27,44.62) 290.89,44.24 289.2,44.24 287.77,42.81 282.84,42.81 278.86,38.83 274.91,38.83 274.43,38.34 271.94,38.34 269.77,36.17 269.29,36.17 268.79,35.67 268.79,34.86 268.6,34.67 264.69,34.67 263.79,33.77 262.75,33.77 260.36,31.38 244.73,31.38 244.55,31.56 211.99,31.56 211.99,31.56 211.8,31.56 210.4,32.96 208.26,32.96 206.38,34.85 201.65,34.85 201.18,35.32 192.52,35.32 190,37.84 189.32,37.84 188.25,38.91 184.09,38.91 183.25,39.74 182.67,39.74 179.71,42.71 178.98,42.71 178.47,43.22 174.17,43.22 173.44,43.96 171.49,43.96 170.77,44.68 169.82,44.68 169.68,44.54 169.55,44.54 v2(169.38,44.72)
  BOTTOM w0.076: v2(169.38,44.72) 169.38,44.64 169.11,44.38 169,44.38 168.82,44.19 168.82,44.06 168.64,43.88 168.64,42.92 168.61,42.83 UH2.C22
  BOTTOM w0.114: CL47.1 290.88,44.35 291,44.35 v2(291.27,44.62)
PCIE_PTX_LANRX_P5_C: length 1.7
  BOTTOM w0.114: UL1.13 288.58,44.49 288.66,44.41 289.33,44.41 CL47.2
PCIE_PTX_SSDRX_N10: length 52
  IN1 w0.094: v2(162.72,44.41) 162.27,44.87 162.27,46.35 162.93,47.01 167.45,47.01 167.7,47.26 170.32,47.26 171.63,48.57 178.27,48.57 179.32,49.62 190.21,49.62 198.89,40.93 v2(198.89,40.2)
  BOTTOM w0.076: UH2.C32 163.13,42.76 163.13,43.33 162.94,43.52 162.94,44.2 v2(162.72,44.41)
  BOTTOM w0.114: v2(198.89,40.2) 198.7,40 198.7,39.86 200.97,37.58 200.97,36.24 CD45.1
