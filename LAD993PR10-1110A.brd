# Allegro board LAD993PR10-1110A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+3VS on IN3 (solid shape): outline of 317 points within 8.62,37.61 18.53,42.94
+3VS on IN3 (solid shape): outline of 1347 points within 44.59,31.61 69.99,49.52
+3VS on IN4 (solid shape): 247.99,31.25 247.99,30.47 247.76,30.24 246.37,30.24 244.42,32.19 240.61,32.19 240.32,32.48 240.32,33.16 242.73,33.16 242.73,33.11 242.74,33.06 242.76,33.01 242.78,32.96 242.81,32.91 242.85,32.88 242.89,32.84 242.93,32.82 242.98,32.8 243.03,32.78 243.09,32.78 243.14,32.78 243.19,32.8 243.24,32.82 243.29,32.84 243.33,32.88 243.37,32.91 243.4,32.96 243.42,33.01 243.44,33.06 243.44,33.11 243.44,33.16 243.44,33.22 243.42,33.27 243.4,33.32 243.37,33.36 243.33,33.4 243.29,33.43 243.24,33.46 243.19,33.48 243.14,33.49 243.09,33.49 243.03,33.49 242.98,33.48 242.93,33.46 242.89,33.43 242.85,33.4 242.81,33.36 242.78,33.32 242.76,33.27 242.74,33.22 242.73,33.16 240.32,33.16 240.32,33.54 240.67,33.9 245.34,33.9
+3VS on VCC: outline of 217 points within 188,29.48 219.97,46.95
+3VS on IN4: outline of 390 points within 67.07,28.65 190.5,50.46
+3VS_CAM on BOTTOM (solid shape): 231.49,48.59 231.49,46.58 231,46.08 231,45.09 230.34,44.42 230.34,42.89 230.16,42.72 229.83,42.72 229.68,42.86 229.68,44.82 229.37,45.13 229.37,47.3 229.88,47.81 229.88,48.78 229.97,48.87 231.21,48.87
+3VS_WLAN on TOP (solid shape): 187.02,29.05 187.02,28.56 186.44,27.99 184.39,27.99 184.17,28.21 184.17,29.11 184.27,29.21 186.86,29.21
+3VS_WLAN on TOP (solid shape): outline of 94 points within 194,26.48 202.7,34.03
+3VS_WLAN on IN3 (solid shape): outline of 318 points within 184.29,27.82 195.34,34.25
+5V_AVDD on TOP (solid shape): outline of 119 points within 283.98,17.36 291.39,23.76
+5V_CHGUSB_1 on TOP (solid shape): outline of 260 points within 291.98,25.39 297.09,44.85
+5V_CHGUSB_1 on BOTTOM (solid shape): 295.84,44.69 295.84,42.6 295.67,42.43 292.45,42.43 292.2,42.18 292.2,41.53 292.07,41.4 291.49,41.4 291.26,41.63 291.26,42.79 291.98,43.51 291.98,44.58 292.29,44.88 295.65,44.88
+5V_CHGUSB_1 on IN1 (solid shape): outline of 309 points within 291.65,25.93 297.08,45.02
+5V_CHGUSB_1 on IN2 (solid shape): outline of 424 points within 290.61,25.64 297.06,45.05
+5V_CHGUSB_1 on IN3 (solid shape): outline of 147 points within 290.61,25.64 297.08,31.36
+5V_CHGUSB_1 on IN4 (solid shape): 295.67,44.74 295.67,42.15 295.28,41.77 294.22,41.77 293.71,42.28 293.71,44.77 293.84,44.9 295.51,44.9
+5V_CHGUSB_2 on TOP (solid shape): 297.05,48.21 297.05,46.74 295.46,45.15 294.25,45.15 293.13,46.28 293.13,48.3 293.44,48.62 296.64,48.62
+5V_CHGUSB_2 on TOP (solid shape): 284.02,34.28 285.1,34.28 285.3,34.08 285.3,33.44 284.62,32.76 283.72,32.76 283.72,32.76 283.29,32.76 283.25,32.81 283.24,32.82 283.15,33.02 282.96,33.11 282.94,33.11 282.56,33.49 282.56,34.22 282.66,34.32 283.98,34.32
+5V_CHGUSB_2 on BOTTOM (solid shape): 294.65,48.63 296.34,48.63 297.03,47.94 297.03,46.59 295.56,45.13 293.33,45.13 293.13,45.33 293.13,48.81 293.24,48.93 294.35,48.93
+5V_CHGUSB_2 on IN1 (solid shape): 297.06,48.28 297.06,46.73 295.54,45.2 294.4,45.2 294.24,45.35 294.24,48.19 294.68,48.62 296.72,48.62
+5V_CHGUSB_2 on IN2 (solid shape): outline of 2712 points within 281.62,31.18 297.05,54.22
+5V_CHGUSB_2 on IN3 (solid shape): outline of 652 points within 283.04,31.71 297.06,48.64
+5V_CHGUSB_2 on IN4 (solid shape): 297.06,48.24 297.06,46.44 295.72,45.1 293.74,45.1 293.53,45.3 293.53,48.25 293.88,48.59 296.7,48.59
+5V_PVDD on TOP (solid shape): 294.06,24.97 294.06,23.66 293.93,23.52 292.72,23.52 292.62,23.43 291.78,23.43 290.94,24.27 290.94,24.6 291.5,25.16 293.87,25.16
+5V_PVDD on TOP (solid shape): 281.5,31.35 282.5,31.35 282.69,31.16 282.69,30.66 282.53,30.5 282.23,30.5 282.09,30.65 279.11,30.65 278.83,30.37 278.83,29.73 278.6,29.5 277.12,29.5 276.9,29.73 276.9,31.13 277.12,31.35 281.5,31.35
+5V_PVDD on BOTTOM (solid shape): 278.8,31.05 278.8,29.99 278.44,29.63 276.79,29.63 276.64,29.78 275.65,29.78 275.42,30.01 275.17,30.01 275.08,30.03 274.99,30.04 274.48,30.04 274.39,30.03 274.3,30.01 274.13,30.01 274.06,30.04 274.03,30.12 273.67,30.5 273.32,30.12 273.29,30.04 273.21,30.01 272.76,30.01 272.55,30.22 272.55,31.35 272.65,31.45 278.41,31.45
+5V_PVDD on IN4 (solid shape): outline of 1001 points within 277.12,23.44 294.27,35.73
+5VALW on TOP (solid shape): 131.12,101.24 131.12,98.94 131.01,98.83 130.58,98.83 130.52,98.9 130.52,99.59 130.31,99.79 130.31,101.21 130.5,101.39 130.98,101.39
+5VALW on TOP (solid shape): 10.36,24.82 10.36,23.93 11.88,22.41 11.88,20.37 11.42,19.9 8.16,19.9 7.76,20.31 7.76,21.38 6.74,22.39 6.74,23.97 7.68,24.91 10.27,24.91
+5VALW on TOP (solid shape): 284.07,38.56 284.07,38.29 284.62,37.74 284.62,36.93 284.25,36.56 283.14,36.56 283.02,36.44 282.73,36.44 282.57,36.6 282.57,38.59 282.66,38.67 283.05,38.67 283.15,38.78 283.85,38.78
+5VALW on TOP (solid shape): 218.32,12.18 218.32,11.45 218.48,11.29 218.8,11.29 219.05,11.04 219.05,10.71 219.03,10.69 219.03,10.17 218.91,10.05 215.38,10.05 215.16,10.27 215.16,12.19 215.22,12.25 216.9,12.25 217.09,12.44 218.07,12.44
+5VALW on TOP (solid shape): 36.52,32.05 37.23,32.05 37.23,32.58 37.72,32.58 37.72,32.05 38.43,32.05 38.43,32.58 39.58,32.58 39.71,32.45 39.71,28.79 39.31,28.39 36.63,28.39 34.93,30.09 34.93,32.35 35.16,32.58 36.52,32.58
+5VALW on BOTTOM (solid shape): 11.29,22.02 11.29,20.26 11.16,20.13 8.19,20.13 7.97,20.36 7.97,21.92 8.26,22.22 11.1,22.22
+5VALW on BOTTOM (solid shape): 132.99,101.61 132.99,101.35 132.82,101.18 132.47,101.18 131.66,100.37 130.59,100.37 130.48,100.49 130.48,101.04 130.48,101.24 130.96,101.72 132.88,101.72
+5VALW on BOTTOM (solid shape): 291.35,41.24 292.13,41.24 292.79,40.58 292.8,40.58 292.97,40.4 292.97,39.49 292.51,39.02 291.36,39.02 291.07,39.32 290.59,39.32 290.14,39.76 290.14,40.92 290.66,41.44 291.15,41.44
+5VALW on BOTTOM (solid shape): 147.43,111.38 147.49,111.32 147.55,111.28 147.73,111.2 147.92,111.22 148.02,111.12 148.02,110.81 147.95,110.74 146.41,110.74 146.21,110.94 146.21,111.17 146.42,111.38
+5VALW on BOTTOM (solid shape): 145.31,19.76 145.31,16.91 145.11,16.7 143.13,16.7 142.96,16.87 142.96,17.76 143.08,18.03 142.96,18.29 142.96,19.41 143.48,19.93 145.15,19.93
+5VALW on BOTTOM (solid shape): 140.07,116.73 140.07,115.97 140.41,115.62 140.41,115.19 140.45,115.15 140.45,114.14 140.4,114.09 140.17,114.09 140.09,114.16 140.09,114.93 139.71,115.31 138.95,115.31 138.69,115.05 138.69,114.42 138.44,114.16 136.92,114.16 136.79,114.29 136.79,116.7 137.14,117.06 139.74,117.06
+5VALW on IN2 (solid shape): 145.04,18.61 145.04,17.71 144.97,17.64 144.97,17.64 144.89,17.57 143.95,17.57 143.14,18.38 142.91,18.38 142.91,18.39 142.31,18.39 142.23,18.47 142.08,18.47 142.04,18.51 141.62,18.51 141.5,18.39 138.48,18.39 138.3,18.2 138.3,17.76 138.17,17.63 137.32,17.63 137.13,17.82 137.13,18.98 137.72,19.56 140.01,19.56 140.24,19.47 140.48,19.56 140.77,19.85 143.8,19.85
+5VALW on IN2 (solid shape): outline of 5730 points within 156.73,6.42 251.1,22.39
+5VALW on IN3 (solid shape): 216.6,11.16 218.86,11.16 219.08,10.94 219.08,10.12 218.98,10.02 215.76,10.02 215.61,10.18 215.61,11.67 215.68,11.75 216.01,11.75
+5VALW on VCC: outline of 666 points within 1.02,5.27 308.07,87.75
+5VALWP on TOP (solid shape): 39.71,35.02 39.71,32.96 39.51,32.76 38.3,32.76 38.3,32.18 37.85,32.18 37.85,32.71 37.1,32.71 37.1,32.18 36.65,32.18 36.65,32.71 36.64,32.71 36.64,32.76 35.09,32.76 34.84,33 34.84,34.63 35.75,35.54 35.75,35.54 35.93,35.72 35.93,35.75 38.97,35.75
+5VALWP on BOTTOM (solid shape): 43.57,36.95 43.57,34.53 43.19,34.15 39.89,34.15 38.87,33.14 38.24,33.14 37.09,31.99 37.09,31.61 36.99,31.36 37.09,31.11 37.09,30.97 36.99,30.72 37.09,30.47 37.09,30.34 36.99,30.09 37.09,29.84 37.09,29.7 36.99,29.45 37.09,29.2 37.09,29.07 36.99,28.82 37.09,28.57 37.09,26.91 36.97,26.79 34.93,26.79 34.68,27.04 34.68,33.05 34.81,33.18 34.81,33.6 34.68,33.73 34.68,34.29 34.68,35.55 34.71,35.55 35.19,36.03 35.19,36.06 35.32,36.19 37.47,36.19 38.49,37.2 43.32,37.2
+5VS on TOP (solid shape): 56.74,31.27 56.74,30.8 56.37,30.43 56.37,29.56 56.68,29.25 56.68,29.02 56.5,28.84 56.04,28.84 55.42,29.46 55.42,29.89 55.23,30.09 55.08,30.09 54.8,30.36 54.8,30.8 54.86,30.86 55.67,30.86 56.19,31.38 56.62,31.38
+5VS on TOP (solid shape): 210.07,12.92 210.07,12.13 209.89,11.95 209.89,10.12 209.79,10.01 207.64,10.01 207.59,10.06 207.6,10.09 207.8,11.22 207.73,12.36 207.73,12.38 207.64,12.77 207.52,13.16 207.51,13.19 207.74,13.42 209.57,13.42
+5VS on BOTTOM (solid shape): 295.64,63.29 295.64,62.45 295.51,62.32 294.4,62.32 294.03,61.95 292.76,61.95 292.62,62.09 292.62,63.24 292.92,63.54 295.39,63.54
+5VS on BOTTOM (solid shape): 271.36,21.83 271.36,20.05 271.29,19.98 269.83,19.98 269.77,20.05 269.77,21.03 270.01,21.28 270.07,21.28 270.37,21.57 270.37,21.96 270.39,21.99 271.21,21.99
+5VS on BOTTOM (solid shape): 277.59,33.23 277.59,31.91 277.5,31.82 276.03,31.82 275.9,31.94 275.9,32.26 275.8,32.36 272.76,32.36 272.65,32.46 272.65,33.65 273.14,34.13 276.69,34.13
+5VS on BOTTOM (solid shape): 208.34,15.05 208.34,14.98 210.78,12.54 210.78,10.23 210.57,10.02 207.72,10.02 207.64,10.06 207.62,10.15 207.02,14.2 203.59,16.45 203.59,18.3 203.66,18.37 205.02,18.37
+5VS on IN1 (solid shape): outline of 1532 points within 259.8,17.19 277.5,32.86
+5VS on IN2 (solid shape): outline of 1467 points within 275.96,31.05 293.99,62.59
+5VS on IN3 (solid shape): 128.77,15.71 128.77,14.71 128.53,14.47 126.25,14.47 125.87,14.85 125.87,15.48 126.37,15.99 128.28,15.99 128.48,15.99
+5VS on IN3 (solid shape): 206.57,15.2 208.27,15.2 210.71,12.75 210.71,10.24 210.49,10.02 205.38,10.02 205.22,10.18 205.22,12.51 203.82,13.91 201.74,13.91 198.23,10.4 196.53,10.4 196.28,10.66 196.28,11.75 199.73,15.2 206.56,15.2
+5VS on IN3 (solid shape): outline of 448 points within 269.94,20.16 277.81,33.49
+5VS on IN4 (solid shape): 129.85,15.93 129.85,15.23 129.72,15.1 127.4,15.1 127.28,15.22 127.28,15.92 127.47,16.12 129.66,16.12
+5VS on IN4 (solid shape): outline of 4912 points within 195.1,10.02 273.39,22.19
+5VS_HDD on BOTTOM (solid shape): 202.82,18.67 202.82,16.87 202.58,16.63 196.64,16.63 195.97,15.97 195.97,11.58 195.82,11.43 194.52,11.43 194.36,11.59 194.36,12.86 194.84,13.33 194.84,16.27 194.57,16.53 194.57,18.79 194.7,18.91 198.28,18.91 198.57,19.21 202.28,19.21
+19VB_1VALWP on TOP (solid shape): 255.25,18.96 255.25,17.52 255.25,17.52 255.16,17.52 255.03,17.54 254.89,17.52 253.63,17.52 252.71,18.43 252.71,19.12 252.92,19.32 254.9,19.32
+19VB_1VALWP on BOTTOM (solid shape): 254.22,21.75 254.24,21.73 254.77,21.73 254.77,21.81 254.77,21.82 254.77,22.29 255.02,22.29 255.02,21.83 255.03,21.83 255.03,21.76 255.05,21.73 255.58,21.73 255.58,22.29 255.89,22.29 255.89,20.82 255.99,20.72 255.99,18.28 255.28,17.57 253.38,17.57 253.19,17.75 252.68,17.75 252.56,17.64 252.56,17.64 252.05,17.14 251.83,17.14 251.39,16.7 249.97,16.7 249.87,16.8 249.87,17.85 249.56,18.15 249.56,18.75 249.67,18.85 251.25,18.85 251.48,19.08 251.48,21.34 251.98,21.83 253.4,21.83 253.86,22.29 254.22,22.29
+19VB_+0.95VSP on TOP (solid shape): 70.7,75.16 70.31,74.77 70.67,74.41 71.06,74.8 71.26,74.59 70.88,74.2 71.23,73.85 71.62,74.23 71.84,74.02 72.32,73.53 72.32,72.94 70.74,71.36 69.57,71.36 69.07,70.86 68.84,70.86 68.72,70.73 68.69,70.73 68.08,70.13 68.08,68.7 67.98,68.6 66.56,68.6 66.46,68.7 66.46,69.38 66.38,69.46 66.38,69.46 66.05,69.79 66.05,71.76 65.81,71.99 64.77,71.99 64.61,71.83 64.61,70.89 64.48,70.75 61.35,70.75 61.21,70.89 61.21,71.43 61.44,72.23 62.28,73.06 64.11,73.06 67.15,73.34 69.12,75.67 69.12,75.68 70.17,75.68
+19VB_+1.0VSP on TOP (solid shape): 225.05,49.77 225.05,46.6 224.67,46.22 222.51,46.22 222.51,46.22 222.22,46.22 221.81,46.64 221.81,47.92 221.83,47.94 222.37,47.94 222.39,47.95 222.39,48.48 222.36,48.51 221.83,48.51 221.82,48.52 221.82,48.72 221.84,48.75 222.34,48.75 222.39,48.79 222.39,49.31 221.84,49.31 221.81,49.34 221.81,50.07 222.02,50.28 224.55,50.28
+19VB_+1.0VSP on BOTTOM (solid shape): 225.05,49.39 225.05,46.83 224.19,45.96 224.19,44.83 224.11,44.76 222.65,44.76 222.58,44.83 222.58,46.02 222.35,46.25 222.35,48.16 222.06,48.45 221.68,48.45 221.56,48.57 221.56,49.58 221.62,49.65 224.8,49.65
+19VB_+1.8VSP on TOP (solid shape): 208.04,124.2 209.53,124.2 212.02,121.71 212.02,120.18 211.97,120.13 211.09,120.13 211.06,120.16 210.25,120.16 209.59,120.82 209.59,121.05 209.53,121.1 207.6,121.1 207.48,121.22 207.48,122.09 208.01,122.09 208.06,122.14 208.06,122.65 207.53,122.65 207.48,122.7 207.48,122.9 208.01,122.9 208.04,122.93 208.04,123.41 208.01,123.43 207.55,123.43 207.5,123.48 207.5,123.82 207.91,124.22 208.01,124.22
+19VB_+1.8VSP on BOTTOM (solid shape): 212.02,121.66 212.02,120.18 211.97,120.13 209.69,120.13 209.42,120.4 209.43,120.41 209.43,120.79 208.09,120.79 208.09,120.51 208.11,120.49 208.09,120.46 208.09,119.52 206.41,119.52 206.38,119.55 206.38,122.21 206.64,122.47 207.78,122.47 207.91,122.6 207.91,124.07 208.04,124.2 209.48,124.2
+VCC_CORE on TOP (solid shape): outline of 1898 points within 103.13,81.4 126.63,115.31
+VCC_CORE on BOTTOM (solid shape): outline of 422 points within 110.84,81.27 122.2,83.18
+VCC_CORE on BOTTOM (solid shape): outline of 1603 points within 103.39,93.59 126.63,116.2
+VCC_CORE on IN1 (solid shape): 108.21,112.66 108.65,112.66 108.67,112.69 109.64,112.69 109.99,112.33 109.99,111.47 109.64,111.12 103.64,111.12 103.39,111.37 103.39,113.4 103.59,113.6 107.27,113.6
+VCC_CORE on IN1 (solid shape): 126.71,113.49 126.71,109.72 124.88,107.89 122.11,107.89 120.51,109.49 120.51,111.89 120.92,112.3 121.34,112.45 121.3,112.89 121.27,112.96 121.3,113.03 121.38,113.16 121.39,113.32 121.39,113.34 121.85,113.81 126.39,113.81
+VCC_CORE on IN1 (solid shape): 117.32,112.85 117.3,112.47 117.63,112.28 117.71,112.26 117.74,112.18 117.74,111.43 118.2,110.98 118.2,109.03 117.51,108.35 112.18,108.35 111.21,109.31 111.21,110.78 111.26,110.83 111.26,111.9 112.08,112.72 112.11,112.7 112.53,112.77 112.59,113.18 112.58,113.22 113.34,113.99 116.19,113.99
+VCC_CORE on IN1 (solid shape): outline of 2197 points within 107.83,81.25 122.82,102.46
+VCC_CORE on IN2 (solid shape): outline of 4223 points within 101.86,80.53 126.76,118.61
+VCC_CORE on IN3 (solid shape): outline of 1238 points within 101.48,108.78 126.91,118.63
+VCC_CORE on IN3 (solid shape): outline of 2295 points within 107.99,81.25 122.71,102.46
+VCC_CORE on IN4 (solid shape): outline of 1155 points within 101.53,108.73 126.73,118.13
+VCC_CORE on IN4 (solid shape): outline of 1380 points within 107.83,87.39 120.02,102.14
+VCC_CORE on VCC: outline of 193 points within 101.86,81.52 126.76,118.61
+VCCGT on TOP (solid shape): outline of 2847 points within 83.83,81.59 108.13,117.34
+VCCGT on BOTTOM (solid shape): outline of 162 points within 93.93,81.49 106.94,83.18
+VCCGT on BOTTOM (solid shape): outline of 1743 points within 83.96,93.85 108.13,119.12
+VCCGT on IN1 (solid shape): 88.48,115.79 88.48,111.67 88.25,111.45 87.2,111.45 86.23,110.48 84.03,110.48 83.55,110.96 83.55,115.89 84.03,116.37 87.89,116.37
+VCCGT on IN1 (solid shape): outline of 174 points within 89.65,110.45 101.79,116.8
+VCCGT on IN1 (solid shape): outline of 4169 points within 85.81,81.64 109.48,102.26
+VCCGT on IN2 (solid shape): outline of 6268 points within 79.51,80.74 108.09,118.61
+VCCGT on IN3 (solid shape): outline of 331 points within 83.32,108.78 101.05,118.79
+VCCGT on IN3 (solid shape): outline of 3621 points within 88.38,81.64 108.12,102.45
+VCCGT on IN4 (solid shape): outline of 142 points within 84.06,108.88 101.2,116.58
+VCCGT on IN4 (solid shape): outline of 2596 points within 88.38,87.9 108.11,102.14
+VCCGT on VCC: outline of 107 points within 82.31,81.52 108.09,118.61
+VCCIO on TOP (solid shape): 122.69,92.85 122.69,92.22 122.93,91.98 123.58,91.98 123.64,91.91 123.64,91.26 123.64,91.25 123.6,91.25 123.56,91.2 122.79,91.2 122.18,91.81 122.18,92.24 122.26,92.32 122.26,92.8 122.36,92.9 122.64,92.9
+VCCIO on TOP (solid shape): 70.88,61.02 71.68,61.02 71.68,60.48 72.43,60.48 72.43,61.02 72.88,61.02 72.88,60.48 73.63,60.48 73.63,61.02 75,61.02 75.83,60.19 75.83,57.43 75.06,56.66 67.9,56.66 67.66,56.9 67.66,59.9 67.95,60.19 68.84,60.19 69.68,61.03 70.88,61.03
+VCCIO on TOP (solid shape): 124.88,88.1 124.88,87.67 124.7,87.49 124.52,87.49 124.29,87.26 124.29,85.3 124.47,85.12 124.72,85.12 124.86,84.98 124.86,84.56 124.67,84.37 124.57,84.37 124.29,84.09 124.29,83.58 124.23,83.52 123.77,83.52 123.66,83.63 123.66,84.28 123.55,84.39 122.94,84.39 122.74,84.19 122.74,83.86 122.64,83.76 122.44,83.76 122.26,83.94 122.26,85.38 122.39,85.51 123.25,85.51 123.86,86.12 123.86,86.88 123.66,87.09 122.95,87.09 122.69,86.83 122.49,86.83 122.31,87.01 122.31,87.19 122.69,87.57 122.69,88.1 122.9,88.31 124.67,88.31
+VCCIO on BOTTOM (solid shape): outline of 89 points within 121.49,83.24 124.84,93.33
+VCCIO on IN1 (solid shape): outline of 1828 points within 122.06,78.1 132.72,92.84
+VCCIO on VCC (solid shape): outline of 2034 points within 120.53,76.57 136.03,89.65
+VCCIO on IN2 (solid shape): outline of 424 points within 120.25,83.68 125.15,89.93
+VCCIO on IN3 (solid shape): outline of 20621 points within 68.08,33.01 136.66,94.25
+VCCSA on TOP (solid shape): outline of 311 points within 119.8,84.76 135.9,111.75
+VCCSA on BOTTOM (solid shape): outline of 335 points within 119.19,93.57 136.53,115.94
+VCCSA on IN1 (solid shape): outline of 1017 points within 120.41,86.45 134.83,111.42
+VCCSA on IN2 (solid shape): outline of 2633 points within 120.53,90.16 135.65,117.08
+VCCSA on IN3 (solid shape): 134.76,111.7 134.76,108.85 134.22,108.32 133.39,108.32 133.04,108.68 132.95,108.68 132.9,108.73 131.05,108.73 130.9,108.88 130.9,111.67 131.15,111.93 134.53,111.93
+VCCSA on IN4 (solid shape): 134.63,111.55 134.63,108.52 134.27,108.17 131.83,108.17 131.05,108.95 131.05,111.5 131.38,111.83 134.35,111.83
+VCCSA on VCC: outline of 124 points within 120.53,90.16 135.65,117.08
+VCCST on TOP (solid shape): outline of 605 points within 122.26,92.4 131.95,96
+VCCST on IN1 (solid shape): outline of 803 points within 122.18,91.43 131.96,96.7
+VCCST on IN2 (solid shape): 188.68,37.68 188.68,36.85 187.97,36.13 187.64,36.13 187.64,37.58 187.94,37.89 188.48,37.89
+VCCST on IN2 (solid shape): 131.84,88.64 131.84,87.51 131.55,87.21 130.46,87.21 130.13,87.54 130.13,88.6 130.35,88.81 131.67,88.81
+VCCST on IN2 (solid shape): outline of 1136 points within 152.49,20.31 177.55,26.09
+VCCST on IN4 (solid shape): outline of 1744 points within 121.55,76.95 135.01,93.81
+VCCSTG on TOP (solid shape): 134.33,96.89 134.33,96.68 134.23,96.58 134.23,96.01 134.1,95.89 133.09,95.89 132.49,96.49 132.49,96.81 132.67,97 134.22,97
+VCCSTG on BOTTOM (solid shape): 133.79,97.93 133.79,96.63 133.59,96.43 131.82,96.43 131.72,96.53 131.72,97.73 131.98,97.99 133.73,97.99
+VCCSTG on IN3 (solid shape): outline of 737 points within 123.33,93.84 133.84,101.58
GND on TOP (solid shape): 46.15,18.11 46.15,15.9 45.73,15.48 44.46,15.48 44.02,15.93 44.02,18.6 44.21,18.79 45.48,18.79
GND on TOP (solid shape): 83.45,117.34 83.45,114.29 83.32,114.16 81.16,114.16 81.04,114.29 81.04,117.21 81.29,117.47 83.32,117.47
GND on TOP (solid shape): 169.63,69.59 169.63,67.81 169.17,67.35 166.34,67.35 166.3,67.39 166.3,70.21 166.36,70.26 168.95,70.26
GND on TOP (solid shape): 188.71,118.94 188.71,118.2 188.45,117.95 186.67,117.95 186.45,118.18 186.45,119.04 186.55,119.14 188.5,119.14
GND on TOP (solid shape): 212.13,117.77 212.13,117.13 212.07,117.08 210.12,117.08 210.12,117.74 210.14,117.74 210.42,118.02 211.87,118.02
GND on TOP (solid shape): 217.81,43.34 217.81,41.65 216.93,40.76 214.64,40.76 214.51,40.88 214.51,43.13 214.94,43.55 217.61,43.55
GND on TOP (solid shape): 239.71,16.96 239.71,15.67 239.57,15.52 236.8,15.52 236.69,15.63 236.69,17.09 236.81,17.21 239.46,17.21
GND on TOP (solid shape): 149.54,70.46 149.54,67.34 149.4,67.2 146.65,67.2 146.23,67.61 146.23,70.29 146.59,70.65 149.35,70.65
GND on TOP (solid shape): 196.7,119.53 196.7,118.93 196.12,118.35 195.08,118.35 194.7,118.74 194.7,119.24 195.01,119.55 196.68,119.55
GND on TOP (solid shape): 196.78,122.6 196.56,122.37 194.88,122.37 194.61,122.64 194.61,123.19 194.88,123.46 196.78,123.46
GND on TOP (solid shape): 48.65,37.07 48.65,34.35 47.56,33.26 45.86,33.26 45.6,33.52 45.6,37.07 45.86,37.33 48.4,37.33
GND on TOP (solid shape): 72.53,67.62 72.53,63.49 70.62,61.59 69.8,61.59 69.61,61.78 69.61,62.03 71.19,63.62 71.19,67.81 71.26,67.87 72.27,67.87
GND on TOP (solid shape): 119.04,91.9 119.04,88.56 118.91,88.43 115.86,88.43 115.61,88.68 115.61,91.23 116.44,92.06 118.89,92.06
GND on TOP (solid shape): 143.65,56.38 143.65,56.25 144.15,55.74 144.15,46.09 144.03,45.96 143.4,45.96 141.98,47.38 141.98,56.75 142.12,56.89 143.14,56.89
GND on TOP (solid shape): 152.38,103.4 152.38,100.34 151.36,99.31 150.11,99.31 149.98,99.44 149.98,101.21 149.74,101.45 149.74,103.34 150.17,103.77 152.01,103.77
GND on TOP (solid shape): 183.23,46.94 187.36,46.94 187.47,46.83 187.47,42.45 187.28,42.27 182.25,42.27 181.84,42.67 181.84,46.89 181.9,46.95 183.22,46.95
GND on TOP (solid shape): 237.44,11.25 237.44,10.42 237.3,10.28 233.84,10.28 233.64,10.48 233.64,11.24 233.89,11.5 237.19,11.5
GND on TOP (solid shape): 154.82,45.84 154.82,45.62 154.89,45.55 154.89,44.63 154.71,44.45 153.67,44.45 153.3,44.82 153.3,45.96 153.68,46.35 154.31,46.35
GND on TOP (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.49,14.85 172.7,15.64 172.7,17.19 173.03,17.52 177.3,17.52
GND on TOP (solid shape): 180.29,23.36 180.29,21.35 180.23,21.29 179.35,21.29 179.31,21.33 179.31,23.35 179.4,23.44 180.22,23.44
GND on TOP (solid shape): 215.02,14.21 215.02,10.79 214.89,10.66 214.03,10.66 213.92,10.78 213.92,11.41 214,11.5 214,14.22 214.07,14.29 214.95,14.29
GND on TOP (solid shape): 120.37,95.07 120.7,95.07 120.72,95.05 120.72,94.41 120.66,94.35 119.77,94.35 119.64,94.48 119.64,95.11 119.39,95.37 119.39,95.62 119.52,95.75 119.69,95.75
GND on TOP (solid shape): 166.68,92.93 166.68,92.71 165.55,91.58 165.31,91.58 165.04,91.85 165.04,92.16 164.93,92.27 164.93,93.03 164.99,93.09 166.52,93.09
GND on TOP (solid shape): 174.36,63.19 174.36,61.94 173.9,61.48 170.24,61.48 169.12,62.6 146.85,62.6 146.56,62.89 146.56,63.58 146.8,63.82 171.37,63.82 171.49,63.94 173.61,63.94
GND on TOP (solid shape): 187.02,30.94 187.02,29.75 186.71,29.44 184.24,29.44 184.16,29.52 184.16,30.18 184.22,30.24 184.92,30.24 184.98,30.3 184.98,31.02 185.18,31.22 186.74,31.22
GND on TOP (solid shape): 172.25,26.53 172.25,25.92 172.2,25.87 171.82,25.87 171.69,26 171.69,26.03 171.43,26.28 171.05,26.28 170.65,26.69 170.65,27.42 170.7,27.47 171.31,27.47
GND on TOP (solid shape): 176.03,74.17 176.04,74.17 176.16,74.05 176.16,73.19 176.06,73.09 175.28,73.09 175.13,73.24 175.13,74.03 175.43,74.34 175.86,74.34
GND on TOP (solid shape): 274.75,23.1 274.75,21.72 274.72,21.69 272.31,21.69 272.08,21.46 271.7,21.46 271.51,21.65 271.51,21.93 272.51,22.93 274.05,22.93 274.25,23.12 274.72,23.12
GND on TOP (solid shape): 162.06,83.32 162.06,82.77 162.01,82.72 161.5,82.72 161.17,83.05 160.41,83.05 160.33,83.12 160.33,83.18 160.33,83.23 160.33,83.73 160.54,83.94 161.44,83.94
GND on TOP (solid shape): 143.34,132.63 143.34,132.2 143.55,131.99 144.18,131.99 144.31,131.87 144.31,131.38 144.18,131.26 143.82,131.26 142.17,129.61 139.23,129.61 138.62,130.22 138.62,132.71 138.69,132.78 143.19,132.78
GND on TOP (solid shape): 268.97,29.29 268.97,28.18 268.65,27.87 267.41,27.87 267.24,28.03 267.24,28.08 267.19,28.08 267.07,28.21 266.84,28.21 266.64,28.41 266.64,29.33 266.66,29.35 268.9,29.35
GND on TOP (solid shape): 14.79,39.74 14.92,39.71 14.94,39.71 15.58,39.07 15.58,37.3 15.48,37.2 14.84,37.2 14.75,37.29 14.75,38.43 13.9,39.28 13.9,39.62 14.08,39.79 14.65,39.79
GND on TOP (solid shape): 177.27,72.96 178.22,72.96 178.42,73.15 179.51,73.15 179.77,72.9 179.77,71.88 179.76,71.87 179.76,68.94 179.68,68.86 176.17,68.86 175.85,69.18 175.85,71.8 176.39,72.33 176.39,73.04 176.5,73.15 177.08,73.15
GND on TOP (solid shape): 281.44,46.98 281.44,43.04 281.83,42.66 281.83,42.13 281.48,41.77 278.01,41.77 277.63,42.15 277.63,46.79 277.95,47.11 281.31,47.11
GND on TOP (solid shape): 102.6,82.03 102.6,81.78 102.42,81.6 102.38,81.6 102.37,81.6 102.24,81.63 102.12,81.6 102.11,81.6 100.97,81.6 100.85,81.73 100.85,82.29 100.87,82.31 102.32,82.31
GND on TOP (solid shape): 211.29,119.75 212,119.75 212.1,119.65 212.1,118.48 211.92,118.3 210.12,118.3 209.74,117.92 206.59,117.92 206.56,117.95 206.56,118.79 208.85,118.79 209.03,118.96 209.03,119.32 209.36,119.65 209.36,119.75 209.64,120.03 211.01,120.03
GND on TOP (solid shape): 112.74,87.7 112.74,85.99 112.48,85.74 112.48,85.46 112.74,85.21 112.74,84.78 112.53,84.57 111.1,84.57 110.88,84.79 110.88,87.7 110.98,87.8 112.63,87.8
GND on TOP (solid shape): 274.15,28.59 274.81,27.93 274.81,26.56 274.66,26.41 274.4,26.41 274.15,26.66 274.15,26.94 273.52,27.57 273.52,27.64 273.45,27.64 273.24,27.85 273.24,28.26 273.57,28.59
GND on TOP (solid shape): 208.34,15.21 208.34,14.74 208.58,14.5 210.72,14.5 210.87,14.35 210.87,12.33 210.83,12.28 210.33,12.28 210.27,12.35 210.27,13.11 209.78,13.6 204.32,13.6 203.87,14.06 203.87,14.98 204.18,15.3 208.25,15.3
GND on TOP (solid shape): 254.84,16.88 254.97,16.83 255.12,16.84 255.25,16.7 255.25,14.7 255.15,14.6 254.06,14.6 253.98,14.52 253.98,11.67 253.71,11.39 253.12,11.39 252.87,11.65 252.87,14.39 252.64,14.62 252.64,16.32 253.2,16.88
GND on TOP (solid shape): 171.77,93.54 171.77,93.05 171.67,92.95 171.29,92.95 171.12,92.78 171.12,92.34 171.1,92.33 171.1,92.12 171.26,91.96 171.6,91.96 171.71,91.86 171.71,91.83 171.88,91.66 171.88,90.71 171.82,90.65 170.95,90.65 170.95,91.78 170.57,92.16 170.39,92.16 170.14,92.42 170.14,93.26 170.26,93.39 170.98,93.39 171.18,93.59 171.73,93.59
GND on TOP (solid shape): 281.16,33.21 281.16,33.15 281.16,33.14 281.13,33.01 281.16,32.88 281.16,32.87 281.16,32.53 281.44,32.25 281.95,32.25 282.08,32.12 282.08,31.61 281.95,31.49 279.28,31.49 278.04,31.49 277.78,31.75 277.78,33.16 278.01,33.39 280.98,33.39
GND on TOP (solid shape): 21.69,27.87 21.69,27.63 21.79,27.29 22.13,27.21 22.5,27.21 22.87,26.84 22.87,24.12 22.74,23.99 21.8,23.99 21.59,24.2 21.16,24.2 20.32,25.04 19.84,25.04 19.57,25.31 19.57,27.78 19.94,28.16 21.4,28.16
GND on TOP (solid shape): 270.11,22.16 270.11,21.71 269.78,21.38 269.78,21.02 270.06,20.74 271.56,20.74 272.23,21.41 274.44,21.41 274.58,21.27 274.58,19.15 274.43,18.99 273.43,18.99 273.43,19 272.82,19 272.42,19.4 271.49,19.4 270.95,19.93 269.3,19.93 268.91,20.32 268.91,20.81 267.75,21.96 266.99,21.96 266.79,22.16 266.79,22.37 267.07,22.65 267.09,22.65 267.85,23.41 268.87,23.41
GND on TOP (solid shape): 168.72,92.92 168.72,92.67 168.06,92.01 168.06,91.93 168.03,91.81 168.06,91.68 168.06,91.61 168.6,91.06 168.6,90.84 168.32,90.56 168.32,90.15 168.18,90.01 167.73,90.01 167.67,90.07 167.67,90.15 167.7,90.18 167.7,90.75 167.7,90.87 167.68,90.9 167.6,91.02 167.47,91.1 167.35,91.22 167.35,92.13 168.28,93.06 168.58,93.06
GND on TOP (solid shape): 65.84,71.77 65.84,70.02 65.84,70.01 65.84,69.76 65.16,69.08 65.16,68.19 65.26,68.09 67.93,68.09 68.4,67.62 69.44,67.62 69.5,67.55 69.5,67.45 69.4,67.35 68.36,67.35 68.01,67 66.99,67 66.63,67.35 66.08,67.35 66.08,67.35 65.35,67.35 65.14,67.14 65.14,67.13 65.01,67.01 65.01,66.97 64.99,66.95 64.99,65.97 64.11,65.09 61.56,65.09 61.27,65.37 61.27,70.36 61.39,70.48 64.55,70.48 64.78,70.7 64.78,71.75 64.9,71.87 65.74,71.87
GND on TOP (solid shape): 229.24,48.89 229.24,45.46 229.12,45.33 228.96,45.33 228.74,45.41 228.52,45.33 228.23,45.33 228.15,45.25 227.81,45.06 227.85,44.68 227.85,43.81 227.47,43.42 225.94,43.42 225.69,43.68 225.69,45.96 225.31,46.35 225.31,48.89 225.56,49.14 228.99,49.14
GND on TOP (solid shape): 177.33,87.59 177.33,87.47 177.32,87.46 177.32,87.17 177.55,86.98 177.56,86.98 178.15,86.4 178.15,86.38 178.21,86.27 178.32,86.19 178.32,85.99 178.11,85.79 177.94,85.79 177.7,86.02 177.43,86.02 177.3,85.89 177.3,85.74 177.28,85.66 177.29,85.58 177.27,85.55 176.66,85.55 176.49,85.72 176.49,87.59 176.57,87.68 177.24,87.68
GND on TOP (solid shape): 200.73,72.15 201.08,71.86 201.43,72.15 203.01,72.15 203.64,71.52 203.64,68.65 203.44,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.97,69.97 198.74,69.74 198.74,68.75 198.43,68.44 194.83,68.44 194.57,68.7 194.57,70.09 194.32,70.35 194.07,70.35 194.06,70.35 194.02,70.35 193.89,70.49 193.89,71.77 194.27,72.15
GND on TOP (solid shape): 297.55,25.01 298.29,25.01 298.11,24.2 298.79,23.72 306.75,23.72 306.76,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 296.22,21.86 296.09,22 296.09,24.79 296.32,25.02 297.55,25.02
GND on TOP (solid shape): 168.6,88.87 168.6,88.75 168.77,88.58 168.95,88.58 169.14,88.39 169.62,88.39 169.81,88.2 169.81,87.45 169.68,87.33 169.16,87.33 168.97,87.13 168.97,86.74 169.04,86.66 169.04,86.65 169.14,86.56 169.49,86.21 169.49,85.42 169.09,85.03 169.09,85.01 169.09,85 169.03,84.8 169.09,84.61 169.09,84.01 169.08,83.98 168.75,83.65 168.74,83.65 168.64,83.58 168.57,83.48 168.57,83.47 168.52,83.42 168.25,83.42 168.13,83.54 168.13,83.77 168.26,83.9 168.31,83.9 168.31,83.96 168.44,84.08 168.44,84.55 168.31,84.67 168.31,84.72 168.27,84.72 168.18,84.81 168.18,84.96 168.64,85.42 168.64,85.55 168.75,85.8 168.65,86.05 168.64,86.06 168.64,86.07 168.07,86.64 168.07,86.79 168.78,87.5 168.78,87.79 168.75,87.83 168.74,87.85 168.64,88.06 168.43,88.16 168.41,88.16 168.03,88.55 168.03,89.02 168.09,89.08 168.4,89.08
GND on TOP (solid shape): outline of 93 points within 156.94,72.88 159.42,75.38
GND on TOP (solid shape): outline of 135 points within 155.76,49.83 167.57,57.24
GND on TOP (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.35 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,85.45 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 306.85,81.67 303.1,81.67 303.1,81.67 302.96,81.63 302.84,81.56 302.66,81.13 302.91,80.73 302.91,66.61 302.87,66.58 302.8,66.52 302.69,65.98 303.14,65.67 305.56,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 305.56,58.42 298.79,58.42 298.24,58.16 298.06,57.58 296.49,57.58 296.49,57.6 296.43,57.6 295.87,58.16 295.87,59.81 296.68,60.62 298.97,60.62 299.93,61.59 299.93,64.18 299.58,64.53 299.58,66.69 300.03,67.14 302.23,67.14 302.4,67.31 302.4,79.99 302.21,80.18 301.76,80.18 301.76,80.18 299.91,80.18 299.59,80.5 299.59,81.75 300.02,82.18 305.13,82.18 305.83,82.89 305.83,86.74 307.22,88.13 307.22,93.08 306.08,94.22 306.08,95.11 306.45,95.49
GND on TOP (solid shape): outline of 104 points within 0.25,11.84 10.35,43.85
GND on TOP (solid shape): outline of 241 points within 295.89,36.43 307.49,45.44
GND on TOP (solid shape): outline of 244 points within 161.6,81.94 173.54,98.47
GND on TOP (solid shape): outline of 289 points within 170.11,82.01 175.19,94.12
GND on TOP (solid shape): outline of 428 points within 69.1,110.23 139.35,127.37
GND on TOP (solid shape): outline of 322 points within 0.25,0.26 309.42,134.55
GND on BOTTOM (solid shape): 31.86,35.52 31.86,34.64 31.76,34.53 31.33,34.53 30.97,34.89 30.97,35.68 31.03,35.74 31.65,35.74
GND on BOTTOM (solid shape): 46.19,18.12 46.19,17.22 46.04,17.07 44.27,17.07 44.01,17.33 44.01,18.6 44.27,18.87 45.44,18.87
GND on BOTTOM (solid shape): 48.14,15.69 48.14,11.93 47.89,11.67 47.63,11.67 47.38,11.93 47.38,15.74 47.51,15.87 47.96,15.87
GND on BOTTOM (solid shape): 86.56,17.07 86.56,14.11 86.41,13.96 83.58,13.96 83.19,14.34 83.19,16.96 83.42,17.18 86.46,17.18
GND on BOTTOM (solid shape): 204.8,60.27 204.8,59.32 204.56,59.07 202.39,59.07 202.16,59.3 202.16,60.29 202.31,60.44 204.63,60.44
GND on BOTTOM (solid shape): 217.89,43.13 217.89,41.24 217.4,40.76 214.64,40.76 214.51,40.88 214.51,42.97 214.83,43.29 217.73,43.29
GND on BOTTOM (solid shape): 237.39,11.23 237.39,10.42 237.24,10.27 234.07,10.27 233.82,10.53 233.82,11.24 233.99,11.41 237.21,11.41
GND on BOTTOM (solid shape): 239.66,17.39 239.66,16.63 239.53,16.5 236.23,16.5 236.1,16.63 236.1,17.18 236.59,17.67 239.38,17.67
GND on BOTTOM (solid shape): 270.45,37.82 270.45,33.93 270.16,33.65 265.24,33.65 264.87,34.01 264.87,37.77 265.34,38.24 270.03,38.24
GND on BOTTOM (solid shape): 50.17,27.62 50.17,26.79 49.54,26.15 49.54,24.76 49.16,24.37 48.65,24.37 48.52,24.5 48.52,27.3 49.03,27.8 49.99,27.8
GND on BOTTOM (solid shape): 111.01,110.23 111.01,108.32 110.37,107.69 103.58,107.69 103.39,107.87 103.39,110.86 103.52,110.99 110.25,110.99
GND on BOTTOM (solid shape): 114.18,8.78 114.18,7.76 114.06,7.64 111.62,7.64 111.44,7.81 111.44,8.52 111.26,8.7 111.26,9.36 111.31,9.41 113.55,9.41
GND on BOTTOM (solid shape): 143.98,16.26 144.74,16.26 144.89,16.11 144.89,15.48 144.49,15.08 142.78,15.08 142.62,15.24 142.62,16.14 142.92,16.44 143.79,16.44
GND on BOTTOM (solid shape): 151.77,105.93 151.77,100.19 151.52,99.94 150.12,99.94 150,100.07 150,105.89 150.24,106.14 151.57,106.14
GND on BOTTOM (solid shape): 182.31,40.14 184.09,40.14 184.13,40.1 184.13,39.5 184.08,39.45 181.39,39.45 180.8,40.03 180.8,40.3 181.05,40.55 181.91,40.55
GND on BOTTOM (solid shape): 196.88,119.4 196.88,118.79 196.45,118.35 194.85,118.35 194.57,118.63 194.57,119.42 194.95,119.8 196.48,119.8
GND on BOTTOM (solid shape): 196.98,123.66 196.98,123 196.68,122.7 194.64,122.7 194.52,122.82 194.52,123.71 194.85,124.04 196.6,124.04
GND on BOTTOM (solid shape): 258.23,20.06 258.23,16.57 258.16,16.51 257.05,16.51 256.8,16.75 256.8,19.93 257.11,20.23 257.4,20.23 257.46,20.28 258,20.28
GND on BOTTOM (solid shape): 263.92,16.62 263.92,14.72 263.81,14.62 263.26,14.62 263.15,14.72 263.15,16.61 263.23,16.69 263.85,16.69
GND on BOTTOM (solid shape): 22.46,26.41 22.74,26.41 22.87,26.28 22.87,23.49 22.74,23.36 20.46,23.36 19.57,24.25 19.57,27.61 19.77,27.8 21.07,27.8
GND on BOTTOM (solid shape): 60.02,15.55 60.02,15.1 58.3,13.39 57.99,13.39 57.41,13.96 57.41,15.36 56.94,15.83 56.94,16.46 57.11,16.63 58.94,16.63
GND on BOTTOM (solid shape): 80.78,8.35 80.78,6.42 80.65,6.29 77.25,6.29 76.97,6.57 76.97,8.27 77.25,8.55 80.58,8.55
GND on BOTTOM (solid shape): 143.58,132.37 143.58,131.02 142.63,130.06 142.63,129.35 142.46,129.18 142.46,129.18 139.3,129.18 138.57,129.91 138.57,132.65 138.69,132.78 143.18,132.78
GND on BOTTOM (solid shape): 151.72,33.09 152.14,33.09 152.14,33.09 152.56,32.67 152.56,31.34 152.14,30.93 149.77,30.93 149.36,31.33 149.36,32.99 149.49,33.13 151.68,33.13
GND on BOTTOM (solid shape): 198.05,60.3 198.05,59.39 197.2,58.54 194.51,58.54 194.33,58.72 194.33,60.11 194.66,60.44 197.91,60.44
GND on BOTTOM (solid shape): 15.12,22.72 15.12,21.33 13.98,20.18 12.33,20.18 12.09,20.42 12.09,22.17 12.27,22.34 13.47,22.34 13.85,22.72 13.85,23.1 13.98,23.23 14.61,23.23
GND on BOTTOM (solid shape): 49.35,36.9 49.35,35.23 49.03,34.92 49.03,34.11 48.82,33.9 45.73,33.9 45.48,34.15 45.48,36.95 45.73,37.2 49.04,37.2
GND on BOTTOM (solid shape): 65.29,67.94 65.29,66.16 64.53,65.4 63.37,65.4 63.05,65.72 63.05,66.33 64.78,68.06 65.16,68.06
GND on BOTTOM (solid shape): 99.07,12.44 100.77,12.44 100.86,12.35 100.86,11.42 100.74,11.29 94.12,11.29 93.86,11.55 93.86,12.94 94.12,13.2 98.31,13.2
GND on BOTTOM (solid shape): 154.67,45.79 154.85,45.79 155,45.63 155,44.62 154.85,44.47 153.81,44.47 153.35,44.92 153.35,46.22 153.4,46.27 154.19,46.27
GND on BOTTOM (solid shape): 169.3,122.32 169.3,121.96 169.17,121.83 167.37,121.83 167.35,121.86 166.76,121.86 166.38,121.48 166.28,121.48 166.13,121.63 166.13,121.83 166.74,122.44 169.17,122.44
GND on BOTTOM (solid shape): 189.54,61.28 189.54,59.83 189.47,59.76 180.3,59.76 180.25,59.81 180.25,60.9 180.38,61.03 187.21,61.03 187.89,61.71 189.11,61.71
GND on BOTTOM (solid shape): 224.55,38.09 224.55,36.06 224.42,35.93 220.1,35.93 219.82,36.21 219.82,36.94 219.97,37.09 219.97,38.22 220.23,38.47 224.16,38.47
GND on BOTTOM (solid shape): 186.99,119.18 187.4,119.18 187.97,118.61 189.09,118.61 189.27,118.43 189.27,118.39 189.16,118.29 189.16,117.74 189.09,117.67 187,117.67 185.84,118.84 185.84,118.96 186.06,119.19 186.98,119.19
GND on BOTTOM (solid shape): 149.92,83.48 149.92,82.41 149.72,82.21 146.95,82.21 146.84,82.1 146.73,82.13 146.62,82.13 145.95,82.13 145.7,82.37 145.7,83.23 146.09,83.61 149.79,83.61
GND on BOTTOM (solid shape): 169.8,132.68 169.8,131.84 169.45,131.49 166.83,131.49 166.4,131.06 166.19,131.06 166.1,131.15 166.1,131.36 166.79,132.04 166.79,132.58 167.04,132.83 169.65,132.83
GND on BOTTOM (solid shape): 206.89,114.63 207.54,114.63 207.63,114.54 207.63,113.29 207.64,113.28 207.64,112.75 207.35,112.46 206.18,112.46 205.75,112.89 205.75,114.59 205.95,114.8 206.73,114.8
GND on BOTTOM (solid shape): 265.42,16.63 265.42,16.04 265.69,15.76 266.46,15.76 266.58,15.64 266.58,15.38 266.43,15.23 265.62,15.23 265.16,15.69 265.16,16.63 265.24,16.7 265.34,16.7
GND on BOTTOM (solid shape): 112.07,95.57 112.07,95.38 111.69,95 111.69,94.37 111.56,94.24 111.34,94.24 111.24,94.34 111.24,95.21 111.42,95.39 111.42,95.42 111.72,95.72 111.93,95.72
GND on BOTTOM (solid shape): 157.54,43.91 157.73,43.72 157.73,43.33 157.84,43.21 157.84,43.04 157.75,42.95 157.72,42.96 157.49,42.96 157.34,43.11 156.73,43.11 156.47,43.36 156.47,44.19 156.6,44.31 157.13,44.31
GND on BOTTOM (solid shape): 76.77,122.39 76.77,119.55 76.59,119.37 76.59,116.96 74.56,114.93 74.56,114.16 74.43,114.04 74.43,110.48 74.3,110.35 73.16,110.35 73.16,111.12 72.27,111.12 72.27,119.75 71.76,120.27 71.76,122.77 72.14,123.15 76,123.15
GND on BOTTOM (solid shape): 104.95,95.61 104.95,95.42 104.58,95.05 104.58,94.3 104.51,94.24 104.26,94.24 104.13,94.37 104.13,95 103.75,95.38 103.75,95.57 103.88,95.7 104.07,95.7 104.22,95.55 104.48,95.55 104.65,95.72 104.84,95.72
GND on BOTTOM (solid shape): 36.84,13.96 36.84,9.27 36.64,9.07 35.95,9.07 35.7,9.32 35.7,13.2 35.19,13.71 34.05,13.71 33.66,13.33 33.66,6.7 33.5,6.53 27.65,6.53 27.28,6.9 27.28,13.35 28.77,14.85 35.95,14.85
GND on BOTTOM (solid shape): 101.89,95.53 102.08,95.53 102.28,95.73 102.45,95.73 102.61,95.57 102.61,95.38 102.23,95 102.23,94.37 102.1,94.24 101.85,94.24 101.78,94.3 101.78,95.01 101.4,95.4 101.4,95.59 101.54,95.73 101.69,95.73
GND on BOTTOM (solid shape): 107.3,95.59 107.3,95.4 106.93,95.02 106.93,94.3 106.86,94.24 106.61,94.24 106.48,94.37 106.48,95 106.1,95.38 106.1,95.57 106.23,95.7 106.42,95.7 106.56,95.55 106.82,95.55 107,95.73 107.16,95.73
GND on BOTTOM (solid shape): 261.92,16.61 261.92,15.79 261.49,15.37 261.49,15.37 261.45,15.33 260.68,15.33 260.56,15.45 260.56,15.77 260.68,15.89 261.35,15.89 261.66,16.2 261.66,16.58 261.66,16.61 261.73,16.68 261.84,16.68
GND on BOTTOM (solid shape): 137.3,111.62 137.3,108.58 136.94,108.22 136.73,108.27 136.53,108.19 135.9,108.19 135.77,108.32 135.77,108.83 136.03,109.08 136.03,111.5 136.28,111.75 137.17,111.75
GND on BOTTOM (solid shape): 158.34,22.58 158.34,22.39 158.22,22.27 157.84,22.27 157.74,22.17 157.74,21.83 157.49,21.58 156.92,21.58 156.35,22.15 156.35,22.41 156.48,22.54 157.1,22.54 157.11,22.54 157.29,22.54 157.38,22.64 158.27,22.64
GND on BOTTOM (solid shape): 195.62,20.13 198.24,20.13 198.38,19.99 198.38,19.34 198.24,19.2 194.69,19.2 193.86,20.03 193.86,20.09 193.88,20.18 193.86,20.28 193.86,20.69 194.13,20.96 194.79,20.96
GND on BOTTOM (solid shape): 108.85,18.79 108.85,18.41 109.02,18.24 109.56,18.24 109.74,18.06 109.74,15.76 109.65,15.67 107.27,15.67 107.26,15.66 106.82,15.66 106.41,16.07 106.36,16.13 106.29,16.19 106.25,16.23 106.25,18.21 106.99,18.96 108.67,18.96
GND on BOTTOM (solid shape): 212.1,119.62 212.1,118.74 211.59,118.23 209.24,118.23 209.16,118.31 208.42,118.31 208.34,118.23 208.16,118.23 207.71,117.77 206.46,117.77 206,118.23 205.17,118.23 205.01,118.38 205.01,118.48 205.09,118.56 205.98,118.56 206.41,118.99 209.18,118.99 209.43,119.24 209.43,119.75 209.56,119.88 211.85,119.88
GND on BOTTOM (solid shape): 292.9,49.8 292.9,45.53 292.54,45.18 292.43,45.18 292.43,45.14 292,45.14 291.98,45.15 291.2,45.15 291.17,45.13 291.07,45.13 290.98,45.22 290.98,45.28 291.36,45.67 291.36,46.75 291.74,47.12 291.74,47.14 291.75,47.16 291.75,49.7 291.76,49.7 291.76,49.88 291.89,50.01 292.69,50.01
GND on BOTTOM (solid shape): 120.2,127.04 120.2,125.11 120.53,124.78 120.53,119.88 120.02,119.37 118.25,119.37 117.8,119.81 117.8,123.75 116.66,124.89 113.04,124.89 112.98,124.96 112.98,126.04 113.04,126.1 113.8,126.1 113.84,126.14 113.84,126.96 113.88,126.99 118.12,126.99 118.25,127.12 118.45,127.32 119.92,127.32
GND on BOTTOM (solid shape): 130.44,116.32 130.44,115.43 129.8,114.8 128.91,114.8 128.66,114.54 128.66,113.66 128.79,113.53 129.04,113.53 129.3,113.27 129.3,111.67 129.75,111.22 129.75,108.42 129.22,107.89 125.66,107.89 125.61,107.94 125.61,110.68 125.69,110.76 126.53,110.76 126.81,111.03 126.81,115.48 127.77,116.45 130.31,116.45
GND on BOTTOM (solid shape): 17.66,33.65 17.66,32.68 17.66,28.26 17.66,28.18 17.67,28.17 17.67,26.29 16.9,25.52 16.01,25.52 15.56,25.97 15.56,26.71 15.76,26.91 15.76,32.88 15.76,32.95 15.86,33.05 15.95,33.05 16.16,33.27 16.16,34.01 16.25,34.1 17.21,34.1
GND on BOTTOM (solid shape): 113.62,95.63 113.71,95.55 113.89,95.55 113.92,95.57 113.98,95.57 114.1,95.7 114.29,95.7 114.42,95.57 114.42,95.38 114.04,95 114.04,94.37 113.91,94.24 113.66,94.24 113.59,94.3 113.59,94.97 113.2,95.37 113.2,95.59 113.34,95.73 113.53,95.73
GND on BOTTOM (solid shape): 255.61,16.4 255.61,14.45 255.12,13.96 252.92,13.96 252.74,14.14 252.74,15.27 252.53,15.48 251.51,15.48 251.14,15.1 249.82,15.1 249.44,15.48 248.5,15.48 248.45,15.53 248.45,15.69 248.5,15.74 249.44,15.74 249.9,16.2 252.57,16.2 253.12,16.75 255.25,16.75
GND on BOTTOM (solid shape): 33.66,34.28 33.66,33.31 34.09,32.88 34.3,32.88 34.3,26.91 34.17,26.79 32.65,26.79 32.39,27.04 32.39,30.4 31.69,31.11 30.74,31.11 30.65,31.2 30.65,31.83 30.69,31.87 30.8,31.87 31.41,32.48 31.7,32.48 31.74,32.51 31.74,32.57 31.73,32.58 31.73,33.29 31.71,33.32 31.71,34.03 32.09,34.41 33.54,34.41
GND on BOTTOM (solid shape): 94.79,95.53 95.01,95.53 95.18,95.71 95.41,95.71 95.54,95.58 95.54,95.36 95.47,95.31 95.42,95.23 95.42,95.23 95.33,95.14 95.33,94.45 95.11,94.23 94.58,94.23 94.42,94.39 94.42,95.23 94.26,95.4 94.26,95.57 94.4,95.71 94.62,95.71
GND on BOTTOM (solid shape): 109.66,126.84 109.66,126.56 110.55,125.67 110.55,124.86 110.63,124.78 110.63,119.5 110.37,119.24 108.34,119.24 107.9,119.69 107.9,123.62 106.75,124.77 103.13,124.77 103.07,124.83 103.07,125.91 103.13,125.97 103.9,125.97 103.9,126.8 103.96,126.86 108.21,126.86 108.34,126.99 109.51,126.99
GND on BOTTOM (solid shape): 166.51,119.23 166.64,119.23 166.71,119.17 169.58,119.17 169.73,119.01 169.73,118.28 169.43,117.97 167.19,117.97 166.62,118.54 166.62,118.56 166.53,118.72 166.37,118.81 166.35,118.81 166.12,119.04 166.1,119.07 166.08,119.1 166.08,119.37 166.22,119.52
GND on BOTTOM (solid shape): 293.02,69.69 288.3,69.69 288.29,69.7 289.67,74.7 290.36,79.84 293.02,79.84
GND on BOTTOM (solid shape): 64.4,10.66 64.4,9.9 64.27,9.77 64.27,8.25 64.4,8.12 64.84,8.12 64.91,8.05 64.91,6.78 64.72,6.59 49.92,6.59 49.67,6.85 49.67,10.02 49.92,10.28 52.59,10.28 55.25,7.61 59.45,7.61 60.46,8.63 60.97,8.63 61.22,8.88 61.22,9.26 61.94,9.97 61.94,10.73 62.11,10.91 64.14,10.91
GND on BOTTOM (solid shape): 104.02,17.64 104.02,16.75 103.44,16.17 101.05,16.17 100.82,15.94 100.82,14.04 100.81,14.02 100.81,12.65 100.77,12.61 100.64,12.61 100.57,12.69 100.57,13.78 100.21,14.14 100.21,14.9 100.16,14.95 99.4,14.95 99.4,15.61 99.5,15.71 99.5,16.02 99.58,16.09 100.21,16.09 100.26,16.14 100.26,17.36 100.77,17.87 103.79,17.87
GND on BOTTOM (solid shape): 116.8,95.6 116.8,95.41 116.39,95 116.39,94.3 116.32,94.24 116.07,94.24 115.94,94.37 115.94,95 115.56,95.38 115.56,95.57 115.69,95.7 115.88,95.7 116.01,95.57 116.07,95.57 116.07,95.57 116.16,95.56 116.24,95.57 116.25,95.57 116.3,95.57 116.46,95.73 116.67,95.73
GND on BOTTOM (solid shape): 200.58,71.7 201.08,71.7 201.17,71.71 201.27,71.74 201.28,71.75 203.72,71.75 204.66,70.81 204.66,68.77 204.45,68.57 201.18,68.57 201.05,68.7 201.05,69.84 200.92,69.97 198.98,69.97 198.74,69.73 198.74,68.75 198.57,68.58 195.13,68.58 194.83,68.88 194.83,71.62 194.84,71.63 194.84,71.96 195.21,72.33 199.96,72.33
GND on BOTTOM (solid shape): 118.29,95.7 118.34,95.63 118.44,95.57 118.52,95.56 118.6,95.57 118.61,95.57 118.67,95.57 118.8,95.7 118.99,95.7 119.12,95.57 119.12,95.38 118.74,95 118.74,94.37 118.61,94.24 118.36,94.24 118.29,94.3 118.29,94.99 117.93,95.36 117.93,95.63 118.05,95.75 118.24,95.75
GND on BOTTOM (solid shape): 161.93,56.3 161.93,55.33 162.61,54.65 162.95,54.65 163.15,54.45 163.15,51.45 163.28,51.32 166.43,51.32 166.43,51.33 167.34,51.33 167.57,51.09 167.57,49.27 167.37,49.06 156.83,49.06 156.6,48.83 155.76,48.83 155.76,51.07 155.86,51.17 156.29,51.17 156.45,51.32 159.17,51.32 159.34,51.15 159.34,50.46 160.66,50.46 161.1,50.89 161.1,51.93 160.51,52.52 160.16,52.52 160,52.68 160,56.3 160.2,56.49 161.74,56.49
GND on BOTTOM (solid shape): 228.23,48.89 228.23,47.74 228.74,47.23 229.12,47.23 229.24,47.11 229.24,45.53 229.15,45.44 228.71,45.44 228.66,45.48 228.66,45.84 228.47,46.03 227.56,46.03 227.34,45.81 227.34,44.16 226.86,43.68 225.27,43.68 225.11,43.52 224.01,43.52 223.53,43.04 222.45,43.04 221.97,43.53 221.22,43.53 221.16,43.58 221.16,43.72 221.22,43.78 221.98,43.78 222.44,44.24 225.1,44.24 225.69,44.82 225.69,45.96 225.31,46.35 225.31,48.89 225.56,49.14 227.97,49.14
GND on BOTTOM (solid shape): 99.47,127.21 99.66,127.21 99.88,127 99.88,126.25 100.34,125.79 100.34,125.24 101,124.58 101.36,124.58 101.48,124.45 101.48,117.85 101.23,117.59 97.55,117.59 97.42,117.72 97.42,122.04 97.55,122.16 98.82,122.16 98.94,122.29 98.94,123.94 98.82,124.07 97.93,124.07 97.67,123.82 97.42,123.82 96.47,124.77 92.85,124.77 92.78,124.83 92.78,125.91 92.85,125.97 93.61,125.97 93.61,126.8 93.67,126.86 97.72,126.86 98.08,127.22 99.46,127.22
GND on BOTTOM (solid shape): 97.87,95.61 97.87,95.34 97.82,95.29 97.78,95.23 97.53,94.98 97.53,94.37 97.38,94.22 96.98,94.22 96.8,94.4 96.8,95.15 96.75,95.19 96.75,95.2 96.7,95.29 96.62,95.36 96.6,95.38 96.6,95.57 96.73,95.71 97,95.71 97.1,95.61 97.12,95.6 97.32,95.56 97.48,95.69 97.49,95.7 97.52,95.73 97.74,95.73
GND on BOTTOM (solid shape): 99.39,95.71 99.39,95.7 99.55,95.57 99.76,95.6 99.78,95.61 99.91,95.73 100.1,95.73 100.23,95.61 100.23,95.41 99.85,95.03 99.85,94.4 99.72,94.27 99.31,94.27 99.2,94.39 99.2,95.14 99.1,95.23 99.1,95.24 99.04,95.32 98.96,95.38 98.96,95.59 99.02,95.63 99.06,95.7 99.1,95.73 99.36,95.73
GND on BOTTOM (solid shape): 109.69,95.6 109.69,95.37 109.36,95.04 109.36,94.37 109.24,94.25 108.77,94.25 108.62,94.39 108.62,95.14 108.56,95.2 108.56,95.21 108.5,95.3 108.42,95.37 108.42,95.56 108.56,95.7 108.83,95.7 108.87,95.66 108.89,95.63 108.94,95.59 109.13,95.56 109.29,95.68 109.33,95.73 109.56,95.73
GND on BOTTOM (solid shape): 298.29,25.02 298.11,24.2 298.79,23.72 306.75,23.72 306.76,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.85 303.23,21.85 303.23,21.86 296.22,21.86 296.09,22 296.09,24.8 296.31,25.02 297.64,25.02
GND on BOTTOM (solid shape): 178.99,43.44 178.99,42.21 178.88,42.1 178.19,42.1 177.95,42.34 177.36,42.34 177.35,42.37 177.35,42.4 177.02,42.61 176.97,42.23 176.97,41.95 176.81,41.79 176.63,41.79 176.6,41.79 176.57,41.79 176.44,41.92 176.44,42.43 176.27,42.61 176.27,43.18 176.41,43.32 177.05,43.32 177.2,43.47 177.2,43.63 177.36,43.79 178.64,43.79
GND on BOTTOM (solid shape): 143.85,71.14 143.85,63.85 143.56,63.55 142.44,63.55 140.01,65.98 142.25,65.98 142.25,65.93 142.26,65.87 142.28,65.82 142.31,65.78 142.34,65.74 142.38,65.7 142.43,65.67 142.48,65.65 142.53,65.63 142.58,65.62 142.63,65.62 142.68,65.63 142.74,65.65 142.78,65.67 142.83,65.7 142.87,65.74 142.9,65.78 142.93,65.82 142.95,65.87 142.96,65.93 142.96,65.98 142.96,66.03 142.95,66.08 142.93,66.13 142.9,66.18 142.87,66.22 142.83,66.26 142.78,66.29 142.74,66.31 142.68,66.33 142.63,66.34 142.58,66.34 142.53,66.33 142.48,66.31 142.43,66.29 142.38,66.26 142.34,66.22 142.31,66.18 142.28,66.13 142.26,66.08 142.25,66.03 142.25,65.98 140.01,65.98 136.94,69.05 136.94,72.33 138.52,73.9 141.08,73.9
GND on BOTTOM (solid shape): 151.64,111.67 151.64,111.09 151.57,111.01 150.54,111.01 150.27,110.74 149.52,110.74 149.17,110.4 149.17,108.91 148.85,108.58 148.85,107.79 148.34,107.28 146.34,107.28 146.06,107.56 146.06,107.97 146.26,108.17 147.7,108.17 148.21,108.68 148.21,108.68 148.27,108.74 148.27,111.22 148.43,111.39 149.2,111.39 149.5,111.24 149.79,111.41 149.85,111.47 149.89,111.47 150.22,111.45 150.42,111.7 150.52,111.8 151.52,111.8
GND on BOTTOM (solid shape): 144.46,55.13 144.71,55.13 144.95,54.89 144.95,51.99 143.93,50.97 143.93,50.35 144.13,50.15 144.13,49.44 144.32,49.25 144.88,49.25 145.04,49.09 145.04,45.76 145.36,45.45 145.99,45.45 146.19,45.25 146.19,40.35 146.82,39.72 148.02,39.72 148.37,39.36 148.37,36.4 147.91,35.94 147.14,35.94 145.8,37.28 145.8,38.08 145.04,38.84 145.04,43.25 143.11,45.18 144.57,45.18 144.58,45.12 144.59,45.07 144.61,45.02 144.63,44.98 144.67,44.93 144.71,44.9 144.75,44.87 144.8,44.84 144.85,44.83 144.9,44.82 144.96,44.82 145.01,44.83 145.06,44.84 145.11,44.87 145.15,44.9 145.19,44.93 145.22,44.98 145.25,45.02 145.27,45.07 145.28,45.12 145.29,45.18 145.28,45.23 145.27,45.28 145.25,45.33 145.22,45.38 145.19,45.42 145.15,45.46 145.11,45.49 145.06,45.51 145.01,45.52 144.96,45.53 144.9,45.53 144.85,45.52 144.8,45.51 144.75,45.49 144.71,45.46 144.67,45.42 144.63,45.38 144.61,45.33 144.59,45.28 144.58,45.23 144.57,45.18 143.11,45.18 141.82,46.47 141.82,55.06 141.83,55.07 141.83,55.6 142.22,56 143.6,56
GND on BOTTOM (solid shape): 289.89,107.9 289.59,106.37 288.72,105.07 284.66,101.01 284.54,100.9 283.37,102.66 282.11,104.35 281.99,104.56 281.94,104.81 281.94,107.9 282.09,108.96 282.51,109.93 286.12,116.65 286.39,116.94 286.78,117.05 289.19,117.05 289.56,117.1 289.89,117.26
