# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D5: length 73.2
  IN1 w0.094: v2(70.29,25.95) 69.84,26.4 69.84,34.23 68.16,35.91 68.16,38.69 70,40.53 70,49.48 71.82,51.3 71.82,60.66 76.3,65.15 76.3,73.5 83.49,80.7 84,80.7 84.12,80.59 84.12,80.33 84.23,80.21 84.62,80.21 84.74,80.33 84.74,81.37 84.85,81.48 85.25,81.48 85.36,81.37 85.36,80.88 85.54,80.7 86.08,80.7 v2(86.22,80.56)
  BOTTOM w0.076: UH1.BN11 89.05,80.67 87.19,80.67 87.08,80.56 v2(86.22,80.56)
  BOTTOM w0.114: JDIMM2.3 71.16,26.51 70.6,25.95 v2(70.29,25.95)
DDR_B_D6: length 73.3
  IN1 w0.094: v2(75.13,23.6) 74.73,23.6 74.57,23.44 74.57,22.34 74.44,22.22 73.95,22.22 73.82,22.34 73.82,23.54 74.12,23.84 74.12,24.14 73.82,24.44 73.82,25.83 73.84,25.85 73.84,26.7 73.82,26.71 73.82,45.89 74.76,46.83 74.76,54.07 74.91,54.22 75.26,54.22 75.35,54.31 75.35,54.6 75.26,54.69 74.86,54.69 74.76,54.78 74.76,55.07 74.86,55.16 75.26,55.16 75.35,55.25 75.35,55.54 75.26,55.63 74.86,55.63 74.76,55.72 74.76,56 74.86,56.1 75.26,56.1 75.35,56.19 75.35,56.47 75.26,56.57 74.86,56.57 74.76,56.66 74.76,56.94 74.86,57.04 75.26,57.04 75.35,57.13 75.35,57.41 75.26,57.51 74.86,57.51 74.76,57.6 74.76,57.99 84.89,68.12 84.89,76.27 85.63,77.01 v2(85.63,77.97)
  BOTTOM w0.076: UH1.BT8 87.56,78.38 87.12,77.94 85.66,77.94 v2(85.63,77.97)
  BOTTOM w0.114: v2(75.13,23.6) 74.41,22.88 JDIMM2.16
DDR_B_D7: length 73.2
  IN1 w0.094: v2(86.94,78.67) 87.49,78.13 87.49,77.04 85.48,75.04 85.48,67.81 76.26,58.59 76.26,47.1 75.55,46.39 75.55,45.85 75.45,45.75 74.88,45.75 74.79,45.66 74.79,45.38 74.88,45.28 75.68,45.28 75.8,45.16 75.8,44.94 75.68,44.81 74.61,44.81 74.48,44.69 74.48,44.47 74.61,44.34 75.75,44.34 75.88,44.22 75.88,44 75.75,43.87 74.64,43.87 74.51,43.75 74.51,43.53 74.64,43.41 75.45,43.41 75.55,43.31 75.55,42.18 74.46,41.09 74.46,30.97 74.57,30.85 74.89,30.85 75.02,30.73 75.02,30.36 74.89,30.23 74.59,30.23 74.46,30.1 74.46,29.49 74.57,29.37 74.91,29.37 75.04,29.25 75.04,28.88 74.91,28.75 74.57,28.75 74.46,28.64 74.46,28.24 74.57,28.13 74.91,28.13 75.04,28 75.04,27.63 74.91,27.51 74.57,27.51 74.46,27.39 74.46,25.97 74.61,25.82 74.91,25.82 v2(75.14,26.05)
  BOTTOM w0.076: v2(86.94,78.67) 86.95,78.67 87.39,79.11 88.68,79.11 88.78,79.01 89.13,79.01 UH1.BN8
  BOTTOM w0.114: JDIMM2.17 74.66,26.54 v2(75.14,26.05)
DDR_B_D8: length 68.5
  IN1 w0.094: v2(77.1,23.61) 76.87,23.61 76.67,23.41 76.49,23.41 76.11,23.79 76.11,31.13 75.68,31.56 75.68,40.68 77.02,42.02 77.02,44.65 77.67,45.3 77.67,58.45 86.51,67.3 86.51,74.21 87.83,75.53 87.83,75.87 88.24,76.28 88.24,76.37 89.71,77.84 89.71,78.45 89.43,78.72 89.43,79.12 90.12,79.8 v2(90.5,79.8)
  BOTTOM w0.089: v2(90.5,79.8) 90.83,80.14 UH1.BL11
  BOTTOM w0.114: JDIMM2.28 77.41,21.69 77.61,21.88 77.61,23.21 77.2,23.61 v2(77.1,23.61)
DDR_B_D9: length 68.4
  IN1 w0.094: v2(77.1,24.88) 76.97,24.88 76.82,24.73 76.55,24.73 76.43,24.86 76.43,31.26 76.14,31.54 76.14,31.54 76.01,31.68 76.01,32.76 76.13,32.88 76.34,32.88 76.46,33.01 76.46,33.38 76.34,33.51 76.13,33.51 76.01,33.62 76.01,34.01 76.13,34.13 76.42,34.13 76.53,34.24 76.53,34.64 76.42,34.75 76.13,34.75 76.01,34.87 76.01,35.18 76.13,35.3 76.41,35.3 76.53,35.42 76.53,37.06 76.65,37.18 76.73,37.18 76.84,37.29 76.84,37.69 76.73,37.8 76.65,37.8 76.53,37.92 76.53,38.31 76.65,38.42 76.73,38.42 76.84,38.54 76.84,38.93 76.73,39.05 76.65,39.05 76.53,39.16 76.53,39.55 76.65,39.67 76.73,39.67 76.84,39.78 76.84,40.18 76.73,40.29 76.49,40.29 76.38,40.4 76.38,40.86 76.49,40.97 77.19,40.97 77.33,41.12 77.33,44.52 77.96,45.15 77.96,58.33 86.81,67.17 86.81,69.77 87.42,70.39 87.42,74.65 88.22,75.44 88.22,75.88 88.43,76.09 88.43,76.29 90.09,77.94 90.09,78.58 v2(90.51,79)
  BOTTOM w0.089: v2(90.51,79) 90.51,78.94 UH1.BL8
  BOTTOM w0.114: v2(77.1,24.88) 77.18,24.88 77.66,25.36 JDIMM2.29
DDR_B_D10: length 68.4
  IN1 w0.094: v2(80.67,24.74) 80.12,25.28 80.12,28.36 80.69,28.93 80.69,32 80.6,32.09 80.27,32.09 80.17,32.18 80.17,32.47 80.27,32.56 80.6,32.56 80.69,32.65 80.69,32.94 80.6,33.03 80.27,33.03 80.17,33.12 80.17,33.41 80.27,33.5 80.6,33.5 80.69,33.59 80.69,33.88 80.6,33.97 80.27,33.97 80.17,34.06 80.17,34.35 80.27,34.44 80.6,34.44 80.69,34.53 80.69,34.82 80.6,34.91 80.27,34.91 80.17,35 80.17,35.29 80.27,35.38 80.43,35.38 80.55,35.51 80.55,35.72 80.43,35.85 80.27,35.85 80.17,35.94 80.17,36.22 80.27,36.32 80.4,36.32 80.53,36.45 80.53,36.66 80.4,36.79 80.27,36.79 80.17,36.88 80.17,39.98 81.09,40.9 81.09,53.23 80.58,53.74 80.58,57.16 83.3,59.88 84.16,59.88 89.94,65.66 89.94,70.01 90.52,70.59 90.52,74.54 90.86,74.88 90.86,76.37 91.79,77.3 91.79,78.24 v2(92.17,78.62)
  BOTTOM w0.089: UH1.BJ8 91.85,78.3 v2(92.17,78.62)
  BOTTOM w0.114: v2(80.67,24.74) 81.08,25.15 81.08,26.75 80.66,27.17 JDIMM2.41
DDR_B_D11: length 68.4
  IN1 w0.094: v2(92.17,79.27) 91.56,78.66 91.56,77.34 90.68,76.46 90.68,75.29 89.57,74.18 89.57,69.21 89.06,68.7 89.06,66.11 80.24,57.28 80.24,53.31 80.35,53.19 80.58,53.19 80.69,53.08 80.69,52.68 80.58,52.57 80.35,52.57 80.24,52.45 80.24,52.06 80.35,51.95 80.58,51.95 80.69,51.83 80.69,51.44 80.58,51.32 80.35,51.32 80.24,51.21 80.24,50.82 80.35,50.7 80.58,50.7 80.69,50.59 80.69,50.19 80.58,50.08 80.48,50.08 80.24,49.84 80.24,40.8 79.8,40.36 79.8,24.65 79.9,24.56 80.03,24.56 80.12,24.47 80.12,24.18 80.03,24.09 79.9,24.09 79.8,24 79.8,23.62 79.96,23.47 v2(80.67,23.47)
  BOTTOM w0.089: v2(92.17,79.27) 92.04,79.27 UH1.BJ10
  BOTTOM w0.114: JDIMM2.42 80.91,21.54 81.24,21.87 81.24,22.89 v2(80.67,23.47)
DDR_B_D12: length 68.5
  IN1 w0.094: v2(90.51,80.58) 90.51,80.51 89.23,79.23 89.23,78.91 88.01,77.68 88.01,76.76 87.29,76.04 87.29,75.75 86.21,74.67 86.21,67.42 77.33,58.54 77.33,45.38 76.72,44.77 76.72,42.18 75.36,40.82 75.36,31.44 75.79,31 75.79,23.64 v2(77.09,22.34)
  BOTTOM w0.076: v2(90.51,80.58) 90.83,80.9 UH1.BL12
  BOTTOM w0.114: v2(77.09,22.34) 77.06,22.32 76.96,22.32 76.41,21.77 JDIMM2.24
DDR_B_D13: length 68.4
  IN1 w0.094: v2(77.12,26.15) 76.87,26.15 76.74,26.28 76.74,27.85 76.87,27.98 77.45,27.98 77.58,28.11 77.58,28.41 77.45,28.53 76.9,28.53 76.77,28.66 76.77,29.03 76.9,29.16 77.57,29.16 77.68,29.27 77.68,30.04 77.55,30.16 76.87,30.16 76.74,30.29 76.74,31.36 76.44,31.66 76.44,31.87 76.62,32.04 77.55,32.04 77.67,32.17 77.67,32.45 77.55,32.58 76.92,32.58 76.79,32.71 76.79,33.01 76.92,33.14 77.52,33.14 77.65,33.26 77.65,33.54 77.52,33.67 76.98,33.67 76.85,33.79 76.85,34.17 76.96,34.29 77.07,34.29 77.17,34.38 77.17,34.82 77.07,34.91 76.96,34.91 76.85,35.02 76.85,35.52 76.96,35.64 77.05,35.64 77.17,35.75 77.17,36.15 77.05,36.26 76.96,36.26 76.85,36.37 76.85,36.77 76.96,36.88 77.05,36.88 77.17,37 77.17,40.53 77.3,40.66 77.5,40.66 77.63,40.78 77.63,44.35 77.89,44.61 77.89,44.62 78.26,44.99 78.26,58.1 87.1,66.94 87.1,69.64 87.61,70.16 87.61,73.32 87.74,73.45 87.74,74.5 88.64,75.4 88.64,75.79 88.78,75.94 88.78,76.32 90.55,78.08 v2(90.55,78.18)
  BOTTOM w0.089: UH1.BL7 90.55,78 v2(90.55,78.18)
  BOTTOM w0.114: v2(77.12,26.15) 77.05,26.08 76.72,26.08 76.54,26.25 76.54,26.43 76.66,26.55 JDIMM2.25
DDR_B_D14: length 68.5
  IN1 w0.094: v2(80.67,22.2) 79.38,23.48 79.38,40.36 79.92,40.9 79.92,41.31 79.82,41.41 79.63,41.41 79.53,41.5 79.53,41.78 79.63,41.87 79.82,41.87 79.92,41.97 79.92,42.25 79.82,42.34 79.63,42.34 79.53,42.44 79.53,42.72 79.63,42.81 79.82,42.81 79.92,42.91 79.92,43.19 79.82,43.28 79.56,43.28 79.44,43.41 79.44,43.63 79.56,43.75 79.82,43.75 79.92,43.85 79.92,57.41 88.76,66.26 88.76,68.9 89.27,69.42 89.27,74.28 89.95,74.96 89.95,76.31 91.37,77.73 91.37,78.77 91.81,79.2 91.81,79.55 v2(92.17,79.92)
  BOTTOM w0.089: UH1.BJ11 92.04,79.92 v2(92.17,79.92)
  BOTTOM w0.114: v2(80.67,22.2) 79.91,21.44 JDIMM2.38
DDR_B_D15: length 68.4
  IN1 w0.094: v2(92.17,77.97) 92.17,77.37 91.63,76.82 91.63,75.09 90.84,74.31 90.84,73.72 90.84,73.71 90.84,70.46 90.24,69.86 90.24,65.45 83.9,59.12 83.77,59.12 83.69,59.19 83.51,59.19 83.36,59.04 83.36,58.86 83.43,58.78 83.43,58.65 83.24,58.45 83.1,58.45 82.91,58.65 82.77,58.65 82.57,58.45 82.57,58.31 82.77,58.12 82.77,57.98 82.57,57.79 82.44,57.79 82.24,57.98 82.11,57.98 81.91,57.78 81.91,57.65 82.1,57.45 82.1,57.32 81.91,57.12 81.77,57.12 81.58,57.32 81.44,57.32 81.24,57.12 81.24,56.98 81.44,56.79 81.44,56.65 81.21,56.43 81.21,56.2 81.32,56.09 81.75,56.09 81.85,56 81.85,55.72 81.75,55.62 81.09,55.62 80.96,55.5 80.96,55.28 81.09,55.15 81.75,55.15 81.85,55.06 81.85,54.78 81.75,54.68 81.04,54.68 80.91,54.56 80.91,54.19 81.04,54.07 81.23,54.07 81.39,53.91 81.39,40.45 81.01,40.07 81.01,39.58 80.92,39.49 80.6,39.49 80.5,39.39 80.5,39.11 80.6,39.02 80.92,39.02 81.01,38.92 81.01,38.64 80.92,38.55 80.6,38.55 80.5,38.45 80.5,38.17 80.6,38.08 80.92,38.08 81.01,37.98 81.01,37.7 80.92,37.61 80.6,37.61 80.5,37.51 80.5,37.23 80.6,37.14 80.92,37.14 81.01,37.04 81.01,33.32 81.2,33.13 81.2,26.54 v2(80.67,26.01)
  BOTTOM w0.089: UH1.BJ7 91.85,77.65 v2(92.17,77.97)
  BOTTOM w0.114: v2(80.67,26.01) 80.37,26.01 79.66,26.72 JDIMM2.37
DDR_B_D16: length 67.5
  IN1 w0.094: v2(94,80.56) 93.5,80.05 93.5,79.83 92.6,78.94 92.6,77.14 92.39,76.93 92.39,74.5 91.36,73.47 91.36,70.24 90.97,69.85 90.97,65.04 82.72,56.79 82.72,54.43 82.31,54.02 82.31,40.17 81.93,39.8 81.93,24.99 81.7,24.76 81.7,24.15 81.92,23.92 82.19,23.92 v2(82.48,24.21)
  BOTTOM w0.089: v2(94,80.56) 93.86,80.56 UH1.BG11
  BOTTOM w0.114: JDIMM2.50 82.91,23.79 v2(82.48,24.21)
DDR_B_D17: length 67.2
  IN1 w0.076: 93.45,77.67 93.45,78.32 93.64,78.52 93.64,79.56 v2(94,79.92)
  IN1 w0.094: v2(82.46,26.14) 82.51,26.09 82.7,26.09 82.82,26.21 82.82,27.2 82.73,27.3 82.32,27.3 82.23,27.39 82.23,27.67 82.32,27.77 82.73,27.77 82.82,27.86 82.82,28.14 82.73,28.24 82.32,28.24 82.23,28.33 82.23,28.61 82.32,28.71 82.73,28.71 82.82,28.8 82.82,29.08 82.73,29.18 82.32,29.18 82.23,29.27 82.23,29.55 82.32,29.65 82.73,29.65 82.82,29.74 82.82,30.02 82.73,30.12 82.32,30.12 82.23,30.21 82.23,30.49 82.32,30.59 82.69,30.59 82.81,30.71 82.81,30.98 82.69,31.11 82.36,31.11 82.25,31.22 82.25,35.26 82.36,35.38 82.64,35.38 82.76,35.5 82.76,35.87 82.64,36 82.36,36 82.25,36.11 82.25,39.62 82.67,40.04 82.67,53.86 83.04,54.23 83.04,56.68 91.34,64.98 91.34,69.77 91.68,70.11 91.68,73.31 92.57,74.2 92.57,76.8 93.45,77.67
  BOTTOM w0.089: v2(94,79.92) 93.87,79.92 UH1.BG10
  BOTTOM w0.114: JDIMM2.49 82.66,27.28 82.92,27.02 82.92,26.24 82.77,26.09 82.51,26.09 v2(82.46,26.14)
DDR_B_D18: length 67.4
  IN1 w0.076: 95.46,78.52 95.46,79.98 v2(94.9,80.54)
  IN1 w0.094: 95.46,78.52 95.69,78.29 95.69,77.52 94.93,76.76 94.93,69.65 94.48,69.2 94.48,62.53 92.88,60.92 92.74,60.92 92.55,61.11 92.42,61.11 92.22,60.91 92.22,60.77 92.41,60.58 92.41,60.45 92.21,60.25 92.08,60.25 91.89,60.44 91.76,60.44 91.56,60.24 91.56,60.11 91.75,59.92 91.75,59.79 87.16,55.2 87.16,48.58 86.06,47.48 86.06,32.66 86.24,32.48 86.24,28.17 86.46,27.95 86.46,23.22 v2(85.73,22.49)
  BOTTOM w0.089: UH1.BF11 94.75,80.54 v2(94.9,80.54)
  BOTTOM w0.114: JDIMM2.62 85.91,21.51 85.73,21.69 v2(85.73,22.49)
DDR_B_D19: length 67.2
  IN1 w0.094: v2(85.73,26.48) 85.65,26.57 85.65,32.15 85.47,32.33 85.47,47.73 86.52,48.78 86.52,52.62 86.43,52.72 86.12,52.72 85.99,52.84 85.99,53.06 86.12,53.19 86.43,53.19 86.52,53.28 86.52,53.56 86.43,53.66 85.76,53.66 85.63,53.78 85.63,54 85.76,54.13 86.43,54.13 86.52,54.22 86.52,54.5 86.43,54.6 86.04,54.6 85.91,54.72 85.91,54.94 86.04,55.07 86.43,55.07 86.52,55.16 86.52,55.7 86.16,56.06 86.16,56.19 86.36,56.39 86.49,56.39 86.85,56.03 86.99,56.03 87.19,56.23 87.19,56.36 86.83,56.73 86.83,56.86 87.02,57.06 87.16,57.06 87.52,56.7 87.65,56.7 87.85,56.9 87.85,57.03 87.49,57.39 87.49,57.52 87.69,57.72 87.82,57.72 88.18,57.36 88.32,57.36 88.52,57.56 88.52,57.69 88.16,58.06 88.16,58.19 88.35,58.39 88.49,58.39 88.85,58.03 88.98,58.03 89.18,58.23 89.18,58.36 88.91,58.63 88.91,58.94 93.89,63.92 93.89,69.31 93.81,69.38 93.81,71.27 93.87,71.33 93.87,76.26 95.29,77.68 95.29,78.12 94.9,78.51 v2(94.9,78.63)
  BOTTOM w0.089: UH1.BF8 94.8,78.63 v2(94.9,78.63)
  BOTTOM w0.114: v2(85.73,26.48) 86.16,26.91 JDIMM2.63
DDR_B_D20: length 67.2
  IN1 w0.094: v2(82.48,22.94) 82.75,22.67 82.99,22.67 83.19,22.88 83.19,23.1 83.1,23.2 83.1,24.88 83.42,25.21 83.42,31.52 82.88,32.05 82.88,32.28 82.98,32.37 83.3,32.37 83.4,32.47 83.4,32.75 83.3,32.84 82.98,32.84 82.88,32.94 82.88,33.22 82.98,33.31 83.3,33.31 83.4,33.41 83.4,33.69 83.3,33.78 82.98,33.78 82.88,33.88 82.88,34.61 83,34.72 83.28,34.72 83.39,34.83 83.39,36.51 83.28,36.62 83,36.62 82.88,36.74 82.88,39.3 83.4,39.82 83.4,48.64 83.65,48.89 83.65,56.45 91.93,64.73 91.93,69.47 92.31,69.85 92.31,71.74 93.04,72.46 93.04,76.58 94,77.54 v2(94,77.97)
  BOTTOM w0.089: UH1.BG7 93.87,77.97 v2(94,77.97)
  BOTTOM w0.114: v2(82.48,22.94) 82.04,22.5 82.04,21.51 81.91,21.38 JDIMM2.46
DDR_B_D21: length 67.1
  IN1 w0.076: v2(94,78.62) 94,78.49 93.62,78.11 93.62,77.49
  IN1 w0.094: v2(82.47,24.87) 82.64,24.87 83.12,25.34 83.12,31.31 82.99,31.44 82.69,31.44 82.56,31.56 82.56,34.96 82.68,35.08 82.95,35.08 83.07,35.19 83.07,36.19 82.94,36.31 82.69,36.31 82.56,36.44 82.56,39.52 82.97,39.92 82.97,48.71 83.36,49.1 83.36,49.32 83.26,49.42 83.06,49.42 82.97,49.51 82.97,49.79 83.06,49.89 83.26,49.89 83.36,49.98 83.36,50.26 83.26,50.36 83.06,50.36 82.97,50.45 82.97,50.73 83.06,50.83 83.26,50.83 83.36,50.92 83.36,51.2 83.26,51.3 83.06,51.3 82.97,51.39 82.97,51.67 83.06,51.77 83.26,51.77 83.36,51.86 83.36,52.14 83.26,52.24 83.06,52.24 82.97,52.33 82.97,52.61 83.06,52.71 83.26,52.71 83.36,52.8 83.36,53.05 83.26,53.14 83.09,53.14 82.97,53.27 82.97,53.49 83.09,53.61 83.26,53.61 83.36,53.71 83.36,56.58 91.64,64.86 91.64,69.62 92,69.98 92,71.87 92.74,72.61 92.74,74.11 92.86,74.23 92.86,76.72 93.62,77.49
  BOTTOM w0.089: UH1.BG8 93.87,78.62 v2(94,78.62)
  BOTTOM w0.114: JDIMM2.45 81.66,27.23 81.87,27.01 81.87,25.26 82.27,24.87 v2(82.47,24.87)
DDR_B_D22: length 67.4
  IN1 w0.076: 95.27,78.42 95.27,79.57 v2(94.92,79.92)
  IN1 w0.094: 95.27,78.42 95.49,78.21 95.49,77.59 94.06,76.16 94.06,71.12 94.05,71.12 94.05,69.52 94.19,69.38 94.19,63.8 90.02,59.64 90.02,59.5 90.42,59.11 90.42,58.98 90.22,58.78 90.08,58.78 89.69,59.17 89.56,59.17 89.36,58.97 89.36,58.84 89.75,58.45 89.75,58.31 86.83,55.39 86.83,48.66 85.77,47.6 85.77,32.45 85.94,32.27 85.94,27.74 86.14,27.55 86.14,26.06 86.14,24.05 86.02,23.94 v2(85.73,23.94)
  BOTTOM w0.089: v2(94.92,79.92) 94.79,79.92 UH1.BF10
  BOTTOM w0.114: v2(85.73,23.94) 85.3,23.51 85.3,22.15 84.91,21.75 JDIMM2.58
DDR_B_D23: length 67.3
  IN1 w0.094: v2(94.92,77.97) 94.92,77.57 93.69,76.34 93.69,71.42 93.59,71.32 93.59,64.05 85.33,55.78 85.33,53.31 85.42,53.22 85.56,53.22 85.68,53.09 85.68,52.88 85.56,52.75 85.42,52.75 85.33,52.65 85.33,52.37 85.42,52.28 86.12,52.28 86.22,52.18 86.22,51.9 86.12,51.81 85.42,51.81 85.33,51.71 85.33,51.43 85.42,51.34 86.12,51.34 86.22,51.25 86.22,50.96 86.12,50.87 85.42,50.87 85.33,50.78 85.33,50.49 85.42,50.4 86.12,50.4 86.22,50.31 86.22,50.02 86.12,49.93 85.42,49.93 85.33,49.84 85.33,49.55 85.42,49.46 86.12,49.46 86.22,49.37 86.22,49.08 86.12,48.99 85.42,48.99 85.33,48.9 85.33,48.01 85.17,47.85 85.17,32.2 85.23,32.15 85.23,25.79 v2(85.73,25.29)
  BOTTOM w0.089: UH1.BF7 94.79,77.97 v2(94.92,77.97)
  BOTTOM w0.114: JDIMM2.59 85.16,25.86 v2(85.73,25.29)
DDR_B_D24: length 66
  IN1 w0.076: v2(96.75,80.56) 96.2,80.01 96.2,78.53
  IN1 w0.094: 96.2,78.53 95.93,78.26 95.93,76.64 95.21,75.92 95.21,69.5 94.98,69.27 94.98,66.94 95.21,66.71 95.21,62.22 87.97,54.98 87.97,48.25 86.81,47.09 86.81,33.48 87.19,33.1 87.19,28.26 87.19,28.25 87.19,23.58 v2(87.9,22.87)
  BOTTOM w0.089: UH1.BC11 96.6,80.56 v2(96.75,80.56)
  BOTTOM w0.114: JDIMM2.70 87.91,21.81 87.82,21.9 87.82,22.79 v2(87.9,22.87)
DDR_B_D25: length 65.6
  IN1 w0.094: v2(87.9,26.67) 87.92,26.68 87.92,33.42 87.44,33.9 87.44,41.13 87.55,41.24 88.25,41.24 88.36,41.35 88.36,41.7 88.25,41.81 87.55,41.81 87.44,41.93 87.44,42.27 87.55,42.38 88.25,42.38 88.36,42.5 88.36,42.84 88.25,42.95 87.55,42.95 87.44,43.07 87.44,43.41 87.55,43.53 88.25,43.53 88.36,43.64 88.36,43.98 88.25,44.1 87.55,44.1 87.44,44.21 87.44,44.55 87.55,44.67 88.25,44.67 88.36,44.78 88.36,45.13 88.25,45.24 87.55,45.24 87.44,45.35 87.44,45.7 87.55,45.81 87.84,45.81 88.15,46.12 88.15,46.4 87.74,46.8 87.74,46.98 87.93,47.17 88.11,47.17 88.21,47.07 88.44,47.07 88.63,47.26 88.63,54.78 95.81,61.95 95.81,67.03 95.67,67.17 95.67,75.78 96.33,76.44 96.33,78.09 96.75,78.51 v2(96.75,78.62)
  BOTTOM w0.089: UH1.BC8 96.61,78.62 v2(96.75,78.62)
  BOTTOM w0.114: JDIMM2.71 88.16,26.92 v2(87.9,26.67)
DDR_B_D26: length 65.8
  IN1 w0.076: 97.67,80.56 98.21,80.03 98.21,78.52
  IN1 w0.094: 98.21,78.52 98.65,78.07 98.65,60.64 91.96,53.94 91.96,39.92 91.83,39.79 91.45,39.79 91.32,39.66 91.32,34.66 91.2,34.54 91.2,34.1 91.38,33.91 91.83,33.91 91.94,33.8 91.94,33.41 91.83,33.29 91.22,33.29 91.09,33.17 91.09,32.8 91.22,32.67 91.83,32.67 91.94,32.56 91.94,32.16 91.83,32.05 91.27,32.05 91.15,31.92 91.15,31.55 91.27,31.43 91.83,31.43 91.94,31.31 91.94,30.94 91.81,30.8 91.55,30.8 91.32,30.57 91.32,30.08 91.78,29.63 91.78,26.39 v2(92.19,25.97) ; 97.67,80.56 v2(97.66,80.57)
  BOTTOM w0.089: UH1.BB11 97.53,80.57 v2(97.66,80.57)
  BOTTOM w0.114: JDIMM2.83 91.16,26.65 91.84,25.97 v2(92.19,25.97)
DDR_B_D27: length 65.9
  IN1 w0.094: v2(97.66,77.97) 98,77.63 98,75.81 97.76,75.57 97.76,61.01 91,54.25 91,44.44 90.84,44.27 90.62,44.27 90.51,44.16 90.51,43.76 90.62,43.65 90.89,43.65 91,43.53 91,41.92 90.89,41.8 90.6,41.8 90.49,41.69 90.49,41.29 90.6,41.18 90.89,41.18 91,41.07 91,40.63 89.72,39.34 89.72,34.51 90.15,34.08 90.15,25.61 91.29,24.47 91.29,22.3 91.55,22.04 92.06,22.04 v2(92.19,22.16)
  BOTTOM w0.089: v2(97.66,77.97) 97.53,77.97 UH1.BB7
  BOTTOM w0.114: JDIMM2.84 91.41,22 91.57,22.16 v2(92.19,22.16)
DDR_B_D28: length 66.1
  IN1 w0.076: 96.38,78.4 96.38,79.55 v2(96.75,79.92)
  IN1 w0.094: 96.38,78.4 96.14,78.17 96.14,76.54 95.44,75.84 95.44,69.43 95.3,69.29 95.3,67.03 95.51,66.82 95.51,62.08 88.27,54.84 88.27,48.02 87.12,46.87 87.12,33.7 87.62,33.2 87.62,27.28 87.49,27.14 87.49,24.02 87.56,23.94 87.79,23.94 87.9,24.05 v2(87.9,24.14)
  BOTTOM w0.089: UH1.BC10 96.61,79.92 v2(96.75,79.92)
  BOTTOM w0.114: v2(87.9,24.14) 86.91,23.15 JDIMM2.66
DDR_B_D29: length 65.9
  IN1 w0.094: v2(96.75,77.97) 96.66,77.88 96.66,76.45 95.87,75.67 95.87,69.13 95.91,69.1 95.91,67.19 96.1,66.99 96.1,61.82 88.93,54.64 88.93,54.42 89.02,54.33 89.25,54.33 89.35,54.23 89.35,53.95 89.25,53.86 89.02,53.86 88.93,53.76 88.93,53.48 89.02,53.39 89.25,53.39 89.35,53.29 89.35,53.01 89.25,52.92 89.02,52.92 88.93,52.82 88.93,52.54 89.02,52.45 89.25,52.45 89.35,52.35 89.35,52.07 89.25,51.98 89.02,51.98 88.93,51.88 88.93,51.6 89.02,51.51 89.25,51.51 89.35,51.41 89.35,51.13 89.25,51.04 89.02,51.04 88.93,50.95 88.93,50.66 89.02,50.57 89.25,50.57 89.35,50.48 89.35,50.19 89.25,50.1 89.02,50.1 88.93,50.01 88.93,49.72 89.02,49.63 89.25,49.63 89.35,49.54 89.35,49.25 89.25,49.16 89.02,49.16 88.93,49.07 88.93,48.78 89.02,48.69 89.25,48.69 89.35,48.6 89.35,48.31 89.25,48.22 89.02,48.22 88.93,48.13 88.93,46.82 88.68,46.57 88.68,40.72 88.56,40.6 88,40.6 87.76,40.36 87.76,34 88.22,33.54 88.22,32.53 88.35,32.4 88.35,31.94 88.22,31.81 88.22,31.24 88.35,31.11 88.35,30.55 88.22,30.42 88.22,28.87 88.36,28.73 88.36,25.38 88.22,25.24 88.03,25.24 v2(87.89,25.37)
  BOTTOM w0.089: v2(96.75,77.97) 96.61,77.97 UH1.BC7
  BOTTOM w0.114: JDIMM2.67 87.16,26.11 v2(87.89,25.37)
DDR_B_D30: length 66
  IN1 w0.076: v2(97.66,79.92) 98.03,79.55 98.03,78.39
  IN1 w0.094: v2(92.19,24.7) 91.28,25.61 91.28,26.55 91.17,26.67 90.9,26.67 90.78,26.78 90.78,27.18 90.9,27.29 91.2,27.29 91.32,27.42 91.32,27.79 91.2,27.91 90.9,27.91 90.78,28.03 90.78,28.42 90.9,28.54 91.27,28.54 91.4,28.66 91.4,29.03 91.27,29.16 90.9,29.16 90.78,29.27 90.78,34.6 91,34.82 91,39.78 91.64,40.41 91.64,54.05 98.36,60.77 98.36,75.43 98.38,75.45 98.38,78.04 98.03,78.39
  BOTTOM w0.089: v2(97.66,79.92) 97.53,79.92 UH1.BB10
  BOTTOM w0.114: JDIMM2.79 90.16,26.73 v2(92.19,24.7)
DDR_B_D31: length 66.1
  IN1 w0.094: v2(92.19,23.43) 92.19,23.33 92.06,23.21 91.73,23.21 91.6,23.33 91.6,24.63 90.47,25.77 90.47,34.19 90.04,34.61 90.04,37.46 90.13,37.56 90.54,37.56 90.66,37.68 90.66,37.9 90.54,38.03 90.13,38.03 90.04,38.12 90.04,39.24 91.32,40.52 91.32,54.15 98.06,60.89 98.06,75.43 98.2,75.57 98.2,77.95 97.66,78.49 v2(97.66,78.62)
  BOTTOM w0.089: v2(97.66,78.62) 97.53,78.62 UH1.BB8
  BOTTOM w0.114: v2(92.19,23.43) 90.41,21.66 JDIMM2.80
DDR_B_D32: length 65.9
  IN1 w0.076: v2(113.21,80.57) 112.67,80.03 112.67,78.84 112.48,78.65 112.48,77.66 112.74,77.4 112.74,77.1
  IN1 w0.094: v2(115.98,24) 116.13,24.15 116.13,33.64 116.64,34.15 116.64,39.14 116.88,39.39 116.88,46.09 119.55,48.75 119.55,63.75 112.74,70.57 112.74,77.1
  BOTTOM w0.089: v2(113.21,80.57) 113.07,80.57 UH1.AC11
  BOTTOM w0.114: JDIMM2.174 115.91,21.52 115.98,21.59 v2(115.98,24)
DDR_B_D33: length 65.9
  IN1 w0.094: v2(117.61,24.96) 117.33,24.68 117.21,24.68 117.08,24.8 117.08,28.29 117.2,28.4 117.28,28.4 117.41,28.53 117.41,28.9 117.28,29.03 117.2,29.03 117.08,29.14 117.08,29.53 117.27,29.71 117.27,30.15 117.08,30.34 117.08,30.77 117.27,30.96 117.27,31.4 117.08,31.58 117.08,33.25 117.59,33.75 117.59,34.02 117.7,34.14 117.88,34.14 117.99,34.25 117.99,34.65 117.88,34.76 117.7,34.76 117.59,34.87 117.59,35.27 117.7,35.38 117.92,35.38 118.03,35.5 118.03,35.87 117.89,36 117.7,36 117.59,36.12 117.59,36.51 117.7,36.63 117.88,36.63 117.99,36.74 117.99,37.14 117.88,37.25 117.7,37.25 117.59,37.36 117.59,37.76 117.7,37.87 117.85,37.87 117.97,37.99 117.97,38.38 117.85,38.49 117.7,38.49 117.59,38.61 117.59,38.74 117.83,38.98 117.83,45.7 120.46,48.33 120.46,48.34 120.48,48.37 120.48,64.17 113.49,71.17 113.49,77.5 113.21,77.78 v2(113.21,77.97)
  BOTTOM w0.089: v2(113.21,77.97) 113.07,77.97 UH1.AC7
  BOTTOM w0.114: v2(117.61,24.96) 117.43,24.96 115.66,26.73 JDIMM2.173
DDR_B_D34: length 65.6
  IN1 w0.076: 120.54,67.89 120.11,67.89 115.4,72.6 115.4,76.8 114.99,77.21 114.99,78.21 114.67,78.53 114.67,79.69 114.58,79.77 114.58,80.11 v2(114.12,80.57)
  IN1 w0.094: v2(120.33,25.9) 120.48,25.9 120.74,26.16 120.74,27.83 120.66,27.92 120.66,31.53 121.08,31.94 121.08,33.81 121.52,34.26 121.52,35.43 121.41,35.54 121.14,35.54 121.03,35.66 121.03,36.05 121.14,36.17 121.41,36.17 121.52,36.28 121.52,36.67 121.41,36.79 121.14,36.79 121.03,36.9 121.03,37.3 121.14,37.41 121.35,37.41 121.46,37.53 121.46,39.5 120.45,40.51 120.45,44.61 123.12,47.28 123.12,65.31 120.54,67.89
  BOTTOM w0.089: v2(114.12,80.57) 113.99,80.57 UH1.AA11
  BOTTOM w0.114: v2(120.33,25.9) 120.2,25.9 119.38,26.72 119.38,26.9 119.16,27.12 JDIMM2.187
DDR_B_D35: length 66
  IN1 w0.094: v2(114.12,77.97) 114.24,77.85 114.24,71.88 120.43,65.69 121.39,65.69 122.16,64.92 122.16,47.67 119.49,45 119.49,40.09 119.98,39.61 119.98,36.12 119.78,35.92 119.78,35.56 119.98,35.36 119.98,32.38 119.71,32.1 119.71,29.14 119.25,28.68 119.25,22.56 119.72,22.09 v2(120.34,22.09)
  BOTTOM w0.089: UH1.AA7 113.99,77.97 v2(114.12,77.97)
  BOTTOM w0.114: v2(120.34,22.09) 119.75,22.09 118.91,21.25 JDIMM2.186
DDR_B_D36: length 65.8
  IN1 w0.076: 113.07,77.31 112.67,77.71 112.67,78.61 112.83,78.77 112.83,79.55 v2(113.21,79.92)
  IN1 w0.094: v2(115.29,21.65) 116.45,22.81 116.45,33.51 116.95,34.02 116.95,39.01 117.2,39.26 117.2,45.95 119.87,48.62 119.87,63.88 113.07,70.69 113.07,77.31
  BOTTOM w0.076: UH1.AC10 112.88,79.6 v2(113.21,79.92)
  BOTTOM w0.114: v2(115.29,21.65) 114.91,21.26 JDIMM2.170
DDR_B_D37: length 66.2
  IN1 w0.076: 113.28,77.39 112.84,77.84 112.84,78.14 113.21,78.51 v2(113.21,78.62)
  IN1 w0.094: 113.28,77.39 113.28,70.92 120.19,64.02 120.19,48.49 117.52,45.82 117.52,39.12 117.27,38.88 117.27,33.88 116.77,33.38 116.77,24.53 v2(117.61,23.69)
  BOTTOM w0.089: v2(113.21,78.62) 113.07,78.62 UH1.AC8
  BOTTOM w0.114: JDIMM2.169 114.66,27.02 116.55,25.13 116.55,24.76 v2(117.61,23.69)
DDR_B_D38: length 66
  IN1 w0.076: v2(114.12,79.92) 114.49,79.55 114.49,78.42 114.81,78.1 114.81,77.15 115.2,76.77 115.2,72.57 120.2,67.56
  IN1 w0.094: v2(120.33,24.63) 119.88,25.08 119.88,28.42 120.34,28.88 120.34,31.74 120.62,32.02 120.62,39.87 120.13,40.36 120.13,44.74 122.8,47.41 122.8,65.18 120.42,67.56 120.2,67.56
  BOTTOM w0.089: UH1.AA10 113.99,79.92 v2(114.12,79.92)
  BOTTOM w0.114: JDIMM2.183 118.16,27.36 118.46,27.05 118.74,27.05 119.06,26.74 119.06,26.51 119.25,26.31 119.25,25.71 v2(120.33,24.63)
DDR_B_D39: length 65.8
  IN1 w0.076: 120.37,67.11 114.99,72.48 114.99,76.73 114.61,77.12 114.61,78.01 114.12,78.5 v2(114.12,78.62)
  IN1 w0.094: 120.37,67.11 120.42,67.11 122.48,65.05 122.48,47.54 119.81,44.87 119.81,40.23 120.3,39.74 120.3,32.22 120.02,31.94 120.02,29.01 119.56,28.55 119.56,24.12 v2(120.33,23.36)
  BOTTOM w0.089: UH1.AA8 113.99,78.62 v2(114.12,78.62)
  BOTTOM w0.114: JDIMM2.182 117.91,21.09 120.18,23.36 v2(120.33,23.36)
DDR_B_D40: length 68.1
  IN1 w0.076: 121.7,68.64 120.3,68.64 116.07,72.86 116.07,76.84 115.56,77.36 115.56,77.67 v2(115.96,78.07)
  IN1 w0.094: v2(122.27,26.14) 122.53,26.14 122.9,26.51 122.9,29.43 122.49,29.84 122.49,33.31 123.39,34.21 123.39,40.08 122.63,40.84 122.63,41.57 122.73,41.67 123.33,41.67 123.45,41.79 123.45,42.01 123.33,42.14 122.74,42.14 122.62,42.26 122.62,42.63 122.74,42.75 123.91,42.75 124.02,42.87 124.02,43.26 123.91,43.37 122.75,43.37 122.63,43.49 122.63,43.88 122.75,44 123.91,44 124.02,44.11 124.02,44.47 123.93,44.57 123.23,44.57 123.14,44.66 123.14,44.94 123.23,45.04 123.93,45.04 124.02,45.13 124.02,45.49 124.5,45.97 124.5,65.83 121.7,68.64
  BOTTOM w0.089: v2(115.96,78.07) 115.72,78.07 UH1.W8
  BOTTOM w0.114: v2(122.27,26.14) 121.87,26.14 121.16,26.86 JDIMM2.195
DDR_B_D41: length 68
  IN1 w0.076: v2(115.97,77.46) 115.97,77.23 116.25,76.94 116.25,72.93 120.31,68.88 121.89,68.88
  IN1 w0.094: v2(122.28,22.33) 122.44,22.33 122.99,21.78 123.17,21.78 123.62,22.23 123.62,22.41 122.69,23.35 122.69,25.77 123.21,26.29 123.21,30.04 122.8,30.44 122.8,33.17 124.43,34.8 124.43,40.77 124.15,41.06 123.82,41.06 123.64,41.23 123.64,41.5 123.82,41.68 124.15,41.68 124.43,41.96 124.43,45.33 124.8,45.7 124.8,65.97 121.89,68.88
  BOTTOM w0.076: UH1.W7 115.78,77.65 v2(115.97,77.46)
  BOTTOM w0.114: v2(122.28,22.33) 121.69,22.33 120.91,21.55 JDIMM2.194
DDR_B_D42: length 68.4
  IN1 w0.076: 125.28,68.75 124.52,68.75 122.8,70.47 121.56,70.47 117.88,74.14 117.88,77.05 117.52,77.41 117.52,78.14 117.27,78.39 117.27,78.58 117.23,78.62 117.23,78.76 117.23,78.76 117.23,79.75 117.06,79.92 v2(116.82,79.92)
  IN1 w0.094: 125.28,68.75 127.3,66.72 127.3,33.53 125.92,32.14 125.92,24.4 125.35,23.83 v2(125.09,23.83)
  BOTTOM w0.089: UH1.V10 116.73,79.92 v2(116.82,79.92)
  BOTTOM w0.114: v2(125.09,23.83) 125.5,24.24 125.5,24.27 125.51,24.27 125.51,25.4 124.16,26.75 JDIMM2.207
DDR_B_D43: length 68.3
  IN1 w0.076: 125.52,68.95 124.57,68.95 122.89,70.64 121.62,70.64 118.05,74.21 118.05,77.12 117.69,77.48 117.69,78.22 117.43,78.48 117.43,78.65 117.4,78.69 117.4,80.01 v2(116.84,80.57)
  IN1 w0.094: v2(125.11,22.61) 125.56,23.06 125.56,23.58 126.21,24.24 126.21,31.99 127.62,33.4 127.62,66.85 125.52,68.95
  BOTTOM w0.089: UH1.V11 116.73,80.57 v2(116.84,80.57)
  BOTTOM w0.114: v2(125.11,22.61) 124.66,22.16 124.66,21.26 124.41,21.01 JDIMM2.208
DDR_B_D44: length 68.4
  IN1 w0.076: v2(115.95,79.92) 115.57,79.55 115.57,78.14 115.37,77.93 115.37,77.31 115.87,76.81 115.87,72.81 120.22,68.46 121.45,68.46
  IN1 w0.094: 121.45,68.46 124.21,65.71 124.21,46.72 121.63,44.14 121.63,42.52 121.72,42.43 121.78,42.43 121.9,42.3 121.9,42.08 121.78,41.96 121.72,41.96 121.63,41.86 121.63,40.87 123.05,39.45 123.05,39.43 123.07,39.41 123.07,34.32 122.17,33.41 122.17,29.28 122.26,29.19 122.5,29.19 122.6,29.09 122.6,28.81 122.5,28.72 122.26,28.72 122.17,28.63 122.17,28.34 122.26,28.25 122.5,28.25 122.6,28.16 122.6,27.87 122.5,27.78 122.26,27.78 122.17,27.69 122.17,27.23 121.83,26.89 121.83,25.32 v2(122.27,24.87)
  BOTTOM w0.076: v2(115.95,79.92) 115.62,80.25 UH1.W11
  BOTTOM w0.114: JDIMM2.191 120.16,27.31 121,26.47 121,26.14 v2(122.27,24.87)
DDR_B_D45: length 68.2
  IN1 w0.076: v2(115.08,79.27) 115.41,78.95 115.41,78.21 115.19,77.99 115.19,77.25 115.67,76.78 115.67,72.76 120.23,68.19 121.3,68.19
  IN1 w0.094: 121.3,68.19 123.91,65.58 123.91,47 121.33,44.42 121.33,40.75 122.75,39.32 122.75,34.42 121.85,33.51 121.85,28.19 121.47,27.81 121.47,23.76 121.7,23.54 122.2,23.54 v2(122.27,23.6)
  BOTTOM w0.076: UH1.W10 115.41,79.6 v2(115.08,79.27)
  BOTTOM w0.114: v2(122.27,23.6) 121.37,22.71 121.37,22.51 119.91,21.04 JDIMM2.190
DDR_B_D46: length 68.3
  IN1 w0.076: v2(116.86,78.62) 117,78.62 117.1,78.52 117.1,78.3 117.36,78.04 117.36,77.35 117.72,76.98 117.72,74.08 121.49,70.31 122.63,70.31 124.39,68.54 125.03,68.54
  IN1 w0.094: v2(125.09,25.07) 125.09,25.02 125.36,24.76 125.51,24.76 125.62,24.86 125.62,25.91 125.52,26.01 125.3,26.01 125.21,26.1 125.21,26.38 125.3,26.48 125.52,26.48 125.62,26.57 125.62,26.85 125.52,26.95 125.3,26.95 125.21,27.04 125.21,27.32 125.3,27.42 125.52,27.42 125.62,27.51 125.62,27.79 125.52,27.89 125.3,27.89 125.21,27.98 125.21,28.26 125.3,28.36 125.52,28.36 125.62,28.45 125.62,28.73 125.52,28.83 125.3,28.83 125.21,28.92 125.21,29.2 125.3,29.3 125.52,29.3 125.62,29.39 125.62,32.29 126.99,33.66 126.99,66.59 125.03,68.54
  BOTTOM w0.089: v2(116.86,78.62) 116.73,78.62 UH1.V8
  BOTTOM w0.114: v2(125.09,25.07) 124.2,25.96 124.04,25.96 123.76,25.68 123.59,25.68 123.35,25.92 123.35,26.09 123.63,26.37 123.63,26.53 123.16,27.01 JDIMM2.203
DDR_B_D47: length 68
  IN1 w0.076: 124.78,68.34 124.77,68.34 124.73,68.38 124.25,68.38 122.51,70.12 121.44,70.12 117.55,74.01 117.55,76.92 117.19,77.28 117.19,77.8 117.02,77.97 v2(116.86,77.97)
  IN1 w0.094: v2(124.01,21.88) 124.22,21.88 124.68,21.42 124.86,21.42 125.06,21.61 125.06,21.93 124.62,22.37 124.62,25.31 124.88,25.57 124.88,29.48 125.3,29.9 125.3,32.42 126.69,33.81 126.69,36.69 126.59,36.78 126.37,36.78 126.25,36.91 126.25,37.12 126.37,37.25 126.59,37.25 126.69,37.35 126.69,40.01 126.59,40.1 126.47,40.1 126.38,40.2 126.38,40.48 126.47,40.57 126.59,40.57 126.69,40.67 126.69,40.95 126.59,41.04 126.47,41.04 126.38,41.14 126.38,41.42 126.47,41.51 126.59,41.51 126.69,41.61 126.69,66.44 124.78,68.34
  BOTTOM w0.089: UH1.V7 116.73,77.97 v2(116.86,77.97)
  BOTTOM w0.114: v2(124.01,21.88) 123.41,21.28 JDIMM2.204
DDR_B_D48: length 68.9
  IN1 w0.076: 119.8,72.94 119.57,72.94 118.26,74.24 118.26,77.41 117.99,77.68 117.99,78.26 118.16,78.42 118.16,80.04 v2(118.69,80.57)
  IN1 w0.094: v2(126.41,23.12) 126.97,23.69 126.97,28.94 127.35,29.32 127.35,31.82 128.66,33.14 128.66,67.05 126.1,69.61 124.29,69.61 122.9,71.01 122.51,71.01 120.38,73.14 120,73.14 119.8,72.94
  BOTTOM w0.089: v2(118.69,80.57) 118.56,80.57 UH1.R11
  BOTTOM w0.114: v2(126.41,23.12) JDIMM2.216
DDR_B_D49: length 69
  IN1 w0.076: v2(118.69,77.97) 118.69,77.7 118.8,77.59 118.8,75.16 119.33,74.63 120.09,74.63
  IN1 w0.094: v2(128.17,25.06) 127.87,25.36 127.87,26.34 127.97,26.43 128.04,26.43 128.14,26.52 128.14,26.9 128.04,26.99 127.97,26.99 127.87,27.09 127.87,27.46 127.97,27.56 128.28,27.56 128.41,27.68 128.41,27.99 128.28,28.12 127.97,28.12 127.87,28.22 127.87,28.49 128.3,28.92 128.3,30.57 129.55,31.82 129.55,36.47 129.64,36.57 130.09,36.57 130.18,36.66 130.18,37.04 130.09,37.13 129.64,37.13 129.55,37.23 129.55,37.6 129.64,37.7 130.09,37.7 130.18,37.79 130.18,38.17 130.09,38.26 129.64,38.26 129.55,38.35 129.55,38.73 129.64,38.82 130.09,38.82 130.18,38.92 130.18,39.29 130.09,39.39 129.64,39.39 129.55,39.48 129.55,67.42 126.27,70.7 124.29,70.7 123.02,71.97 122.74,71.97 120.09,74.63
  BOTTOM w0.089: UH1.R7 118.56,77.97 v2(118.69,77.97)
  BOTTOM w0.114: JDIMM2.215 126.16,26.79 127.88,25.06 v2(128.17,25.06)
DDR_B_D50: length 68.9
  IN1 w0.076: v2(119.63,77.94) 120.07,77.51 120.07,77.02 120.96,76.13 120.96,75.95 121.89,75.02 122.34,75.02 122.89,74.48 123.14,74.48 125.2,72.41 125.48,72.41
  IN1 w0.094: v2(129.57,23.62) 129.57,23.56 129.96,23.18 130.18,23.18 130.32,23.31 130.32,28.72 130.59,28.99 130.59,29.68 131.15,30.24 131.46,30.24 131.57,30.36 131.57,31.84 131.46,31.95 131.36,31.95 131.25,32.06 131.25,32.46 131.36,32.57 131.46,32.57 131.57,32.69 131.57,33.08 131.46,33.2 131.36,33.2 131.25,33.31 131.25,33.7 131.36,33.82 131.9,33.82 132.19,34.11 132.19,40.06 131.63,40.63 131.63,67.69 126.91,72.41 125.48,72.41
  BOTTOM w0.089: UH1.P7 119.47,77.96 119.61,77.96 v2(119.63,77.94)
  BOTTOM w0.114: v2(129.57,23.62) 130.01,23.18 130.01,21.56 129.41,20.96 JDIMM2.228
DDR_B_D51: length 68.5
  IN1 w0.076: v2(119.61,80.57) 120.13,80.05 120.13,79.09 120.56,78.65 120.56,77.23 121.48,76.31 121.48,76.14 122.04,75.58 122.56,75.58 122.72,75.73 123.17,75.73 123.43,75.48 123.43,75.28 125.37,73.34 125.67,73.34
  IN1 w0.094: 125.67,73.34 127.24,73.34 132.52,68.06 132.52,41 133.77,39.75 133.77,35.14 133.67,35.05 133.22,35.05 133.12,34.96 133.12,34.58 133.22,34.49 133.67,34.49 133.77,34.39 133.77,33.34 133.21,32.79 133.21,32.17 133.22,32.17 133.22,29.51 132.77,29.07 132.16,29.07 131.25,28.16 131.25,26.24 v2(131.38,26.11)
  BOTTOM w0.089: UH1.P11 119.47,80.57 v2(119.61,80.57)
  BOTTOM w0.114: JDIMM2.229 129.66,27.36 130.91,26.11 v2(131.38,26.11)
DDR_B_D52: length 69.1
  IN1 w0.076: v2(118.69,78.62) 118.69,78.49 118.32,78.12 118.32,77.83 118.63,77.52 118.63,75.09 119.26,74.46 119.9,74.46 119.91,74.45
  IN1 w0.094: v2(128.18,23.79) 128,23.61 127.7,23.61 127.57,23.74 127.57,28.64 127.98,29.06 127.98,30.7 128.68,31.39 128.68,31.99 128.79,32.1 129.12,32.1 129.25,32.23 129.25,67.3 126.18,70.37 124.27,70.37 123.06,71.58 122.78,71.58 119.91,74.45
  BOTTOM w0.089: UH1.R8 118.56,78.62 v2(118.69,78.62)
  BOTTOM w0.114: JDIMM2.211 125.16,26.81 v2(128.18,23.79)
DDR_B_D53: length 68.7
  IN1 w0.076: 120.2,73.73 119.44,73.73 118.43,74.74 118.43,77.49 118.16,77.76 118.16,78.19 118.32,78.35 118.32,79.55 v2(118.69,79.92)
  IN1 w0.094: 120.2,73.73 122.59,71.34 122.95,71.34 124.29,69.99 126.14,69.99 128.96,67.17 128.96,33 127.67,31.71 127.67,29.19 127.27,28.79 127.27,22.83 126.33,21.89 v2(125.92,21.89)
  BOTTOM w0.089: UH1.R10 118.56,79.92 v2(118.69,79.92)
  BOTTOM w0.114: JDIMM2.212 125.41,21.37 v2(125.92,21.89)
DDR_B_D54: length 68.7
  IN1 w0.076: 125.26,72.71 123.33,74.64 122.96,74.64 122.41,75.19 121.96,75.19 121.13,76.02 121.13,76.2 120.23,77.09 120.23,77.99 119.63,78.6 v2(119.63,78.62)
  IN1 w0.094: 125.26,72.71 127.03,72.71 131.92,67.81 131.92,40.75 132.51,40.17 132.51,33.63 132.37,33.49 132.03,33.49 131.89,33.36 131.89,29.7 130.63,28.44 130.63,22.54 130.34,22.24 129.63,22.24 v2(129.52,22.35)
  BOTTOM w0.089: UH1.P8 119.31,78.3 v2(119.63,78.62)
  BOTTOM w0.114: v2(129.52,22.35) 128.41,21.24 JDIMM2.224
DDR_B_D55: length 68.9
  IN1 w0.076: v2(119.61,79.92) 119.96,79.56 119.96,78.98 120.4,78.55 120.4,77.16 121.31,76.24 121.31,76.07 122.03,75.35 122.48,75.35 123.03,74.81 123.52,74.81
  IN1 w0.094: v2(131.38,24.84) 130.95,25.27 130.95,28.31 132.21,29.57 132.21,31.76 132.83,32.38 132.83,33.19 132.92,33.28 133.11,33.28 133.23,33.41 133.23,33.72 133.11,33.84 132.92,33.84 132.83,33.94 132.83,40.27 132.22,40.88 132.22,67.94 127.15,73 125.32,73 123.52,74.81
  BOTTOM w0.089: UH1.P10 119.47,79.92 v2(119.61,79.92)
  BOTTOM w0.114: v2(131.38,24.84) 130.15,26.07 130.15,26.19 129.63,26.71 129.28,26.71 128.66,27.34 JDIMM2.225
DDR_B_D56: length 71.9
  IN1 w0.076: 125.23,75.5 124.82,75.5 124.27,76.05 123.71,76.05 122.57,77.19 121.59,77.19 v2(121.42,77.36)
  IN1 w0.094: 125.23,75.5 126.07,74.66 127.04,74.66 127.79,74.66 133.84,68.61 133.84,53.66 134.07,53.43 134.07,53.28 133.84,53.05 133.84,52.77 133.93,52.67 134.09,52.67 134.18,52.58 134.18,52.2 134.09,52.11 133.93,52.11 133.84,52.01 133.84,51.64 133.93,51.54 134.09,51.54 134.18,51.45 134.18,51.07 134.09,50.98 133.93,50.98 133.84,50.89 133.84,50.51 133.93,50.42 134.09,50.42 134.18,50.32 134.18,49.95 134.09,49.85 133.93,49.85 133.84,49.76 133.84,49.34 133.93,49.25 134.53,49.25 134.66,49.12 134.66,48.81 134.53,48.68 133.93,48.68 133.84,48.59 133.84,48.21 133.93,48.12 134.53,48.12 134.66,47.99 134.66,47.68 134.53,47.56 133.93,47.56 133.84,47.46 133.84,47.09 133.93,46.99 134.53,46.99 134.66,46.87 134.66,46.56 134.53,46.43 133.93,46.43 133.84,46.33 133.84,45.96 133.93,45.86 134.5,45.86 134.63,45.74 134.63,45.43 134.5,45.3 133.93,45.3 133.84,45.21 133.84,44.83 133.93,44.74 134.1,44.74 134.22,44.61 134.22,44.3 134.1,44.17 133.93,44.17 133.84,44.08 133.84,43.7 133.93,43.61 134.53,43.61 134.66,43.48 134.66,43.17 134.53,43.05 133.93,43.05 133.84,42.95 133.84,42.58 133.93,42.48 134.07,42.48 134.16,42.39 134.16,42.01 134.07,41.92 133.93,41.92 133.84,41.82 133.84,41.57 135.21,40.2 135.21,35.07 135.1,34.95 135.1,32.71 134.58,32.2 134.58,28.96 132.7,27.08 v2(132.7,26.68)
  BOTTOM w0.076: v2(121.42,77.36) 121.38,77.39 121.23,77.39 UH1.M7
  BOTTOM w0.114: JDIMM2.237 131.66,27.09 132.2,26.55 132.57,26.55 v2(132.7,26.68)
DDR_B_D57: length 71.8
  IN1 w0.076: 124.73,75.12 124.14,75.72 123.57,75.72 122.98,76.31 121.71,76.31 120.87,77.16 120.87,79.43 121.05,79.61 121.05,80.19 v2(121.43,80.57)
  IN1 w0.094: 124.73,75.12 124.8,75.12 125.86,74.07 127.54,74.07 133.25,68.36 133.25,41.3 134.62,39.93 134.62,35.46 134.5,35.35 134.5,33.03 133.94,32.48 133.94,29.2 132,27.26 132,24.42 131.79,24.22 131.79,23.49 131.71,23.41 131.51,23.41 131.38,23.28 131.38,23 131.55,22.83 131.98,22.83 132.19,22.62 132.19,21.66 131.91,21.38 v2(131.53,21.38)
  BOTTOM w0.089: v2(121.43,80.57) 121.3,80.57 UH1.M11
  BOTTOM w0.114: v2(131.53,21.38) 131.41,21.25 JDIMM2.236
DDR_B_D58: length 72
  IN1 w0.094: v2(135.83,25.75) 136.98,26.9 137.12,26.9 137.49,26.53 137.62,26.53 137.89,26.8 137.89,26.93 137.52,27.3 137.52,27.44 137.78,27.7 137.91,27.7 138.06,27.55 138.24,27.55 138.46,27.77 138.46,27.95 138.31,28.1 138.31,28.23 139.23,29.15 139.23,31 139.76,31.54 139.76,34.79 140.29,35.31 140.29,37.84 138.75,39.38 138.75,40.8 137.63,41.91 137.63,50.68 137.03,51.28 137.03,52.4 137.03,54.51 136.69,54.85 136.69,70.01 127.15,79.54 126.22,79.54 126.14,79.63 125.08,79.63 124.3,80.41 123.75,80.41 123.64,80.3 122.6,80.3 v2(122.32,80.57)
  BOTTOM w0.089: UH1.L11 122.22,80.57 v2(122.32,80.57)
  BOTTOM w0.114: v2(135.83,25.75) 135.38,25.75 134.66,26.48 JDIMM2.249
DDR_B_D59: length 71.9
  IN1 w0.076: 123.78,77.87 123.33,78.32 122.57,78.32 v2(122.3,78.06)
  IN1 w0.094: v2(134.38,22.72) 134.38,24.64 134.78,25.05 134.78,26.21 137.7,29.13 137.7,32.63 137.91,32.83 138.41,32.83 138.64,33.06 138.64,33.34 138.39,33.59 138.39,33.95 138.64,34.2 138.64,35.85 139.33,36.55 139.33,37.45 137.86,38.93 137.86,38.96 137.82,39 137.82,40.37 136.73,41.46 136.73,50.32 136.14,50.91 136.14,52.77 136.14,54.14 135.8,54.49 135.8,69.64 128.15,77.28 125.03,77.28 124.9,77.41 124.9,77.64 124.62,77.92 124.27,77.92 124.22,77.87 123.78,77.87
  BOTTOM w0.102: v2(122.3,78.06) 122.3,78.06 122.23,77.99 122.16,77.99 UH1.L7
  BOTTOM w0.114: JDIMM2.250 134.91,22.19 v2(134.38,22.72)
DDR_B_D60: length 72
  IN1 w0.076: v2(121.43,79.92) 121.22,79.7 121.22,79.55 121.03,79.36 121.03,77.23 121.26,77 122,77 122.02,77.02 122.5,77.02 123.64,75.89 124.21,75.89 124.79,75.3 125.03,75.3
  IN1 w0.094: 125.03,75.3 125.97,74.36 127.16,74.36 127.66,74.36 133.54,68.49 133.54,41.45 134.92,40.07 134.92,35.27 134.8,35.15 134.8,32.84 134.28,32.32 134.28,32.07 134.28,29.12 132.29,27.13 132.29,24.3 132.09,24.09 132.09,23.89 132.27,23.71 132.45,23.71 132.7,23.96 v2(132.7,24.14)
  BOTTOM w0.089: UH1.M10 121.3,79.92 v2(121.43,79.92)
  BOTTOM w0.114: v2(132.7,24.14) 130.77,22.21 130.77,21.25 130.41,20.89 JDIMM2.232
DDR_B_D61: length 71.9
  IN1 w0.076: 125.56,75.81 124.75,75.81 124.34,76.22 123.78,76.22 122.64,77.35 121.96,77.35 121.44,77.88 121.44,77.94
  IN1 w0.094: 121.44,77.94 v2(121.41,77.97) ; 125.56,75.81 125.82,75.56 127.31,75.56 134.14,68.73 134.14,53.8 134.48,53.46 134.48,50.21 134.99,49.7 134.99,40.84 136.14,39.69 136.14,34.61 136.01,34.48 135.54,34.48 135.41,34.36 135.41,34.07 135.51,33.98 135.98,33.98 136.1,33.85 136.1,33.54 135.98,33.42 135.51,33.42 135.41,33.32 135.41,32.95 135.51,32.85 135.83,32.85 135.93,32.76 135.93,32.32 135.8,32.19 135,32.19 134.88,32.07 134.88,31.76 135,31.63 135.37,31.63 135.49,31.5 135.49,31.32 135.37,31.19 135,31.19 134.88,31.07 134.88,30.86 135,30.73 135.37,30.73 135.47,30.63 135.47,30.37 135.37,30.27 135.06,30.27 134.93,30.14 134.93,29.86 135.09,29.71 135.26,29.71 135.37,29.61 135.37,29.3 133.11,27.04 133.11,25.82 v2(132.7,25.41)
  BOTTOM w0.089: v2(121.41,77.97) 121.31,77.97 UH1.M8
  BOTTOM w0.114: JDIMM2.233 130.66,27.43 131.23,26.86 131.44,26.86 131.88,26.42 131.88,25.42 132.15,25.15 132.44,25.15 v2(132.7,25.41)
DDR_B_D62: length 72.3
  IN1 w0.094: v2(122.32,79.92) 122.45,79.92 122.9,79.47 123.5,79.47 123.69,79.65 124.08,79.65 124.29,79.45 124.29,79.04 124.49,78.84 126.28,78.84 126.32,78.88 127.39,78.88 136.39,69.88 136.39,54.73 136.73,54.39 136.73,51.16 137.32,50.56 137.32,50.07 137.32,50.07 137.32,41.77 138.43,40.66 138.43,39.25 139.97,37.71 139.97,35.45 139.43,34.92 139.43,31.84 138.41,30.83 138.41,28.95 135.42,25.95 135.42,24.61 v2(135.36,24.56)
  BOTTOM w0.089: v2(122.32,79.92) 122.22,79.92 UH1.L10
  BOTTOM w0.114: v2(135.36,24.56) 133.66,26.26 JDIMM2.245
DDR_B_D63: length 71.8
  IN1 w0.076: 123.61,78.29 123.39,78.51 122.47,78.51 v2(122.34,78.65)
  IN1 w0.094: v2(134.38,21.45) 134.83,21.9 134.83,24.64 135.1,24.92 135.1,26.08 138.08,29.07 138.08,30.95 138.52,31.38 138.52,32.3 138.96,32.74 138.96,35.72 139.65,36.41 139.65,37.58 138.11,39.12 138.11,40.53 137.03,41.61 137.03,50.19 137.03,50.44 136.43,51.03 136.43,52.65 136.43,54.27 136.09,54.61 136.09,69.76 127.81,78.04 125,78.04 124.9,78.15 124.22,78.15 124.14,78.07 123.83,78.07 123.61,78.29
  BOTTOM w0.102: UH1.L8 122.19,78.62 122.31,78.62 v2(122.34,78.65)
  BOTTOM w0.114: JDIMM2.246 133.91,21.11 134.25,21.45 v2(134.38,21.45)
DDR_B_DQS0: length 72.9
  IN1 w0.094: v2(88.55,79.79) 88.78,79.57 88.78,79.13 88.66,79.01 88.05,79.01 87.51,79.54 86.34,79.54 86.34,79.54 86.09,79.54 84.58,78.03 84.44,78.03 83.66,77.25 83.66,68.66 82.13,67.13 82.01,67.13 81.87,66.99 80.75,66.99 73.52,59.76 73.52,47.44 72.48,46.4 72.48,46.17 72.38,46.08 72.14,46.08 71.89,45.83 71.89,45.36 72.14,45.11 72.32,45.11 72.45,44.98 72.45,44.67 72.32,44.55 72.06,44.55 71.82,44.3 71.82,43.83 72.06,43.58 72.38,43.58 72.48,43.49 72.48,43.11 72.38,43.02 71.89,43.02 71.68,42.81 71.68,42.26 71.89,42.05 72.38,42.05 72.48,41.96 72.48,41.58 72.38,41.49 71.89,41.49 71.68,41.28 71.68,40.74 71.89,40.52 72.27,40.52 72.48,40.32 72.48,40.05 72.07,39.64 72.07,35.72 72.28,35.52 72.28,27.78 72.05,27.56 72.05,26.04 72.55,25.54 v2(72.81,25.54)
  BOTTOM w0.089: UH1.BR9 v2(88.55,79.79)
  BOTTOM w0.114: JDIMM2.13 73.66,27.14 73.53,27.02 73.53,26.9 73.7,26.74 73.7,25.95 73.45,25.7 72.97,25.7 v2(72.81,25.54)
DDR_B_DQS1: length 68.4
  IN1 w0.076: v2(91.33,79.27) 91.26,79.34 91.13,79.34 91.03,79.24 91.03,78.96 91.1,78.89 91.1,78.6
  IN1 w0.094: v2(78.38,22.96) 78.38,22.95 78.54,22.79 78.54,22.64 78.45,22.55 78.17,22.55 77.92,22.81 77.92,26.96 78.04,27.09 78.43,27.09 78.64,27.3 78.64,33.87 78.1,34.41 78.1,39.78 78.56,40.24 78.56,43.97 79.19,44.6 79.19,57.72 88.03,66.56 88.03,69.26 88.55,69.78 88.55,69.84 88.53,69.86 88.53,71.01 88.54,71.02 88.54,71.47 88.53,71.48 88.53,74.32 89.06,74.85 89.62,75.41 89.62,76.45 91.1,77.92 91.1,78.6
  BOTTOM w0.076: UH1.BJ9 91.65,78.88 91.47,78.88 91.33,79.03 v2(91.33,79.27)
  BOTTOM w0.114: v2(78.38,22.96) 78.66,22.68 78.88,22.68 79.16,22.4 79.16,21.31 78.91,21.06 JDIMM2.34
DDR_B_DQS2: length 67.7
  IN1 w0.076: v2(94.89,79.27) 94.82,79.34 94.52,79.34 94.45,79.26 94.45,79.06 94.53,78.98 94.53,77.91 94.54,77.9 94.54,77.85 94.55,77.84 94.55,77.83
  IN1 w0.094: 94.55,77.83 94.55,77.52 93.46,76.43 93.46,71.99 93.08,71.61 93.08,69.59 92.86,69.37 92.86,64.35 84.58,56.07 84.58,48.29 84.33,48.04 84.33,31.93 84.49,31.77 84.49,24.96 84.17,24.65 84.17,23.53 84.28,23.43 84.5,23.43 84.58,23.5 v2(84.58,23.78)
  BOTTOM w0.076: v2(94.89,79.27) 94.55,79.27 94.46,79.18 UH1.BF9
  BOTTOM w0.114: v2(84.58,23.78) 84.23,23.43 84.12,23.43 83.9,23.64 83.9,25.49 84.08,25.67 84.08,27.12 84.16,27.19 JDIMM2.55
DDR_B_DQS3: length 65.9
  IN1 w0.076: v2(97.66,79.27) 97.28,78.89 97.28,77.85 97.28,77.85 97.28,77.8 97.29,77.8 97.29,77.79
  IN1 w0.094: 97.29,77.79 97.29,77.41 97.63,77.07 97.63,76.23 97.02,75.61 97.02,66.48 97.03,66.47 97.03,61.31 90.28,54.55 90.28,46.21 89.61,45.54 89.61,40.26 88.95,39.6 88.95,34.16 89.29,33.82 89.29,24.84 89.53,24.6 90.01,24.6 90.5,24.1 90.5,22.9 90.29,22.68 90.04,22.68 v2(89.84,22.48)
  BOTTOM w0.089: UH1.BB9 97.53,79.27 v2(97.66,79.27)
  BOTTOM w0.114: JDIMM2.76 89.41,21 89.28,21.12 89.28,22.54 89.37,22.62 89.7,22.62 v2(89.84,22.48)
DDR_B_DQS4: length 65.8
  IN1 w0.076: v2(114.12,79.27) 114.12,79.4 113.98,79.54 113.72,79.54 113.59,79.41 113.59,79.23 113.75,79.07 113.75,77.8 113.93,77.62 113.93,77.33 113.94,77.32
  IN1 w0.094: v2(118.5,26) 118.5,25.98 118.25,25.72 118.18,25.72 118.04,25.85 118.04,27.7 118.4,28.05 118.4,29.91 118.49,30 118.69,30 118.93,30.25 118.93,30.73 118.69,30.97 118.48,30.97 118.35,31.1 118.35,31.48 118.48,31.6 118.58,31.6 118.83,31.85 118.83,32.33 118.58,32.57 118.3,32.57 118.17,32.7 118.17,33.01 118.3,33.14 118.7,33.14 119.03,33.46 119.03,38.83 118.76,39.1 118.76,45.31 121.42,47.98 121.42,64.61 120.78,65.26 120.29,65.26 113.94,71.61 113.94,77.32
  BOTTOM w0.089: UH1.AA9 113.99,79.27 v2(114.12,79.27)
  BOTTOM w0.114: JDIMM2.179 117.16,27.14 117.03,27.02 117.03,26.8 117.88,25.95 118.02,25.95 118.12,25.85 118.35,25.85 v2(118.5,26)
DDR_B_DQS5: length 68.3
  IN1 w0.076: v2(115.94,78.68) 115.94,78.76 116.07,78.89 116.24,78.89 116.34,78.79 116.34,77.39 116.55,77.18 116.55,73.13 117.82,71.86 118.31,71.86 120.6,69.57 122.22,69.57 122.39,69.41
  IN1 w0.094: v2(124.03,23.11) 123.7,23.44 123.63,23.44 123.42,23.65 123.42,25.43 123.94,25.95 123.94,30.14 124.14,30.35 124.14,33.17 124.62,33.65 125.02,33.65 125.31,33.93 125.31,41.94 125.64,42.27 125.64,66.16 122.39,69.41
  BOTTOM w0.076: v2(115.94,78.68) 116.07,78.55 116.29,78.55 116.44,78.7 116.44,78.91 UH1.V9
  BOTTOM w0.114: v2(124.03,23.11) 123.8,23.33 123.38,23.33 123.19,23.14 123.19,22.14 122.28,21.24 122.28,21.12 122.41,21 JDIMM2.200
DDR_B_DQS6: length 68.9
  IN1 w0.076: 120.42,74.94 120.41,74.94 120.4,74.94 120.36,74.98 120.21,74.98 120.2,74.97 119.54,74.97 119.26,75.25 119.26,78.93 119.16,79.04 119.16,79.24 119.31,79.39 119.49,79.39 v2(119.61,79.27)
  IN1 w0.094: v2(129.57,25.49) 129.57,25.33 129.46,25.21 129.25,25.21 129.07,25.39 129.07,26.27 129.55,26.75 129.55,29.96 130.48,30.89 130.48,34.88 131.3,35.7 131.3,39.68 130.57,40.41 130.57,67.72 126.61,71.68 125.32,71.68 124.78,71.14 124.5,71.14 120.75,74.88 120.47,74.88 120.42,74.94
  BOTTOM w0.089: UH1.P9 119.15,79.15 119.27,79.27 v2(119.61,79.27)
  BOTTOM w0.114: JDIMM2.221 127.66,27.14 127.53,27.02 127.53,26.82 128.18,26.18 128.51,26.18 129.02,25.67 129.02,25.35 129.13,25.24 129.32,25.24 v2(129.57,25.49)
DDR_B_DQS7: length 71.9
  IN1 w0.076: 126.63,76.51 126.61,76.51 126.59,76.5 124.82,76.5 124.13,77.18 123.94,77.18 123.58,77.54 123.03,77.54 123,77.56 122.99,77.56 122.86,77.69 122.15,77.69 121.94,77.9 121.94,78.81 121.73,79.02 121.54,79.02 121.42,79.14 v2(121.42,79.24)
  IN1 w0.094: 126.63,76.51 127.89,76.51 135.07,69.34 135.07,54.18 135.41,53.84 135.41,50.61 135.99,50.02 135.99,41.17 137.07,40.09 137.07,33.05 136.87,32.84 136.87,29.38 134.05,26.57 134.05,25.38 133.63,24.95 133.63,23.92 133.63,23.75 133.63,23.58 133.59,23.55 133.59,22.69 133.38,22.48 133.15,22.48 133.07,22.4 v2(132.94,22.27)
  BOTTOM w0.089: v2(121.42,79.24) 121.71,78.95 UH1.L9
  BOTTOM w0.114: v2(132.94,22.27) 132.79,22.43 132.57,22.43 132.39,22.24 132.39,21.61 132.78,21.22 132.78,20.95 132.91,20.82 JDIMM2.242
DDR_B_DQS#0: length 72.9
  IN1 w0.094: v2(72.81,26.27) 72.54,26 72.37,26 72.25,26.13 72.25,27.47 72.48,27.7 72.48,35.6 72.27,35.8 72.27,39.56 72.68,39.96 72.68,40.4 72.36,40.73 71.98,40.73 71.88,40.82 71.88,41.19 71.98,41.29 72.47,41.29 72.68,41.5 72.68,42.04 72.47,42.25 71.98,42.25 71.88,42.35 71.88,42.72 71.98,42.82 72.47,42.82 72.68,43.03 72.68,43.57 72.47,43.78 72.15,43.78 72.02,43.91 72.02,44.22 72.15,44.35 72.41,44.35 72.65,44.59 72.65,45.07 72.41,45.31 72.22,45.31 72.1,45.44 72.1,45.75 72.22,45.88 72.47,45.88 72.68,46.09 72.68,46.32 73.72,47.36 73.72,59.68 80.83,66.79 81.79,66.79 81.96,66.79 82.09,66.93 82.22,66.93 83.86,68.57 83.86,77.17 84.53,77.83 84.67,77.83 86.17,79.34 86.26,79.34 86.26,79.34 87.43,79.34 87.96,78.81 88.74,78.81 88.98,79.04 88.98,79.66 89.11,79.79 v2(89.2,79.79)
  BOTTOM w0.089: UH1.BP9 88.88,79.29 88.99,79.19 89.14,79.19 89.24,79.29 89.24,79.76 v2(89.2,79.79)
  BOTTOM w0.114: JDIMM2.11 73.16,27.14 73.29,27.02 73.29,26.8 73.45,26.63 73.45,26.05 73.34,25.95 73.03,25.95 72.81,26.16 v2(72.81,26.27)
DDR_B_DQS#1: length 68.4
  IN1 w0.076: v2(91.29,79.92) 91.29,79.77 90.87,79.35 90.87,78.89 90.93,78.82 90.93,78.67 90.91,78.65 90.91,78.6
  IN1 w0.094: v2(78.36,22.15) 78.18,22.35 78.09,22.35 77.71,22.72 77.71,27.05 77.96,27.29 78.35,27.29 78.44,27.39 78.44,33.79 77.9,34.33 77.9,39.86 78.36,40.32 78.36,44.05 78.99,44.68 78.99,57.8 87.83,66.64 87.83,69.34 88.35,69.86 88.35,71.09 88.36,71.09 88.36,71.4 88.35,71.4 88.35,74.4 89.44,75.49 89.44,76.52 90.91,78 90.91,78.6
  BOTTOM w0.076: UH1.BL9 v2(91.29,79.92)
  BOTTOM w0.114: v2(78.36,22.15) 78.38,22.15 78.66,22.43 78.78,22.43 78.91,22.3 78.91,21.41 78.41,20.91 JDIMM2.32
DDR_B_DQS#2: length 67.7
  IN1 w0.076: 94.37,77.83 94.37,78.91 v2(94,79.27)
  IN1 w0.094: 94.37,77.83 94.37,77.6 93.27,76.51 93.27,72.06 92.89,71.68 92.89,69.66 92.66,69.43 92.66,64.43 84.38,56.15 84.38,48.38 84.13,48.13 84.13,31.84 84.29,31.69 84.29,25.05 83.97,24.73 83.97,23.45 84.19,23.23 84.35,23.23 84.37,23.21 v2(84.57,23.01)
  BOTTOM w0.089: UH1.BG9 93.87,79.27 v2(94,79.27)
  BOTTOM w0.114: v2(84.57,23.01) 84.39,23.18 84.01,23.18 83.66,23.54 83.66,25.59 83.84,25.77 83.84,27.28 83.66,27.46 JDIMM2.53
DDR_B_DQS#3: length 66
  IN1 w0.076: 97.11,77.79 97.11,77.79 97.11,78.9 v2(96.75,79.27)
  IN1 w0.094: v2(89.84,23.07) 90.02,22.88 90.21,22.88 90.3,22.98 90.3,24.02 89.93,24.4 89.44,24.4 89.09,24.75 89.09,33.74 88.75,34.08 88.75,39.69 89.41,40.34 89.41,45.63 90.07,46.3 90.07,54.64 96.83,61.4 96.83,75.69 97.45,76.3 97.45,76.99 97.11,77.33 97.11,77.79
  BOTTOM w0.089: v2(96.75,79.27) 96.61,79.27 UH1.BC9
  BOTTOM w0.114: v2(89.84,23.07) 89.64,22.87 89.26,22.87 89.03,22.64 89.03,21.12 88.91,21 JDIMM2.74
DDR_B_DQS#4: length 65.9
  IN1 w0.076: v2(113.21,79.27) 113.31,79.27 113.48,79.11 113.48,79.11 113.59,79 113.59,77.73 113.77,77.55 113.77,77.33 113.76,77.32
  IN1 w0.094: v2(118.5,25.25) 118.23,25.52 118.09,25.52 117.84,25.77 117.84,27.78 118.2,28.14 118.2,29.99 118.41,30.2 118.6,30.2 118.73,30.33 118.73,30.64 118.6,30.77 118.39,30.77 118.15,31.01 118.15,31.56 118.39,31.8 118.5,31.8 118.63,31.93 118.63,32.24 118.5,32.37 118.21,32.37 117.97,32.61 117.97,33.09 118.21,33.34 118.62,33.34 118.83,33.55 118.83,38.75 118.56,39.02 118.56,45.39 121.22,48.06 121.22,64.55 120.7,65.08 120.21,65.08 113.76,71.53 113.76,77.32
  BOTTOM w0.089: v2(113.21,79.27) 113.07,79.27 UH1.AC9
  BOTTOM w0.114: v2(118.5,25.25) 118.15,25.6 118.02,25.6 117.92,25.7 117.78,25.7 116.78,26.7 116.78,27.02 116.66,27.14 JDIMM2.177
