# Allegro board LAD993PR10-1110A.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on BOTTOM (solid shape): 130.18,126.86 130.18,124.45 130.19,124.45 130.54,124.1 130.85,124.1 131.12,124.37 132.26,124.37 133.04,125.15 136.58,125.15 136.67,125.24 138.61,125.24 138.85,125 138.85,123.51 139.43,122.93 139.43,120.59 139.25,120.41 139.24,120.41 139.14,120.32 137.01,120.32 136.62,120.7 136.62,123.09 136.39,123.32 135.21,123.32 135.15,123.33 134.99,123.49 132.71,123.49 132.55,123.33 131.57,123.33 131.16,122.92 131.16,118.96 130.81,118.61 127.98,118.61 127.67,118.3 127.24,118.3 127.11,118.43 127.11,121.07 127.31,121.28 128.79,121.28 128.91,121.4 128.91,121.54 129.07,121.86 128.91,122.18 128.91,122.19 128.76,122.19 128.58,122.37 128.58,123.21 128.66,123.28 128.66,123.59 128.58,123.66 128.58,123.76 128.53,123.82 127.9,123.82 126.82,124.89 123.2,124.89 123.14,124.96 123.14,126.04 123.2,126.1 123.96,126.1 123.96,126.93 124.03,126.99 128.28,126.99 128.47,127.18 129.87,127.18
GND on BOTTOM (solid shape): outline of 81 points within 186.52,9.39 191.14,18.46
GND on BOTTOM (solid shape): outline of 89 points within 262.38,40.06 270.65,43.93
GND on BOTTOM (solid shape): 152.44,115.2 152.44,112.92 152.11,112.59 150.3,112.59 150.22,112.65 150.14,112.7 149.96,112.71 149.79,112.63 149.73,112.61 149.67,112.63 149.45,112.72 149.22,112.64 149.16,112.62 149.09,112.65 148.85,112.74 148.61,112.65 148.55,112.62 148.49,112.64 148.23,112.71 148,112.59 147.86,112.59 147.84,112.6 147.63,112.67 147.42,112.59 147.35,112.57 147.29,112.6 146.83,112.61 146.74,112.16 146.74,112.05 146.65,112 146.62,112 146.09,111.47 143.88,111.47 143.38,111.96 143.39,111.99 143.13,112.4 142.7,112.17 142.69,112.13 139.46,112.13 138.95,111.62 137.93,111.62 136.92,112.64 136.92,113.78 137.04,113.91 142.45,113.91 143.72,115.18 144.05,115.18 144.07,115.13 144.1,115.09 144.16,115.05 144.23,115 144.26,114.99 144.37,114.98 144.48,114.99 144.52,115 144.54,115.02 144.62,115.08 144.68,115.16 144.75,115.23 147.57,115.23 147.66,115.14 147.66,114.65 147.81,114.49 149.31,114.49 149.54,114.72 149.54,115.19 149.73,115.38 152.26,115.38
GND on BOTTOM (solid shape): 163.58,23.76 163.82,23.76 163.83,23.76 163.96,23.74 164.08,23.79 164.14,23.81 164.2,23.79 164.29,23.71 164.72,23.71 164.88,23.55 164.88,23.09 164.77,22.98 164.77,22.89 164.67,22.79 164.37,22.79 164.3,22.82 164.27,22.89 164.27,22.94 164.22,23.06 164.11,23.14 164.08,23.15 164.08,23.22 164.09,23.24 164.13,23.3 164.14,23.37 164.14,23.42 163.94,23.63 163.73,23.42 163.72,23.28 163.67,23.27 163.65,23.27 163.54,23.3 163.43,23.27 163.13,23.27 163.14,23.31 163.15,23.35 163.15,23.41 162.94,23.61 162.74,23.41 162.74,23.35 162.74,23.32 162.75,23.28 162.76,23.25 162.59,23.08 162.59,22.79 162.09,22.79 162.02,22.82 161.99,22.89 161.99,22.94 161.96,23.05 161.88,23.12 161.82,23.18 161.84,23.27 161.86,23.32 161.87,23.37 161.87,23.42 161.86,23.48 161.83,23.54 161.82,23.63 161.88,23.69 161.93,23.71 161.97,23.74 162.04,23.77 162.11,23.73 162.41,23.61 162.66,23.8 162.77,23.8 162.78,23.79 162.94,23.81 163.05,23.94 163.4,23.94
GND on BOTTOM (solid shape): outline of 196 points within 296.1,36.44 307.49,45.44
GND on BOTTOM (solid shape): outline of 84 points within 295.87,57.6 309.42,95.49
GND on BOTTOM (solid shape): outline of 2876 points within 0.25,0.25 309.42,134.55
GND on BOTTOM (solid shape): outline of 9561 points within 156.3,21.99 180.3,43.77
GND on GND1 (solid shape): 307.59,123.75 308.12,123.53 308.34,123 308.34,115.98 308.43,115.5 308.7,115.1 309.2,114.6 309.36,114.36 309.42,114.08 309.42,112.44 309.34,112.27 309.17,112.19 305.91,112.19 305.91,113.87 307.73,115.69 307.73,122.29 306.84,123.18 297.28,123.18 297.22,123.24 291.19,123.24 291.02,123.17 290.95,123 290.95,118.3 290.43,117.06 289.19,116.54 286.78,116.54 286.65,116.51 286.56,116.41 282.95,109.69 282.94,109.67 282.57,108.82 282.45,107.9 282.45,106.21 282.45,106.21 282.45,104.81 282.47,104.73 282.5,104.66 284.04,102.58 285.44,100.4 288.08,96.9 290.12,90.03 290.87,82.91 290.36,82.91 289.63,89.91 287.63,96.65 285.02,100.12 284.86,100.39 284.69,100.66 283.45,102.54 282.11,104.35 281.99,104.56 281.94,104.81 281.94,107.9 282.09,108.96 282.51,109.93 282.51,109.94 286.12,116.65 286.39,116.94 286.78,117.05 289.19,117.05 290.08,117.41 290.44,118.3 290.44,123 290.66,123.53 291.19,123.75
GND on IN1 (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.42,14.85 172.6,15.66 172.6,16.8 173.2,17.4 177.42,17.4
GND on IN1 (solid shape): 179.72,72.97 179.72,68.93 179.54,68.75 176.16,68.75 175.96,68.95 175.96,72.86 176.26,73.17 179.52,73.17
GND on IN1 (solid shape): 224.55,38.09 224.55,36.06 224.42,35.93 220.1,35.93 219.97,36.06 219.97,38.22 220.23,38.47 224.16,38.47
GND on IN1 (solid shape): 281.44,46.98 281.44,43.04 281.7,42.79 281.7,42.41 281.06,41.77 278.01,41.77 277.63,42.15 277.63,46.47 278.27,47.11 281.31,47.11
GND on IN1 (solid shape): 187.45,46.88 187.45,42.43 187.28,42.26 183.55,42.26 183.27,42.54 183.27,43.67 181.85,45.09 181.85,46.59 182.21,46.95 187.39,46.95
GND on IN1 (solid shape): 76.84,119.62 76.84,112.39 74.56,110.1 72.4,110.1 72.02,110.48 72.02,112.93 72.12,113.18 72.02,113.43 72.02,113.74 72.12,113.99 72.02,114.24 72.02,119.75 72.15,119.88 76.59,119.88
GND on IN1 (solid shape): 298.26,24.98 298.11,24.18 298.79,23.72 306.75,23.72 306.76,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 296.22,21.86 296.09,22 296.09,24.8 296.3,25.02 298.23,25.02
GND on IN1 (solid shape): outline of 195 points within 296.08,36.44 307.49,45.44
GND on IN1 (solid shape): outline of 81 points within 295.87,57.6 309.42,95.49
GND on IN1 (solid shape): outline of 220 points within 96.53,117.34 138.92,127.35
GND on IN1 (solid shape): outline of 2730 points within 0.25,0.26 309.42,134.55
GND on IN2 (solid shape): 179.72,72.97 179.72,68.93 179.54,68.75 176.16,68.75 175.96,68.95 175.96,72.86 176.26,73.17 179.52,73.17
GND on IN2 (solid shape): 186.77,46.94 187.25,46.94 187.44,46.75 187.44,42.62 187.09,42.27 182.23,42.27 181.83,42.67 181.83,46.77 182.01,46.95 186.76,46.95
GND on IN2 (solid shape): 297.63,25.01 298.28,25.01 298.11,24.19 298.79,23.72 306.75,23.72 306.76,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 296.22,21.86 296.09,22 296.09,24.8 296.3,25.02 297.64,25.02
GND on IN2 (solid shape): outline of 194 points within 296.05,36.43 307.49,45.43
GND on IN2 (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,85.35 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 306.7,81.67 302.92,81.67 302.92,81.61 302.66,81.18 302.91,80.73 302.91,66.61 302.87,66.58 302.8,66.53 302.69,65.98 303.14,65.67 306.08,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 306.6,58.42 306.59,58.42 298.79,58.42 298.25,58.17 298.06,57.6 297.41,57.6 297.41,57.6 296.43,57.6 295.87,58.16 295.87,59.81 296.68,60.62 298.97,60.62 299.93,61.59 299.93,64.18 299.58,64.53 299.58,66.69 300.03,67.14 302.16,67.14 302.4,67.38 302.4,79.99 302.21,80.18 301.76,80.18 301.76,80.18 299.91,80.18 299.59,80.5 299.59,81.78 300,82.18 301.76,82.18 301.77,82.18 305.09,82.18 305.83,82.92 305.83,86.73 307.22,88.13 307.22,93.08 306.08,94.22 306.08,95.11 306.45,95.49
GND on IN2 (solid shape): outline of 322 points within 0.25,0.26 309.42,134.55
GND on IN2 (solid shape): outline of 4755 points within 62.52,108.02 143.42,133.73
GND on IN3 (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.16,14.85 172.6,15.41 172.6,17.39 172.73,17.52 177.3,17.52
GND on IN3 (solid shape): 224.55,38.09 224.55,36.06 224.49,36 220.03,36 219.97,36.06 219.97,38.22 220.23,38.47 224.16,38.47
GND on IN3 (solid shape): 179.72,72.97 179.72,68.93 179.61,68.82 176.08,68.82 175.96,68.95 175.96,72.86 176.26,73.17 179.52,73.17
GND on IN3 (solid shape): 281.44,46.98 281.44,43.3 281.7,43.04 281.7,42.41 281.06,41.77 278.01,41.77 277.63,42.15 277.63,46.47 278.27,47.11 281.31,47.11
GND on IN3 (solid shape): 186.77,46.94 187.25,46.94 187.44,46.75 187.44,42.62 187.09,42.27 182.23,42.27 181.83,42.67 181.83,46.77 182.01,46.95 186.76,46.95
GND on IN3 (solid shape): 200.54,71.75 200.83,71.75 200.87,71.7 201.29,71.7 201.33,71.75 203.36,71.75 203.67,71.44 203.67,68.67 203.44,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.97,69.97 198.74,69.74 198.74,68.75 198.43,68.44 195.21,68.44 194.83,68.82 194.83,71.82 195.21,72.2 200.09,72.2
GND on IN3 (solid shape): 298.3,25.02 298.1,24.2 298.79,23.72 306.75,23.72 306.76,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 296.22,21.86 296.09,22 296.09,24.8 296.3,25.02 297.13,25.02 297.13,25.02
GND on IN3 (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,86.15 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 306.84,81.67 302.92,81.67 302.92,81.61 302.66,81.18 302.91,80.73 302.91,66.61 302.87,66.58 302.8,66.53 302.69,65.98 303.14,65.67 306.97,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 306.6,58.42 306.59,58.42 298.79,58.42 298.25,58.17 298.06,57.6 297.41,57.6 297.41,57.6 296.43,57.6 295.87,58.16 295.87,59.81 296.68,60.62 298.97,60.62 299.93,61.59 299.93,64.18 299.58,64.53 299.58,66.69 300.03,67.14 302.19,67.14 302.4,67.35 302.4,80.01 302.23,80.18 301.76,80.18 301.76,80.18 299.89,80.18 299.59,80.48 299.59,81.78 300,82.18 302.92,82.18 302.92,82.18 305.09,82.18 305.83,82.92 305.83,86.73 307.22,88.13 307.22,92.7 305.89,94.03 305.89,94.92 306.45,95.49
GND on IN3 (solid shape): outline of 236 points within 296.02,36.44 307.49,45.44
GND on IN3 (solid shape): outline of 320 points within 0.25,0.26 309.42,134.55
GND on GND2 (solid shape): 307.59,123.75 308.12,123.53 308.34,123 308.34,115.98 308.43,115.5 308.7,115.1 309.2,114.6 309.36,114.36 309.42,114.08 309.42,112.44 309.34,112.27 309.17,112.19 305.91,112.19 305.91,113.87 307.73,115.69 307.73,122.29 306.84,123.18 297.28,123.18 297.22,123.24 291.19,123.24 291.02,123.17 290.95,123 290.95,118.3 290.43,117.06 289.19,116.54 286.78,116.54 286.65,116.51 286.56,116.41 282.95,109.69 282.94,109.67 282.57,108.82 282.45,107.9 282.45,106.21 282.45,106.21 282.45,104.81 282.47,104.73 282.5,104.66 284.04,102.58 285.44,100.4 288.08,96.9 290.12,90.03 290.87,82.91 290.91,82.16 290.94,81.4 290.93,81.16 290.92,80.91 290.42,80.91 290.42,81.16 290.43,81.4 290.4,82.15 290.36,82.89 289.63,89.9 287.63,96.65 285.02,100.12 284.75,100.57 284.47,101.02 283.33,102.71 282.11,104.35 281.99,104.56 281.94,104.81 281.94,107.9 282.09,108.96 282.51,109.93 282.51,109.94 286.12,116.65 286.39,116.94 286.78,117.05 289.19,117.05 290.08,117.41 290.44,118.3 290.44,123 290.66,123.53 291.19,123.75
GND on IN4 (solid shape): 224.55,38.09 224.55,36.06 224.42,35.93 220.1,35.93 219.97,36.06 219.97,38.22 220.23,38.47 224.16,38.47
GND on IN4 (solid shape): 281.44,46.98 281.44,42.92 281.7,42.66 281.7,42.41 281.06,41.77 278.01,41.77 277.63,42.15 277.63,46.47 278.27,47.11 281.31,47.11
GND on IN4 (solid shape): 177.56,17.26 177.56,15.1 177.3,14.85 173.7,14.85 172.6,15.94 172.6,16.76 173.08,17.24 173.09,17.24 173.21,17.36 177.45,17.36
GND on IN4 (solid shape): 179.79,72.88 179.79,69.06 179.64,68.9 176.08,68.9 175.98,69 175.98,72.89 176.26,73.17 179.51,73.17
GND on IN4 (solid shape): 186.76,46.95 187.31,46.95 187.41,46.84 187.41,42.59 187.1,42.28 182.24,42.28 181.83,42.68 181.83,46.57 182.21,46.95 186.76,46.95
GND on IN4 (solid shape): 198.21,71.75 203.36,71.75 203.67,71.44 203.67,68.65 203.49,68.47 203.49,68.44 201.3,68.44 201.05,68.7 201.05,69.84 200.92,69.97 198.97,69.97 198.74,69.74 198.74,68.75 198.43,68.44 195.21,68.44 194.83,68.82 194.83,71.97 195.03,72.18 197.77,72.18
GND on IN4 (solid shape): 297.64,25.01 298.29,25.01 298.11,24.2 298.79,23.72 306.75,23.72 306.76,23.72 307.4,23.72 307.57,23.64 307.65,23.47 307.65,21.86 306.57,21.86 296.22,21.86 296.09,22 296.09,24.8 296.3,25.02 297.64,25.02
GND on IN4 (solid shape): 83.83,119.75 83.83,114.16 83.45,113.78 77.35,113.78 75.45,111.88 75.45,105.78 75.07,105.4 71.76,105.4 71.38,105.78 71.38,107.31 70.49,108.19 70.49,112.39 70.51,112.4 70.51,113.06 70.58,113.13 70.67,113.15 71,112.83 71.34,112.92 71.35,112.94 71.43,112.97 71.5,112.94 72.05,112.96 71.93,113.49 71.87,113.58 71.93,113.67 72.12,113.99 71.93,114.3 71.88,114.38 71.91,114.46 71.94,114.49 71.94,114.52 72.02,114.59 72.02,119.62 72.27,119.88 83.7,119.88
GND on IN4 (solid shape): outline of 161 points within 206.38,62.98 215.66,72.26
GND on IN4 (solid shape): outline of 192 points within 296.1,36.44 307.49,45.43
GND on IN4 (solid shape): 309.17,95.49 309.34,95.41 309.42,95.24 309.42,94.07 309.32,93.7 309.05,93.43 308.35,93.01 307.9,92.55 307.74,91.93 307.74,84.86 307.74,84.48 307.83,84 308.1,83.6 309.26,82.44 309.32,82.36 309.34,82.26 309.34,81.92 309.26,81.75 309.09,81.67 307.24,81.67 303.14,81.67 302.67,81.29 302.91,80.73 302.91,66.61 302.87,66.58 302.8,66.53 302.69,65.98 303.14,65.67 305.55,65.67 309.09,65.67 309.26,65.59 309.34,65.42 309.34,64.48 309.32,64.38 309.26,64.3 307.71,62.75 307.54,62.5 307.49,62.21 307.49,58.67 307.41,58.5 307.24,58.42 305.55,58.42 298.79,58.42 298.25,58.17 298.06,57.6 297.41,57.6 297.41,57.6 296.43,57.6 295.87,58.16 295.87,59.81 296.68,60.62 298.97,60.62 299.93,61.59 299.93,64.18 299.58,64.53 299.58,66.69 300.03,67.14 302.18,67.14 302.4,67.36 302.4,79.99 302.21,80.18 301.76,80.18 301.76,80.18 299.91,80.18 299.59,80.5 299.59,81.78 300,82.18 302.92,82.18 302.92,82.18 305.09,82.18 305.83,82.92 305.83,86.73 307.22,88.13 307.22,92.73 305.85,94.1 305.85,94.88 306.45,95.49
GND on IN4 (solid shape): outline of 683 points within 92.72,116.7 139.2,128.39
GND on IN4 (solid shape): outline of 324 points within 0.25,0.26 309.42,134.55
GND on GND3 (solid shape): 307.59,123.75 308.12,123.53 308.34,123 308.34,115.98 308.43,115.5 308.7,115.1 309.2,114.6 309.36,114.36 309.42,114.08 309.42,112.44 309.34,112.27 309.17,112.19 305.91,112.19 305.91,113.87 307.73,115.69 307.73,122.29 306.84,123.18 297.28,123.18 297.22,123.24 291.19,123.24 291.02,123.17 290.95,123 290.95,118.3 290.43,117.06 289.19,116.54 286.78,116.54 286.65,116.51 286.56,116.41 282.95,109.69 282.94,109.67 282.57,108.82 282.45,107.9 282.45,106.21 282.45,106.21 282.45,104.81 282.47,104.73 282.5,104.66 284.04,102.58 285.44,100.4 288.08,96.9 290.12,90.03 290.87,82.91 290.88,82.72 290.37,82.72 290.36,82.89 289.63,89.9 287.63,96.65 285.02,100.12 284.75,100.57 284.47,101.02 283.33,102.71 282.11,104.35 281.99,104.56 281.94,104.81 281.94,107.9 282.09,108.96 282.51,109.93 282.51,109.94 286.12,116.65 286.39,116.94 286.78,117.05 289.19,117.05 290.08,117.41 290.44,118.3 290.44,123 290.66,123.53 291.19,123.75
GND on TOP: 189.19,60.93 189.09,60.83 189.09,59.91 188.43,59.25 184.54,59.25 184.36,59.43 180.71,59.43 180.48,59.66 180.39,59.66 180.2,59.85 180.2,60.68 180.55,61.03 187.67,61.03 187.77,61.13 187.77,62.3 187.41,62.65 187.41,67.76 186.73,68.44 186.7,68.44 186.45,68.7 186.45,71.8 186.45,72.13 186.92,72.6 189.27,72.6 189.37,72.51 189.37,71.36 189.19,71.19 189.19,61.17
GND on BOTTOM: 169.94,64 174.3,64 175.18,63.11 175.18,62.54 173.82,61.17 173.82,61.02 173.67,60.87 169.71,60.87 169.61,60.98 169.61,63.67
GND on GND1: 285.89,111.92 285.89,103.88
GND on GND1: outline of 270 points within 0.26,0.25 309.41,134.55 ; 3 cut-outs
GND on GND1, GND2, GND3: 301.79,119.2 307.79,119.2
GND on VCC: outline of 137 points within 292.34,21.23 309.34,81.65
GND on VCC: outline of 615 points within 131.58,62.04 214.5,134.53 ; 1 cut-out
GND on VCC: 297.76,0.25 297.23,0.47 297.01,1 297.01,2.59 296.92,3.07 296.65,3.47 293.82,6.3 293.84,6.32 291.17,8.99 291.15,9 290.83,9.19 290.47,9.27 290.4,9.28 288.19,9.28 287.68,9.49 287.47,10 287.47,11.62 287.46,11.64 285.79,13.18 284.12,11.64 284.11,11.57 284.11,10 283.9,9.49 283.39,9.28 277.44,9.28 277.44,9.42 276.85,10.02 276.68,10.02 276.68,13.1 276.9,13.23 276.97,13.48 276.96,13.59 276.92,13.69 276.89,13.74 276.84,13.78 276.85,13.81 276.87,13.84 276.97,14.12 276.82,14.38 277.01,14.8 276.68,15.12 276.68,17.11 276.73,17.2 276.82,17.2 277.04,17.16 277.25,17.26 277.38,17.26 277.63,17.16 277.88,17.26 279.11,17.26 279.46,17.62 280.51,17.62 280.6,17.57 280.6,17.47 280.91,16.93 281.22,17.47 281.22,17.57 281.31,17.62 285.81,17.62 286.6,16.83 288.25,16.83 291.5,13.58 292.26,13.58 292.89,12.94 293.67,12.94 294.27,12.44 294.27,11.05 296.17,9.16 296.33,9.16 297.57,7.92 297.57,7.76 298.48,6.85 308.47,6.85 308.37,6.64 308.34,6.41 308.34,1 308.12,0.47 307.59,0.25
GND on VCC: outline of 90 points within 141.53,41.65 229.09,72.25
GND on VCC: outline of 882 points within 55,21.33 140.47,81.65
GND on VCC: 181.82,46.95 181.82,42.67 182.23,42.26 187.49,42.26 187.49,46.95
GND on GND2: outline of 274 points within 0.26,0.25 309.41,134.55 ; 1 cut-out
GND on GND2, GND3: 285.89,103.88 285.89,111.92
GND on GND3: outline of 595 points within 0.26,0.25 309.41,134.55 ; 1 cut-out
VBATT on TOP (solid shape): 43.82,18.79 43.82,15.61 43.7,15.48 41.28,15.48 41.03,15.74 41.03,18.79 41.16,18.91 43.7,18.91
VBATT on BOTTOM (solid shape): 41.22,18.82 41.22,18.31 41.25,18.28 41.6,17.96 41.96,18.28 41.98,18.31 41.98,18.87 42.19,18.87 42.19,18.87 43.72,18.87 43.8,18.79 43.8,17.29 44.08,17.01 44.08,14.34 43.82,14.09 41.67,14.09 40.9,14.85 40.9,15.74 40.52,16.12 40.01,16.12 39.63,16.5 39.63,18.02 40.48,18.87 41.16,18.87
VCCGT_B+ on TOP (solid shape): 99.83,131.23 99.83,127.63 99.59,127.38 96.81,127.38 96.59,127.17 96.36,127.17 96.15,127.38 95.12,127.38 95.01,127.5 95.01,131.22 95.39,131.6 99.46,131.6
VCCGT_B+ on TOP (solid shape): 65.8,119.24 67.83,119.24 67.83,119.75 71.13,119.75 72.08,118.8 72.08,113.13 71.84,112.89 70.9,112.89 70.71,113.08 70.71,114.2 70.49,114.42 68.34,114.42 68.21,114.54 68.21,115.43 67.95,115.69 66.3,115.69 66.05,115.43 66.05,114.04 65.92,113.91 64.4,113.91 64.14,114.16 64.14,119.5 64.4,119.75 65.8,119.75
VCCGT_B+ on BOTTOM (solid shape): 72.15,118.02 72.15,112.26 72.02,112.13 70.88,112.13 70.88,113.53 70.75,113.66 69.73,113.66 69.61,113.78 69.61,114.04 69.35,114.29 68.34,114.29 68.21,114.42 68.21,115.31 68.08,115.43 66.33,115.43 66.33,115.15 65.92,114.75 64.48,114.75 64.14,115.08 64.14,118.13 64.58,118.56 71.61,118.56
VCCGT_B+ on BOTTOM (solid shape): 99.73,130.78 99.73,129.07 99.67,129.01 99.67,127.47 99.59,127.4 97.88,127.4 97.6,127.12 94.66,127.12 94.59,127.19 94.59,128.23 94.72,128.36 94.74,128.39 96.02,128.39 96.15,128.51 96.15,128.82 96.22,128.89 96.22,129.46 96.32,129.57 96.32,129.57 96.91,130.17 96.91,131.18 97.05,131.32 99.18,131.32
VCCGT_B+ on IN1 (solid shape): outline of 1411 points within 64.27,114.06 99.96,132.71
VCCST on TOP (solid shape): 132.26,96.49 132.26,95.99 132.6,95.66 132.6,93.63 132.34,93.37 131.53,93.37 131.41,93.49 131.41,94.45 131.3,94.55 131,94.55 130.9,94.66 130.9,95.77 130.64,96.03 130.64,96.51 130.79,96.66 132.1,96.66
VCCSTG on BOTTOM (solid shape): 137.3,100.7 137.3,98.31 136.14,97.15 135.78,97.15 135.54,96.91 134.6,96.91 134.55,96.96 134.55,98.06 135.14,98.64 135.14,101.51 135.3,101.67 136.33,101.67
VIN on TOP (solid shape): 22.97,42.26 22.97,42.26 23.15,42.08 23.15,39.68 23.39,39.44 24.07,39.44 24.18,39.36 24.31,39.33 24.33,39.33 24.4,39.27 24.4,38.71 24.36,38.63 24.27,38.61 23.83,38.27 24.27,37.92 24.36,37.9 24.4,37.82 24.4,37.32 24.29,37.21 23.35,37.21 22.79,37.76 18.93,37.76 18.37,37.2 15.94,37.2 15.81,37.33 15.81,39.66 15.94,39.8 15.95,39.8 16.66,40.55 16.6,41.58 16.6,41.59 16.6,41.77 17.16,42.33 22.9,42.33
VIN on BOTTOM (solid shape): 23.26,42.22 23.26,41.17 23.13,41.04 23.13,38.09 22.74,37.71 19.31,37.71 18.81,37.2 18.17,37.2 17.73,36.76 17.63,36.73 17.56,36.8 17.02,36.99 17,36.41 17.04,36.33 17,36.25 16.91,35.83 17.29,35.63 17.37,35.61 17.41,35.53 17.41,34.66 17.16,34.41 16.41,34.41 16.26,34.56 16.26,35.31 16.05,35.52 15.28,35.52 15.12,35.68 15.12,38.95 16,39.82 16.01,39.83 16.35,40.07 16.6,40.42 16.6,40.43 16.77,40.6 16.77,41.52 17.66,42.41 23.07,42.41
+AMP on TOP (solid shape): 268.65,20.81 268.65,20.04 268.92,19.78 270.8,19.78 271.36,19.22 271.97,19.22 272.09,19.09 272.09,18.63 271.97,18.51 267.93,18.51 267.7,18.28 267.33,18.28 267.19,18.42 267.19,19.28 267.94,20.03 267.94,20.78 268.02,20.86 268.6,20.86
+AMP on BOTTOM (solid shape): 259.85,20.14 259.85,19.63 259.85,19.63 259.85,19.52 260.19,19.18 260.19,18.93 260.46,18.66 261.38,18.66 261.45,18.59 261.45,18 261.35,17.9 261.11,17.9 261.04,17.91 260.99,17.92 259.28,17.92 258.93,17.57 258.51,17.57 258.4,17.67 258.4,20.18 258.58,20.36 259.62,20.36
+AMP on BOTTOM (solid shape): 271.36,19.64 271.36,18.3 271.26,18.2 267.95,18.2 267.78,18.02 267.53,18.02 267.42,17.92 265.7,17.92 265.63,17.99 265.63,19.08 265.72,19.17 265.99,19.17 266.04,19.16 266.08,19.15 267.09,19.15 267.35,19.41 267.53,19.41 267.55,19.42 267.85,19.12 269.35,19.12 269.4,19.17 269.4,19.65 269.55,19.8 271.2,19.8
+AMP on IN2 (solid shape): outline of 424 points within 258.66,15.36 269.07,20.35
+CHGRTC on BOTTOM (solid shape): 152.81,18.69 152.81,18.15 153.29,17.67 153.29,16.94 153.25,16.91 152.06,16.91 151.97,17 151.97,18.08 151.76,18.29 151.76,18.81 151.91,18.96 152,18.96 152.05,19.01 152.49,19.01
+DC_IN on BOTTOM (solid shape): outline of 247 points within 5.25,34.41 16.11,41.39
+EDPVDD on TOP (solid shape): outline of 127 points within 60.33,33.52 65.12,42.04
+EDPVDD on BOTTOM (solid shape): 62.11,34.66 63.19,34.66 63.32,34.52 63.32,33.5 63.22,33.39 61.98,33.39 61.73,33.14 61,33.14 60.84,33.29 60.84,34.79 61.02,34.96 61.81,34.96
+FB_PLLAVDD on BOTTOM (solid shape): 149.74,103.21 149.74,100.16 149.57,99.99 147.44,99.99 147.2,100.23 147.2,101.9 147.42,102.13 147.42,103.16 147.85,103.6 149.36,103.6
+FB_PLLAVDD on VCC: outline of 214 points within 147.43,88.53 177,100.83
+GPU_CORE on TOP (solid shape): 163.53,85.11 164.17,84.47 164.28,84.47 164.37,84.45 164.45,84.46 164.48,84.46 164.52,84.43 164.52,83.59 164.4,83.48 163.67,83.48 163.66,83.48 163.17,83.97 163.17,84.94 163.34,85.11 163.51,85.11
+GPU_CORE on TOP (solid shape): 173.77,94.81 173.77,94.5 173.52,94.25 173.39,94.25 173.09,93.94 172.63,93.94 172.4,93.72 172.4,92.9 172.48,92.82 172.48,92.72 172.32,92.56 172.15,92.56 171.97,92.74 171.97,93.89 172.97,94.89 173.68,94.89
+GPU_CORE on TOP (solid shape): 164.11,94.55 164.21,94.55 164.78,93.98 164.78,93.46 164.8,93.44 164.8,92.75 164.68,92.62 164.45,92.62 164.32,92.76 164.32,92.94 164.46,93.09 164.46,93.67 164.11,94.02 163.83,94.02 163.21,94.64 163.21,94.98 163.29,95.06 163.59,95.06
+GPU_CORE on TOP (solid shape): outline of 452 points within 145.55,64.05 173.64,94.06
+GPU_CORE on BOTTOM (solid shape): outline of 141 points within 144.15,63.57 172.5,71.32
+GPU_CORE on BOTTOM (solid shape): outline of 3542 points within 161.84,75.94 175.34,96.51
+GPU_CORE on IN1 (solid shape): 157.91,71.11 160.71,71.11 160.82,71.22 166.09,71.22 166.21,71.1 166.21,70.44 166.78,69.87 168.43,69.87 168.5,69.79 168.5,67.73 168.89,67.34 168.89,64.56 168.77,64.43 145.48,64.43 145.3,64.61 145.3,67.02 147.96,69.68 148.12,69.68 148.55,70.11 148.55,70.17 148.68,70.3 148.68,70.63 149.34,71.3 157.72,71.3
+GPU_CORE on IN1 (solid shape): outline of 6444 points within 154.8,82.46 176.46,98.39
+GPU_CORE on IN2 (solid shape): 156.38,71.64 156.42,71.64 159.29,71.64 159.34,71.64 159.62,71.36 160.04,71.36 160.21,71.54 160.79,71.54 160.9,71.64 166.02,71.64 166.82,70.85 166.92,70.59 167.19,70.48 168.26,69.41 168.26,67.42 168.92,66.76 168.92,65.02 168.81,64.91 146.91,64.91 146.4,64.4 145.58,64.4 145.37,64.61 145.37,67.5 147.97,70.09 148.04,70.15 148.13,70.32 148.14,70.4 148.13,70.49 148.09,70.58 148.09,70.62 149.12,71.64 152.56,71.64
+GPU_CORE on IN4 (solid shape): outline of 164 points within 145.07,64.25 168.81,71.49
+GPU_CORE on VCC: outline of 226 points within 143.77,64.46 174.77,95.49
+GPU_CORE on IN3: outline of 145 points within 145.09,64.18 189.09,110.4
+GPU_CORE_VDDS on TOP (solid shape): 164.71,87.86 164.71,86.68 164.52,86.49 163.29,86.49 163.14,86.63 163.14,86.92 163.81,87.59 163.81,87.88 163.86,87.93 164.21,87.93 164.33,88.06 164.51,88.06
+GPU_CORE_VDDS on TOP (solid shape): 166.59,93.99 166.59,93.58 166.45,93.44 165.19,93.44 164.93,93.7 164.93,93.77 164.93,93.82 164.93,93.87 164.93,94.83 165.13,95.04 165.54,95.04
+GPU_CORE_VDDS on TOP (solid shape): 171.47,86 171.78,86 171.88,85.9 171.88,85.01 171.48,84.62 171.27,84.62 170.43,85.46 170.33,85.46 170.16,85.63 170.16,85.95 170.35,86.14 171.33,86.14
+GPU_CORE_VDDS on TOP (solid shape): 171.85,94.81 171.85,94.04 171.62,93.82 171.12,93.82 170.94,93.63 170.25,93.63 170.14,93.75 170.14,93.98 170.25,94.09 170.76,94.09 171.15,94.48 171.15,95 171.26,95.11 171.55,95.11
+GPU_CORE_VDDS on TOP (solid shape): 163.56,92.98 163.67,92.98 164.06,92.59 164.26,92.59 164.89,91.95 164.89,91.69 164.75,91.54 164.58,91.54 164.06,92.07 163.78,92.07 163.21,92.64 163.21,92.97 163.28,93.04 163.49,93.04
+GPU_CORE_VDDS on TOP (solid shape): 172.93,87.57 173.11,87.57 173.13,87.54 173.63,87.54 173.87,87.3 173.87,86.69 173.77,86.59 173.51,86.59 173.09,87.01 172.66,87.01 172.06,87.6 172.06,87.82 172.17,87.92 172.27,87.92 172.27,87.96 172.53,87.96
+GPU_CORE_VDDS on TOP (solid shape): 169,89.41 169.74,89.41 169.76,89.39 169.76,88.75 169.72,88.7 168.93,88.7 168.82,88.81 168.82,88.84 168.72,88.94 168.72,88.95 168.64,89.06 168.53,89.14 168.52,89.14 168.14,89.52 168.13,89.52 168.13,89.81 168.19,89.87 168.53,89.87
+GPU_CORE_VDDS on TOP (solid shape): 186.32,71.75 186.32,68.42 187.21,67.53 187.21,62.55 187.59,62.17 187.59,61.2 187.56,61.18 179.87,61.18 179.59,61.46 179.59,61.48 178.47,62.6 178.47,67.95 178.73,68.21 179.91,68.21 180.38,68.68 180.38,71.29 180.88,71.79 180.91,71.79 181.24,72.12 181.34,72.12 181.35,72.13 185.94,72.13
+GPU_CORE_VDDS on TOP (solid shape): 173.78,92.93 173.78,92.57 173.21,92 173.15,92 173.15,92.01 172.76,92.01 172.31,91.56 172.15,91.56 171.83,91.88 171.83,91.91 171.59,92.15 171.49,92.15 171.42,92.16 171.36,92.16 171.28,92.24 171.28,92.71 171.34,92.77 171.8,92.77 171.84,92.73 171.84,92.69 171.87,92.66 171.87,92.59 172.04,92.42 172.47,92.42 172.96,92.91 173.18,92.91 173.34,93.06 173.64,93.06
+GPU_CORE_VDDS on BOTTOM (solid shape): 186.64,71.93 186.64,71.91 186.75,71.7 186.96,71.59 186.98,71.59 187.21,71.36 187.21,68.65 187.19,68.61 187.16,68.6 186.83,68.24 187.16,67.88 187.19,67.87 187.21,67.83 187.21,61.69 186.75,61.23 178.98,61.23 178.44,61.76 178.44,68.19 178.61,68.35 180.22,68.35 180.46,68.6 180.46,71.78 181.06,72.38 186.19,72.38
+GPU_CORE_VDDS on IN1 (solid shape): 186.42,71.64 186.42,62.78 185.91,62.27 181.59,62.27 178.78,65.09 178.78,67.53 178.9,67.66 179.94,67.66 180.55,68.27 180.55,71.82 180.93,72.2 185.86,72.2
+GPU_CORE_VDDS on IN2 (solid shape): outline of 15460 points within 158.89,61.25 196.73,97.84
+GPU_CORE_VDDS on IN3 (solid shape): 186.42,71.64 186.42,62.78 185.91,62.27 179.77,62.27 178.78,63.26 178.78,67.53 178.9,67.66 179.94,67.66 180.88,68.6 180.88,72.09 180.99,72.2 185.86,72.2
+GPU_CORE_VDDS on IN4 (solid shape): 186.65,72.04 186.65,72.02 186.75,71.7 187.07,71.6 187.09,71.6 187.21,71.49 187.21,68.65 187.19,68.61 187.16,68.6 186.83,68.24 187.16,67.88 187.19,67.87 187.21,67.83 187.21,63.24 186.32,62.35 181.79,62.35 178.76,65.38 178.76,67.58 178.97,67.79 179.76,67.79 180.59,68.62 180.59,68.81 180.6,68.82 180.6,72 180.77,72.16 186.54,72.16
+GPU_CORE_VDDS on IN4 (solid shape): outline of 4122 points within 162.44,82.77 174.84,96.65
+IFP_PLLVDD on TOP (solid shape): 161.98,80.68 161.98,80.41 161.91,80.33 161.52,80.33 161.5,80.31 161.46,80.31 161.2,80.04 161.2,79.37 161.07,79.24 160.5,79.24 160.48,79.26 160.48,80.72 160.6,80.84 161.82,80.84
+INV_PWR_SRC on TOP (solid shape): 62.02,25.31 62.97,25.31 63.13,25.16 63.13,24.76 63.66,24.23 63.66,20.23 63.48,20.06 61.48,20.06 61.35,20.18 61.35,23.71 60.84,24.22 60.84,25.11 61.05,25.32 62.01,25.32
+INV_PWR_SRC on BOTTOM (solid shape): 62.21,25.14 63.26,25.14 63.31,25.09 63.31,23.87 62.79,23.36 61.99,23.36 60.87,24.48 60.87,25.14 61.04,25.31 62.04,25.31
+LAN_IO on TOP (solid shape): outline of 878 points within 281.09,41.06 290.69,51.04
+LAN_IO on BOTTOM (solid shape): 285.13,43.04 285.13,42.18 285.19,42.11 285.19,41.11 285.13,41.05 284.73,41.05 284.72,41.06 284.33,41.06 284.18,41.2 284.18,41.81 284.46,42.09 284.74,42.09 284.9,42.25 284.9,43.03 284.96,43.09 285.08,43.09
+LAN_IO on BOTTOM (solid shape): 290.46,47.81 290.46,47.67 290.17,47.39 290.03,47.39 289.95,47.31 289.95,45.84 289.82,45.71 289.44,45.71 288.91,45.18 287.72,45.18 287.64,45.25 287.64,45.33 287.72,45.41 288.8,45.41 289.33,45.93 289.33,47.06 289.38,47.11 289.38,47.32 289.38,47.32 289.38,47.76 289.49,47.86 290.4,47.86
+LAN_IO on BOTTOM (solid shape): 282.85,49.31 282.85,48.55 283.68,47.73 283.68,46.66 283.75,46.59 283.78,46.55 283.81,46.52 283.81,46.52 283.87,46.45 284.32,46.45 284.41,46.36 284.42,46.35 284.42,46.07 284.35,46 283.58,46 283.31,46.27 283.04,46.27 282.81,46.5 282.81,46.85 282.8,46.86 282.8,46.95 282.19,47.55 282.19,47.82 282.04,47.98 281.04,47.98 281.03,47.98 280.55,47.98 280.33,48.21 280.33,49.21 280.63,49.51 282.65,49.51
+LAN_VDD on BOTTOM (solid shape): 285.52,43.05 285.52,42.18 285.56,42.15 285.56,40.45 285.46,40.35 282.15,40.35 282.13,40.38 282.13,41.26 283.77,42.91 284.28,42.91 284.37,42.91 284.56,43.1 284.66,43.1 284.72,43.04 284.72,42.3 284.62,42.19 284.41,42.19 284.07,41.86 284.07,41.13 284.28,40.92 285.17,40.92 285.3,41.05 285.3,43.04 285.36,43.1 285.47,43.1
+LAN_VDD on IN3 (solid shape): outline of 763 points within 282.46,41.27 288.81,48
+NVVDDS_B+ on BOTTOM (solid shape): 205.74,64.42 204.8,63.48 204.8,60.79 204.58,60.57 194.98,60.57 194.54,61.01 194.54,63.42 199.16,63.42 199.16,62.95 199.44,62.68 200.74,62.68 200.97,62.9 200.97,63.95 200.79,64.13 200.1,64.13 199.65,63.67 199.42,63.67 199.16,63.42 194.54,63.42 194.54,64.33 195.1,64.89 205.74,64.89
+RTCBATT on BOTTOM (solid shape): 154.89,16.22 154.89,15.42 154.57,15.1 154.57,14.73 154.57,14.72 154.57,12.97 154.42,12.82 154.01,12.82 153.77,13.06 153.77,16.02 153.77,16.04 154.05,16.32 154.8,16.32
+SP_PLLVDD on TOP (solid shape): 161.4,82.54 161.93,82.54 162.06,82.41 162.06,81.91 161.2,81.04 160.5,81.04 160.49,81.05 160.49,82.03 160.37,82.14 160.37,82.74 160.4,82.77 161.17,82.77
+VDISPLAY_VCC on TOP (solid shape): 271.23,29.04 271.23,27.97 271.11,27.86 269.67,27.86 269.44,28.09 269.44,28.09 269.35,28.18 269.35,29.31 269.4,29.36 270.91,29.36
+VDISPLAY_VCC on BOTTOM (solid shape): 301.05,69.87 301.05,69.47 298.61,67.02 298.61,65.79 297.53,64.72 295.94,64.72 295.59,65.07 295.59,65.75 295.79,65.95 295.79,67.38 296,67.58 296,68.13 296.25,68.38 296.25,68.62 296.43,68.8 297.29,68.8 298.56,70.07 300.85,70.07
+VDISPLAY_VCC on IN2 (solid shape): 297.37,65.94 297.37,64.88 297.14,64.65 296.22,64.65 295.79,65.08 295.79,65.84 296.05,66.1 297.22,66.1
+VDISPLAY_VCC on IN2 (solid shape): outline of 169 points within 269.32,27.73 271.97,32.25
+VGA_B+ on TOP (solid shape): outline of 240 points within 149.49,50.16 155.2,56.51
+VGA_B+ on BOTTOM (solid shape): 156.32,56.1 156.32,51.56 156.29,51.53 155.69,51.53 155.1,52.11 154.29,52.11 153.81,51.63 153.81,50.6 153.97,50.43 155.2,50.43 155.39,50.24 155.39,48.86 155.56,48.69 156.73,48.69 156.73,48.73 156.89,48.89 167.52,48.89 167.78,49.14 167.78,51.25 167.47,51.55 166.82,51.55 166.76,51.61 166.76,55.54 166.83,55.62 167.27,55.62 168.16,54.73 169.86,54.73 170.44,54.14 170.44,48.63 168.03,46.22 154.49,46.22 154.19,46.52 153.17,46.52 153.1,46.45 153.1,44.8 154.11,43.78 154.11,42.31 153.88,42.08 149.23,42.08 148.63,42.69 148.63,51.07 149.54,51.07 149.54,50.25 149.54,50.18 149.66,50.06 149.66,49.48 149.95,49.18 150.67,49.18 150.9,49.42 150.9,49.99 151.11,50.2 151.11,51.05 150.91,51.25 149.72,51.25 149.54,51.07 148.63,51.07 148.63,55.95 149.01,56.33 149.54,56.33 149.78,56.09 149.78,55.58 150,55.36 152.05,55.36 152.23,55.54 152.23,56.23 152.43,56.43 155.99,56.43
+VGA_B+ on IN1 (solid shape): 154.72,55.97 154.72,52.22 153.17,50.67 152.76,50.67 151.96,51.46 150.85,51.46 150.53,51.78 150.53,54.9 150.92,55.3 151.88,55.3 151.9,55.31 152,55.31 153.02,56.33 154.37,56.33
+VGA_B+ on IN3 (solid shape): outline of 2231 points within 148.85,50.66 171.03,63.36
+VID_PLLVDD on TOP: 162.19,81.4 162.44,81.65 162.7,81.65 162.95,81.4 162.95,81.27 163.2,81.02 164.14,81.02 164.21,80.95 164.21,80.46 164.16,80.41 162.64,80.41 162.19,80.86
+XS_PLLVDD on TOP: 163.15,82.73 163.75,82.73 163.82,82.66 163.82,81.91 163.79,81.88 163.79,81.25 163.75,81.21 163.26,81.21 163.08,81.4 163.08,81.52 162.82,81.78 162.44,81.78 162.32,81.91 162.32,82.41 162.44,82.54 162.95,82.54 163.03,82.62 163.03,82.62
-DC_IN on BOTTOM (solid shape): 16.01,34.05 16.01,33.47 15.94,33.39 15.76,33.39 15.25,32.88 15.25,25.9 15.12,25.77 11.19,25.77 9.46,27.5 9.46,29.15 8.64,29.97 5.46,29.97 5.33,30.1 5.33,32.4 12.91,32.4 12.91,32.37 12.92,32.32 12.94,32.27 12.96,32.22 12.99,32.18 13.03,32.14 13.07,32.11 13.11,32.08 13.16,32.06 13.22,32.05 13.27,32.04 13.32,32.05 13.37,32.06 13.42,32.08 13.47,32.11 13.51,32.14 13.55,32.18 13.58,32.22 13.6,32.27 13.62,32.32 13.62,32.37 13.62,32.43 13.62,32.48 13.6,32.53 13.58,32.58 13.55,32.62 13.51,32.66 13.47,32.7 13.42,32.72 13.37,32.74 13.32,32.75 13.27,32.76 13.22,32.75 13.16,32.74 13.11,32.72 13.07,32.7 13.03,32.66 12.99,32.62 12.96,32.58 12.94,32.53 12.92,32.48 12.91,32.43 12.91,32.4 5.33,32.4 5.33,33.74 5.44,33.85 12.49,33.85 12.52,33.82 13.09,33.82 13.11,33.81 13.16,33.8 13.22,33.8 13.27,33.8 13.32,33.81 13.35,33.82 13.39,33.82 13.73,34.15 15.91,34.15
ACDRV_CHG on TOP (solid shape): 27.06,37.79 27.06,37.28 26.48,36.7 26.48,35.16 26.46,35.15 25.84,35.15 25.83,35.16 25.83,37.87 25.99,38.04 26.81,38.04
ACDRV_CHG on BOTTOM (solid shape): 27.29,37.46 28.2,37.46 28.28,37.38 28.28,37.3 28.2,37.23 26.45,37.23 26.11,37.57 26.08,37.6 26.08,37.87 26.18,37.96 26.78,37.96
AUD_AGND on TOP (solid shape): 292.02,19.15 292.02,17.78 291.92,17.68 290.71,17.68 290.61,17.78 290.61,18.13 290.74,18.26 291.24,18.26 291.43,18.45 291.43,19.17 291.49,19.24 291.94,19.24
AUD_AGND on TOP (solid shape): 288.76,23.92 288.76,22.93 288.81,22.88 288.81,20.74 288.45,20.38 288.41,20.38 288.1,20.07 287.39,20.07 287.23,20.23 287.23,20.82 287.36,20.95 287.36,21.73 287.44,21.81 287.41,21.83 287.41,23.99 287.54,24.12 288.55,24.12
AUD_AGND on IN2 (solid shape): outline of 1870 points within 276.68,7.36 309.79,30.6
AUD_AGND on GND1: 260.53,19.93 260.29,20.17 260.29,20.96 259.71,21.54 259.11,21.54 259.05,21.48 257.16,21.48 256.42,20.74 256.15,20.74 256.02,20.87 256.02,22.05 257.54,23.57 257.54,23.91 259.12,23.91 259.33,23.7 259.33,22.84 261.5,20.66 261.5,20.05 261.38,19.93
AUD_AGND on GND1: outline of 85 points within 276.68,7.36 309.79,30.6
AUD_AGND on VCC: outline of 146 points within 276.68,7.36 309.79,30.6
AUD_AGND on GND2: outline of 82 points within 276.68,7.36 309.79,30.6
AUD_AGND on GND3: outline of 82 points within 276.68,7.36 309.79,30.6
AUD_AGND on GND3: 260.59,19.9 260.51,19.98 260.51,20.13 260.23,20.41 260.23,21.12 259.88,21.48 257.39,21.48 256.68,20.77 256.22,20.77 256.09,20.9 256.09,21.91 257.64,23.46 257.64,23.89 259.11,23.89 259.14,23.86 259.14,22.95 261.5,20.59 261.5,20.03 261.37,19.9
AUD_HP1_JACK_L on TOP (solid shape): 296.75,13.45 296.75,12.82 296.68,12.75 295.68,12.75 295.55,12.63 295.31,12.63 295.17,12.77 295.17,13.21 295.48,13.52 296.68,13.52
AUD_HP1_JACK_L on IN3 (solid shape): 288,25.16 288,23.21 287.3,23.21 286.98,23.54 286.98,24.59 286.23,25.34 286.23,25.53 286.43,25.73 287.42,25.73
AUD_HP1_JACK_L on IN3 (solid shape): 296.05,13.88 296.05,13.07 295.62,12.64 295.3,12.64 295.19,12.76 295.19,13.24 294.6,13.82 294.6,14.53 295.4,14.53
AUD_HP1_JACK_L1 on TOP (solid shape): 297.69,15.31 297.69,12.04 297.62,11.97 297.15,11.97 297.06,12.06 297.06,15.31 297.13,15.38 297.61,15.38
AUD_HP1_JACK_R on IN3 (solid shape): 288.88,26.61 288.88,25.9 288.78,25.8 287.79,25.8 287.54,26.05 286.27,26.05 286.17,26.15 286.17,26.51 286.55,26.89 288.6,26.89
AUD_HP1_JACK_R on IN3 (solid shape): 295.34,15.7 295.34,15.23 295.03,14.93 293.47,14.93 293.02,15.37 293.02,15.56 293.23,15.76 293.25,15.76 293.39,15.79 293.5,15.87 295.17,15.87
AUD_HP1_JACK_R1 on TOP (solid shape): 291.98,17.39 291.98,14.21 291.91,14.14 291.32,14.14 291.18,14.28 291.18,14.94 291.32,15.28 291.09,15.56 291.09,17.32 291.22,17.44 291.93,17.44
AUD_PORTA_L_R_B on TOP (solid shape): 296.81,17.14 296.81,14.85 296.76,14.8 296.09,14.8 296.05,14.85 296.05,16.5 295.54,17.01 295.54,17.58 295.68,17.72 296.22,17.72
AUD_PORTA_R_R_B on TOP (solid shape): 294.28,20.64 294.28,19.13 293.76,18.61 293.76,17.01 293.56,16.81 292.34,16.81 292.24,16.92 292.24,20.49 292.24,20.49 292.24,20.65 292.41,20.82 294.1,20.82
AUD_PORTA_R_R_B on BOTTOM (solid shape): 293.51,20.56 293.51,19.93 293.5,19.92 293.5,19.55 292.95,19 292.07,19 291.78,19.29 291.78,20.41 292.11,20.74 293.33,20.74
AUD_SPK_L+ on TOP (solid shape): 276.5,17.58 276.5,16.44 276.31,16.25 275.6,16.25 275.6,17.14 275.32,17.41 275.32,17.64 275.45,17.77 276.09,17.77 276.1,17.78 276.3,17.78
AUD_SPK_L+ on TOP (solid shape): 281.67,30.27 281.67,27.4 281.62,27.35 281.47,27.35 281.39,27.42 281.39,28.39 281.16,28.62 281.16,30.27 281.26,30.37 281.57,30.37
AUD_SPK_L+ on IN4 (solid shape): 276.11,19.29 276.11,18.02 276.49,17.64 276.49,17.39 276.36,17.26 275.48,17.26 275.09,17.65 275.09,19.29 275.22,19.42 275.98,19.42
AUD_SPK_L+ on IN4 (solid shape): 281.75,30.37 281.75,27.55 281.62,27.42 280.73,27.42 280.48,27.68 280.48,28 281.26,28.79 281.26,30.34 281.37,30.44 281.67,30.44
AUD_SPK_L+_C on TOP (solid shape): 302.73,6.55 302.73,3.77 302.6,3.65 302.21,3.65 302.09,3.76 302.09,6.5 302.25,6.66 302.62,6.66
AUD_SPK_L+_C on TOP (solid shape): 275.35,17.01 275.35,16.27 275.35,16.23 275.73,15.85 275.73,14.85 276.31,14.27 276.39,14.27 276.5,14.23 276.62,14.21 276.87,14.21 276.87,13.21 276.67,13.02 275.53,13.02 274.46,14.09 274.46,14.86 274.33,14.98 274.33,15.92 274.52,16.11 274.52,16.92 274.73,17.14 275.22,17.14
AUD_SPK_L+_C on IN4 (solid shape): 302.85,5.55 302.85,4.1 302.52,3.77 302.04,3.77 301.88,3.94 301.88,5.08 301.66,5.3 300.57,5.3 300.57,6.31 302.09,6.31
AUD_SPK_L+_C on IN4 (solid shape): 277.89,15.23 277.89,13.45 277.5,13.07 276.11,13.07 275.85,13.33 275.85,14.72 276.26,14.72 276.26,14.67 276.27,14.62 276.29,14.57 276.32,14.52 276.35,14.48 276.39,14.44 276.44,14.41 276.49,14.39 276.54,14.37 276.59,14.37 276.64,14.37 276.7,14.37 276.75,14.39 276.79,14.41 276.84,14.44 276.88,14.48 276.91,14.52 276.94,14.57 276.96,14.62 276.97,14.67 276.97,14.72 276.97,14.78 276.96,14.83 276.94,14.88 276.91,14.92 276.88,14.96 276.84,15 276.79,15.03 276.75,15.05 276.7,15.07 276.64,15.08 276.59,15.08 276.54,15.07 276.49,15.05 276.44,15.03 276.39,15 276.35,14.96 276.32,14.92 276.29,14.88 276.27,14.83 276.26,14.78 276.26,14.72 275.85,14.72 275.85,15.23 276.11,15.48 277.63,15.48
AUD_SPK_L- on TOP (solid shape): 277.89,17.64 277.89,17.11 277.89,16.35 277.77,16.24 276.88,16.24 276.77,16.35 276.77,17.64 276.9,17.77 277.76,17.77
AUD_SPK_L- on IN4 (solid shape): 277.89,17.64 277.89,16.37 277.5,15.99 274.84,15.99 274.71,16.12 274.71,16.88 274.84,17.01 276.36,17.01 276.74,17.39 276.74,17.64 276.87,17.77 277.76,17.77
AUD_SPK_L- on IN4 (solid shape): 280.99,30.36 280.99,28.91 280.09,28 279.5,28 279.36,28.14 279.36,29 279.53,29.17 280.3,29.17 280.55,29.43 280.55,30.34 280.66,30.44 280.91,30.44
AUD_SPK_L-_C on TOP (solid shape): 303.74,6.55 303.74,5.1 303.87,4.97 303.87,3.8 303.69,3.62 303.29,3.62 303.11,3.8 303.11,6.57 303.2,6.66 303.64,6.66
AUD_SPK_L-_C on TOP (solid shape): 279.16,17.01 279.16,15.74 278.77,15.36 278.77,15.29 278.6,15.11 278.6,14.79 278.77,14.61 278.77,14.6 278.79,14.6 278.82,14.57 279.07,14.57 279.35,14.29 279.35,13.52 278.77,12.94 277.38,12.94 277.12,13.2 277.12,14.34 277.81,15.03 277.81,15.92 278.14,16.25 278.14,17.01 278.27,17.14 279.03,17.14
AUD_SPK_L-_C on IN4 (solid shape): 279.55,14.07 280.21,14.07 280.43,13.86 280.43,13.2 280.32,13.1 279.89,13.1 279.92,13.07 278.77,13.07 278.36,13.49 278.36,14.38 278.42,14.44 279.18,14.44
AUD_SPK_L-_C on IN4 (solid shape): 303.97,4.69 303.97,3.39 302.63,2.05 302.09,2.05 301.99,2.15 301.99,2.96 302.12,3.09 302.24,3.09 303.06,3.9 303.06,4.64 303.24,4.82 303.84,4.82
AUD_SPK_R+ on TOP (solid shape): 271.66,17.9 271.66,16.42 271.49,16.25 270.77,16.25 270.77,17.97 270.8,18 271.57,18
AUD_SPK_R+ on IN1 (solid shape): 271.54,19.42 271.54,17.62 271.76,17.39 271.76,17.19 271.64,17.06 270.6,17.06 270.39,17.26 270.39,19.24 270.62,19.47 270.72,19.47 270.93,19.68 271.28,19.68
AUD_SPK_R+ on IN1 (solid shape): 279.82,30.27 279.82,29.42 279.09,28.69 278.5,28.69 278.37,28.82 278.37,29.48 278.67,29.78 278.8,29.86 278.88,29.99 279.28,30.39 279.69,30.39
AUD_SPK_R+_C on TOP (solid shape): 300.72,6.5 300.72,5.43 300.72,5.42 300.72,5.26 300.64,5.19 300.64,3.88 300.42,3.65 299.7,3.65 299.48,3.88 299.48,5.63 299.91,6.06 299.91,6.49 300.09,6.67 300.55,6.67
AUD_SPK_R+_C on TOP (solid shape): 270.52,17.01 270.52,16.14 270.89,15.77 270.89,15.03 271.54,14.38 271.71,14.21 271.99,14.21 272.12,14.09 272.12,13.07 271.97,12.92 270.84,12.92 270.83,12.93 270.56,12.93 269.25,14.24 269.25,16.75 269.74,17.24 269.83,17.24 269.92,17.26 270.27,17.26
AUD_SPK_R+_C on IN1 (solid shape): 300.59,4.49 300.59,4.08 300.36,3.85 298.49,3.85 298.28,4.05 298.28,4.71 298.41,4.84 300.24,4.84
AUD_SPK_R+_C on IN1 (solid shape): 272.41,14.1 272.41,11.41 272.37,11.37 272.37,11.27 271.76,11.27 271.23,11.8 271.23,14.09 271.36,14.21 272.3,14.21
AUD_SPK_R- on TOP (solid shape): 272.93,18.27 272.93,16.25 272.91,16.22 272.04,16.22 271.92,16.35 271.92,17.94 272.33,18.36 272.84,18.36
AUD_SPK_R- on IN1 (solid shape): 272.93,19.55 272.93,17.52 272.68,17.26 272.2,17.26 271.79,17.67 271.79,19.09 272.44,19.74 272.74,19.74
AUD_SPK_R- on IN1 (solid shape): 280.43,30.37 280.43,27.78 280.01,27.36 279.09,27.36 278.7,27.75 279.97,29.02 279.97,30.29 280.12,30.44 280.35,30.44
AUD_SPK_R-_C on TOP (solid shape): 301.74,6.51 301.74,3.74 301.62,3.62 301.1,3.62 300.9,3.83 300.9,5.07 301.1,5.27 301.1,6.51 301.25,6.66 301.59,6.66
AUD_SPK_R-_C on TOP (solid shape): 274.56,17.5 274.56,17.14 274.1,16.68 274.1,13.12 273.89,12.91 272.74,12.91 272.37,13.27 272.37,14.42 272.91,14.96 272.91,15.86 273.19,16.14 273.19,17.05 273.27,17.14 273.69,17.14 274.18,17.63 274.43,17.63
AUD_SPK_R-_C on IN1 (solid shape): 274.23,13.96 274.23,12.79 274.63,12.39 274.74,12.39 274.76,12.36 274.76,11.39 274.74,11.37 274.2,11.37 273.29,12.28 273.29,13.96 273.42,14.09 274.1,14.09
AUD_SPK_R-_C on IN1 (solid shape): 301.86,5.53 301.86,3.85 301.71,3.7 301.05,3.7 300.91,3.84 300.91,5.03 300.54,5.4 300.24,5.4 300.07,5.57 300.07,6.28 300.19,6.39 301,6.39
B+ on TOP (solid shape): 44.93,6.61 36.93,6.61 36.93,14.61 44.93,14.61
B+ on TOP (solid shape): 68.72,123.31 68.72,120.13 68.59,120.01 64.78,120.01 64.27,120.51 64.27,123.56 64.4,123.69 68.34,123.69
B+ on TOP (solid shape): 122.56,133.59 122.56,133.34 122.44,133.21 122.18,133.21 121.8,132.83 121.8,132.32 121.68,132.2 121.17,132.2 121.17,132.2 119.19,132.2 119.19,132.2 115.15,132.2 114.82,132.2 114.69,132.32 114.69,133.59 114.82,133.72 122.44,133.72
B+ on TOP (solid shape): 207.35,124.04 207.35,123.31 207.91,123.31 207.91,123.08 207.88,123.05 207.35,123.05 207.35,122.49 207.91,122.49 207.91,122.29 207.86,122.24 207.35,122.24 207.32,122.21 207.32,121.78 206,121.78 204.78,123 204.78,124.17 204.96,124.35 207.05,124.35
B+ on TOP (solid shape): 76.84,78.48 76.84,75.68 74.81,73.65 72.4,73.65 71.63,74.42 71.62,74.42 71.23,74.03 71.23,74.03 71.06,74.2 71.44,74.59 71.06,74.98 70.67,74.59 70.49,74.76 70.49,74.77 70.88,75.16 70.49,75.54 70.49,78.22 71.26,78.98 76.34,78.98
B+ on TOP (solid shape): 221.65,50.23 221.65,49.15 222.19,49.15 222.2,49.14 222.2,48.93 222.18,48.91 221.65,48.91 221.65,48.35 222.18,48.35 222.2,48.33 222.2,48.13 222.18,48.11 221.65,48.11 221.65,47.64 221.5,47.49 219.04,47.49 218.35,48.19 218.35,49.9 218.97,50.52 221.36,50.52
B+ on TOP (solid shape): 139.53,119.89 139.53,118.94 139.07,118.94 138.97,118.94 138.97,118.84 138.97,118.5 138.97,118.4 139.53,118.4 139.53,118.15 138.97,118.15 138.97,118.03 138.97,117.62 139.48,117.62 139.53,117.57 139.53,117.26 137.32,117.26 137.22,117.36 137.22,119.98 137.32,120.08 139.34,120.08
B+ on TOP (solid shape): 139.07,133.47 139.07,133.16 138.85,132.93 138.69,132.93 138.67,132.91 138.64,132.91 138.49,132.76 138.49,132.73 138.39,132.63 138.39,132.27 138.09,131.97 136.75,131.97 136.72,131.97 136.72,131.45 136.28,131.45 136.28,131.97 136.25,131.97 135.55,131.97 135.52,131.97 135.52,131.45 135.08,131.45 135.08,131.97 135.05,131.97 134.27,131.97 134.02,132.22 134.02,133.49 134.22,133.7 138.85,133.7
B+ on TOP (solid shape): outline of 171 points within 233.21,22.52 260.21,45.58
B+ on TOP (solid shape): outline of 4028 points within 19.61,6.52 144.84,39.88
B+ on BOTTOM (solid shape): 75.83,77.21 75.83,75.05 74.43,73.65 72.4,73.65 71.69,74.36 71.69,76.49 72.65,77.46 75.57,77.46
B+ on BOTTOM (solid shape): 207.35,124.04 207.35,123.08 207.22,122.95 205.3,122.95 204.78,123.46 204.78,124.17 204.96,124.35 207.05,124.35
B+ on BOTTOM (solid shape): 220.75,50.11 220.75,48.64 220.64,48.53 218.81,48.53 218.39,48.95 218.39,49.98 218.72,50.31 220.56,50.31
B+ on BOTTOM (solid shape): 70.95,122.77 70.95,119.65 70.23,118.94 64.37,118.94 64.37,122.9 64.78,123.31 70.41,123.31
B+ on BOTTOM (solid shape): 95.49,8.65 95.49,6.72 95.23,6.47 94.37,6.47 93.99,6.85 93.99,8.63 94.12,8.75 95.39,8.75
B+ on BOTTOM (solid shape): 139.58,120.03 139.58,117.67 139.48,117.57 137.4,117.57 137.27,117.69 137.27,119.98 137.42,120.13 139.48,120.13
B+ on BOTTOM (solid shape): 44.21,27.42 44.21,20.06 43.32,20.06 43.19,20.18 43.19,23.1 42.55,23.74 41.41,23.74 41.03,24.12 41.03,27.55 41.16,27.68 43.95,27.68
B+ on BOTTOM (solid shape): 208.29,63.54 208.29,62.04 207.43,61.18 207.43,60.49 207.63,60.29 208.53,60.29 208.67,60.14 208.67,58.04 208.43,57.8 207.48,57.8 206.74,58.54 206.74,62.75 207.65,63.67 208.16,63.67
B+ on BOTTOM (solid shape): 135.91,133.71 136.34,133.71 136.36,133.72 138.95,133.72 139.1,133.57 139.1,133.11 138.95,132.96 138.59,132.96 138.29,132.65 138.29,131.64 138.03,131.38 135.49,131.38 134.86,132.02 134.86,133.47 135.11,133.72 135.9,133.72
B+ on BOTTOM (solid shape): 122.56,133.59 122.56,133.29 122.44,133.16 122.13,133.16 121.42,132.45 117.05,132.45 116.8,132.71 115.52,132.71 115.39,132.71 115.2,132.71 114.69,133.21 114.69,133.59 114.82,133.72 122.44,133.72
B+ on BOTTOM (solid shape): 148.32,44.61 148.32,42.56 149.12,41.76 154.05,41.76 154.31,41.49 154.31,40.25 154.44,40.12 155.2,40.12 155.33,40 155.33,39.11 155.2,38.98 149.23,38.98 148.22,40 147,40 146.52,40.48 146.52,44.56 146.95,44.99 147.94,44.99
B+ on BOTTOM (solid shape): 28.03,30.37 28.86,30.37 29.01,30.22 31.84,30.22 32.01,30.04 32.01,28.06 31.76,27.8 26.82,27.8 26.62,28.01 26.62,29.01 27.16,29.01 27.18,29.04 27.51,29.39 27.18,29.75 27.16,29.77 26.73,29.77 26.73,30.58 26.74,30.6 27.8,30.6
B+ on BOTTOM (solid shape): 201.94,59.27 201.94,57.34 200.88,56.29 197.83,56.29 197.58,56.54 197.58,56.96 199.67,56.96 199.67,56.91 199.68,56.86 199.7,56.81 199.73,56.76 199.76,56.72 199.8,56.68 199.84,56.65 199.89,56.63 199.94,56.61 200,56.61 200.05,56.61 200.1,56.61 200.15,56.63 200.2,56.65 200.24,56.68 200.28,56.72 200.32,56.76 200.34,56.81 200.36,56.86 200.38,56.91 200.38,56.96 200.38,57.02 200.36,57.07 200.34,57.12 200.32,57.16 200.28,57.21 200.24,57.24 200.2,57.27 200.15,57.29 200.1,57.31 200.05,57.32 200,57.32 199.94,57.31 199.89,57.29 199.84,57.27 199.8,57.24 199.76,57.21 199.73,57.16 199.7,57.12 199.68,57.07 199.67,57.02 199.67,56.96 197.58,56.96 197.58,58.61 198.53,59.56 201.65,59.56
B+ on BOTTOM (solid shape): outline of 98 points within 251.15,21.89 259.56,28.85
B+ on IN1 (solid shape): 139.18,133.47 139.18,133.14 138.95,132.91 135.01,132.91 134.73,133.19 134.73,133.52 134.74,133.53 139.11,133.53
B+ on IN1 (solid shape): 206.12,124.31 206.12,123.31 205.89,123.08 204.94,123.08 204.63,123.38 204.63,124.27 204.99,124.63 205.8,124.63
B+ on IN1 (solid shape): outline of 5040 points within 41.03,20.06 76.65,77.68
B+ on IN2 (solid shape): outline of 6856 points within 145.68,36.57 236.18,59.45
B+ on IN3 (solid shape): 66.42,23.88 67.82,23.88 68.92,22.77 68.92,20.23 68.79,20.11 63.56,20.11 63.31,20.36 63.31,23.08 64.12,23.89 66.41,23.89
B+ on IN3 (solid shape): 223.36,50.66 223.89,50.63 224.42,50.66 224.42,50.66 226.14,50.66 226.37,50.43 227.48,50.43 230.46,47.46 230.86,47.46 233.05,45.28 235.51,45.28 235.82,44.97 235.85,44.94 235.85,43.68 235.34,43.17 233.31,43.17 232.93,43.55 232.8,43.55 231.62,44.73 231.62,44.74 231.53,44.9 231.38,44.99 231.36,44.99 229.37,46.98 228.79,46.98 227.37,48.4 224.26,48.4 223.4,49.27 223.15,49.37 222.9,49.27 222.64,49.27 221.88,48.5 218.51,48.5 218.35,48.66 218.35,49.8 219.21,50.66 223.36,50.66
B+ on IN3 (solid shape): outline of 1063 points within 26.3,16.25 47.13,32.25
B+ on IN3 (solid shape): outline of 1686 points within 76.08,6.31 144.76,16.47
B+ on IN3 (solid shape): outline of 10567 points within 62.77,113.02 140.6,133.72
B+ on VCC: 150.73,24.19 150.76,24.12 150.76,12.94 140.07,12.94 139.71,13.3 139.71,26.28 139.73,26.3 139.71,26.32 139.71,26.39 139.73,26.4 139.83,26.58 139.82,26.78 139.77,26.87 139.71,26.93 139.71,28.77 139.91,28.97 139.91,29.36 139.96,29.45 140.05,29.46 140.55,29.78 140.05,30.11 139.96,30.12 139.91,30.21 139.91,30.82 140.85,31.76 140.94,31.79 141.01,31.74 141.07,31.66 141.08,31.59 141.05,31.53 140.98,31.08 141.4,30.92 141.68,31.2 141.54,31.56 141.55,31.6 141.57,31.62 141.65,31.73 141.69,31.85 141.52,32.2 141.13,32.19 141.03,32.19 140.98,32.27 140.98,39.38 142.74,41.14 155.46,41.14 155.46,39.47 152.41,36.41 152.39,36.41 152.16,36.31 152.05,36.08 152.05,36.06 150.76,34.77 150.76,28.72 150.76,28.7 150.75,28.67 150.75,27.9 150.76,27.88 150.76,27.85 150.76,25.04 150.73,24.96 150.66,24.93 150.3,24.58 150.66,24.22
B+ on VCC: outline of 592 points within 15.38,26.33 140.6,133.98
