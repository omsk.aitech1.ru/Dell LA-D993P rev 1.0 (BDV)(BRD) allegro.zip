# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FBC_MA4_BA2_L: length 25.7
  TOP w0.102: v2(204.21,81.27) 204.04,81.44 196.76,81.44 196.53,81.67
  TOP w0.185: v2(189.11,83.28) 189.11,83.25 v4(189.94,82.42) 190.69,81.67 196.53,81.67 196.53,81.67
  BOTTOM w0.185: v2(204.21,81.27) 204.23,81.26 204.23,80 204.66,79.57 UV8.K11 ; UV1.A12 183.59,85.21 185.52,83.28 v2(189.11,83.28)
FBC_MA5_BA1_H: length 31.2
  TOP w0.185: v2(204.66,104.11) 204.66,103.54 204.18,103.05 198.15,103.05 196.86,101.77 196.36,101.77 194.09,99.5 v4(193.69,99.5) 192.08,97.89 192.08,96.74 192.08,95.92 188.55,92.4 v2(188.55,92.24)
  BOTTOM w0.185: UV9.H10 v2(204.66,104.11) ; v2(188.55,92.24) 188.55,92.62 188.38,92.8 184.19,92.8 183.69,92.31 181.69,92.31 UV1.B20
FBC_MA5_BA1_L: length 27.1
  TOP w0.102: 196.86,82.06 197.14,81.78 204.24,81.78 204.66,81.36 v2(204.66,80.84)
  TOP w0.185: 196.86,82.06 196.55,82.36 v4(194.37,82.36) 191.19,82.36 190.31,83.25 v2(190.31,83.28)
  BOTTOM w0.185: UV8.K10 v2(204.66,80.84) ; UV1.B12 181.69,84.81 183.35,84.81 185.74,82.41 190,82.41 190.31,82.72 v2(190.31,83.28)
FBC_MA6_MA11_H: length 36.2
  IN1 w0.102: v2(204.61,101.26) 204.11,100.76 203.42,100.76 203.08,100.42 203.08,97.45 203.34,97.18 203.34,96.11 203.06,95.82 ; v2(177.61,90.63) 178.04,90.21 179.44,90.21 179.79,89.86 180.64,89.86
  IN1 w0.152: 203.06,95.82 200.27,93.03 194.97,93.03 191.89,89.95 180.73,89.95 180.64,89.86
  BOTTOM w0.185: UV9.H5 204.66,101.21 v2(204.61,101.26) ; UV1.G18 v2(177.61,90.63)
FBC_MA6_MA11_L: length 31.2
  TOP w0.102: 182.86,87.09 182.5,87.45 181.39,87.45 181.13,87.72 179.13,87.72 178.71,88.13 v2(177.61,88.13) ; 196.45,83.58 197.65,82.39 v3(200.82,82.39) 203.37,82.39 v2(204.66,83.68)
  TOP w0.185: 182.86,87.09 186.01,87.09 189.13,83.97 192.97,83.97 193.07,83.87 193.19,83.75 196.28,83.75 196.45,83.58
  BOTTOM w0.185: v2(177.61,88.13) UV1.G15 ; UV8.K5 v2(204.66,83.68)
FBC_MA7_MA8_H: length 32.6
  TOP w0.102: 195.72,98.18 196.41,98.88 196.41,99.35 196.9,99.85 197.98,99.85 198.28,100.14 198.28,100.42 198.54,100.68 198.82,100.68 199.04,100.91 199.04,101.18 199.91,102.05 203.51,102.05 204.18,101.38 204.18,100.34 v2(204.26,100.26)
  TOP w0.185: 195.72,98.18 194.95,97.42 194.56,97.42 v4(194.39,97.25) 194.16,97.02 194.16,94.24 v2(192.11,92.18)
  BOTTOM w0.185: v2(204.26,100.26) 204.66,99.86 UV9.H4 ; v2(192.11,92.18) 192.11,92.37 191.78,92.7 191.14,92.7 190.29,91.84 190,91.84 189.69,91.53 188.6,91.53 188.4,91.33 184.77,91.33 184.54,91.1 182.43,91.1 181.54,90.21 UV1.B18
FBC_MA7_MA8_L: length 26.8
  TOP w0.102: v2(204.26,84.68) 204.26,83.64 203.36,82.74 197.8,82.74 196.48,84.06
  TOP w0.185: v2(193.81,84.45) 193.93,84.45 193.94,84.45 v4(194.73,84.45) 196.1,84.45 196.48,84.06
  BOTTOM w0.185: UV8.K4 v2(204.26,84.68) ; v2(193.81,84.45) 193.81,84.7 193.43,85.08 185.32,85.08 184.24,86.15 182.29,86.15 181.54,86.91 UV1.B14
FBC_MA12_RFU_H: length 34.7
  TOP w0.102: 195.72,97.2 196.41,97.9 196.41,98.55 196.94,99.08 198.82,99.08 199.08,99.34 199.08,100.42 199.34,100.68 199.62,100.68 199.84,100.91 199.84,101.18 200.51,101.85 203.18,101.85 v2(203.76,101.26) ; 179.87,89.43 178.85,89.43 v2(178.46,89.81)
  TOP w0.185: 195.72,97.2 194.86,96.34 194.86,93.95 192.25,91.34 190.93,91.34 189.5,89.91 v3(185.39,89.91) 184.52,89.91 184.04,89.43 179.87,89.43
  BOTTOM w0.185: v2(178.46,89.81) 178.06,89.41 UV1.F17 ; UV9.J5 203.86,101.16 v2(203.76,101.26)
FBC_MA12_RFU_L: length 28.1
  TOP w0.102: 196.11,84.91 196.4,84.61 196.4,84.49 196.79,84.1 196.92,84.1 197.92,83.1 203.18,83.1 v2(203.76,83.68) ; v2(179.29,88.13) 179.42,88 181.3,88 181.5,87.8
  TOP w0.185: 181.5,87.8 186.37,87.8 189.03,85.14 v3(191.07,85.14) 195.88,85.14 196.11,84.91
  BOTTOM w0.185: UV8.J5 203.86,83.78 v2(203.76,83.68) ; v2(179.29,88.13) 179.29,88.11 UV1.E15
FBC_RAS#_H: length 30.7
  TOP w0.102: 198.89,95.49 198.89,95.88 198.67,96.1 198.67,97.01 198.9,97.25 201.91,97.25 202.24,97.58 202.24,99.05 v2(202.66,99.46)
  TOP w0.185: v2(197.03,91.96) 197.03,92.19 v4(198.31,93.48) 198.51,93.68 198.51,93.7 198.89,94.08 198.89,95.49
  BOTTOM w0.185: UV9.L3 v2(202.66,99.46) ; UV1.D17 180.09,89.81 182.69,89.81 183.04,90.16 187.9,90.16 188.19,90.46 192.59,90.46 193.45,91.32 196.38,91.32 v2(197.03,91.96)
FBC_RAS#_L: length 27.7
  IN1 w0.102: v2(202.66,86.28) 202.26,86.68 202.26,87.38 201.86,87.78 201.86,88.86 201.85,88.86
  IN1 w0.152: v2(180.87,87.32) 181.27,87.32 181.46,87.51 192.81,87.51 195.62,90.31 200.4,90.31 201.85,88.86
  BOTTOM w0.185: UV8.G3 v2(202.66,86.28) ; UV1.D14 180.09,87.31 180.86,87.31 180.86,87.32 v2(180.87,87.32)
FBC_RST#_H: length 27.9
  TOP w0.11: v2(203.46,97.86) 203.92,97.41 203.92,96.64
  TOP w0.185: 203.92,96.64 203.92,95.59 RV110.1 203.63,95.31 203.63,95.04 201.55,92.95 198.76,92.95 198.25,92.44 v2(198.25,91.99)
  BOTTOM w0.185: UV9.J2 v2(203.46,97.86) ; UV1.A17 182.15,89.47 187.9,89.47 188.19,89.76 193.03,89.76 193.9,90.63 196.82,90.63 197.62,91.43 197.88,91.43 198.25,91.81 v2(198.25,91.99)
FBC_RST#_L: length 27.4
  TOP w0.102: v2(203.46,87.08) 203.46,89.02 203.71,89.27
  TOP w0.185: 203.71,89.27 RV111.1 202.97,90.42 v3(201.72,90.42) 195.57,90.42 193.56,88.41 191.57,88.41 190.19,87.02 v2(190.19,86.99)
  BOTTOM w0.185: UV8.J2 v2(203.46,87.08) ; v2(190.19,86.99) 190.19,87.13 189.63,87.68 188.41,87.68 188.22,87.49 185.3,87.49 185.08,87.72 182.1,87.72 UV1.A15
FBC_WCK0: length 26.1
  IN4 w0.102: 199.78,83.56 199.84,83.62 199.84,84.04 199.72,84.16 v2(199.46,84.68) ; v2(178.46,82.31) 178.63,82.14 178.63,81.81 179.34,81.11 184.24,81.11 184.57,80.78 184.56,80.78
  IN4 w0.117: 199.78,83.56 199.18,82.96 196.16,82.96 193.59,80.39 184.95,80.39 184.56,80.78
  BOTTOM w0.124: v2(178.46,82.31) 178.07,81.91 UV1.F8 ; v2(199.46,84.68) 199.86,85.08 UV8.D4
FBC_WCK0_N: length 24.6
  IN4 w0.102: 184.71,80.93 184.7,80.93 184.32,81.32 179.42,81.32 178.84,81.9 178.84,82.14 179,82.31 v2(179.29,82.31) ; v2(199.46,83.88) 199.46,83.56
  IN4 w0.117: 199.46,83.56 199.46,83.55 199.09,83.18 196.07,83.18 193.5,80.61 185.04,80.61 184.72,80.93 184.71,80.93
  BOTTOM w0.124: UV8.D5 v2(199.46,83.88) ; UV1.E8 v2(179.29,82.31)
FBC_WCK1: length 29.9
  IN1 w0.102: 207.05,83.68 207.05,83.97 207.08,84.04 207.17,84.13 v2(207.46,84.68) ; 184.85,80.78 184.69,80.78 183.97,80.06 183.09,80.06 182.96,80.19 182.96,80.37 v2(183.22,80.63)
  IN1 w0.117: 184.85,80.78 194.77,80.78 196.85,82.86 206.44,82.86 207.05,83.46 207.05,83.68
  BOTTOM w0.124: UV8.P4 v2(207.46,84.68) ; UV1.A5 182.21,79.53 182.56,79.53 183.03,80 183.03,80.45 v2(183.22,80.63)
FBC_WCK1_N: length 29.8
  IN1 w0.102: 207.27,83.38 207.27,83.69 v2(207.46,83.88) ; 184.85,80.56 184.75,80.56 184.05,79.86 183,79.86 182.75,80.11 182.75,80.37 v2(182.49,80.63)
  IN1 w0.117: 184.85,80.56 194.86,80.56 196.94,82.63 206.53,82.63 207.27,83.38
  BOTTOM w0.124: UV1.A6 182.09,79.91 182.25,79.75 182.46,79.75 182.81,80.09 182.81,80.42 182.6,80.63 v2(182.49,80.63) ; UV8.P5 v2(207.46,83.88)
FBC_WCK2: length 26.4
  IN4 w0.102: 199.93,101.49 199.93,101.27 199.88,101.22 199.88,100.68 v2(199.46,100.26) ; v2(179.29,95.63) 179.29,95.86 179.49,96.05 180.07,96.64 182.12,96.64 183.14,97.66 183.14,97.7 183.31,97.87 183.98,97.87 184.2,98.09 184.2,98.1 184.33,98.23 184.39,98.23 184.4,98.24 184.41,98.24
  IN4 w0.117: 184.41,98.24 186.55,98.24 188.96,100.65 195.18,100.65 196.55,102.01 199.62,102.01 199.93,101.7 199.93,101.49
  BOTTOM w0.124: v2(199.46,100.26) 199.86,99.87 UV9.P4 ; UV1.D24 179.69,95.23 v2(179.29,95.63)
FBC_WCK2_N: length 24.7
  IN4 w0.102: v2(199.46,101.06) 199.46,101.21 199.71,101.45 199.71,101.46 ; v2(180.09,95.63) 179.82,95.9 179.82,96.1 180.15,96.43 182.2,96.43 182.28,96.51 183.28,97.51 183.44,97.67 184.07,97.67 184.41,98.02
  IN4 w0.117: 199.71,101.46 199.71,101.61 199.52,101.79 196.64,101.79 195.27,100.42 189.05,100.42 186.64,98.02 184.41,98.02
  BOTTOM w0.124: UV9.P5 199.86,100.67 v2(199.46,101.06) ; v2(180.09,95.63) 179.69,96.03 UV1.D25
FBC_WCK3: length 32.5
  IN1 w0.102: 207.75,101.34 207.75,101.31 207.84,101.22 207.84,100.64 v2(207.46,100.26) ; 184.46,97.52 182.97,97.52 182.19,96.74 181.55,96.74 181.39,96.89 181.39,97.01 v2(181.69,97.31)
  IN1 w0.117: 207.75,101.34 207.75,101.81 207.11,102.45 199.05,102.45 198.34,101.74 190.96,101.74 186.74,97.52 184.46,97.52
  BOTTOM w0.124: UV9.D4 207.86,99.86 v2(207.46,100.26) ; UV1.B27 v2(181.69,97.31)
FBC_WCK3_N: length 31.5
  IN1 w0.102: v2(180.89,97.31) 181.19,97.01 181.19,96.81 181.39,96.6 181.39,96.6 181.46,96.54 182.28,96.54 183.04,97.29 184.46,97.29 ; v2(207.46,101.06) 207.46,101.34
  IN1 w0.117: 207.46,101.34 207.46,101.45 207.53,101.51 207.53,101.72 207.02,102.23 199.15,102.23 198.43,101.51 191.05,101.51 186.84,97.29 184.46,97.29
  BOTTOM w0.124: UV1.C27 v2(180.89,97.31) ; v2(207.46,101.06) 207.86,100.66 UV9.D5
FBC_WE#_H: length 34.9
  TOP w0.102: 205.08,104 205.42,104.34 205.42,105.48 205.06,105.84 v2(205.06,105.86)
  TOP w0.185: 205.08,104 205.08,103.21 204.64,102.77 198.57,102.77 v4(198.07,102.27) 196.88,101.07 196.65,101.07 194.38,98.81 193.98,98.81 192.77,97.6 192.77,97.02 192.78,97.02 192.78,95.45 189.75,92.42 v2(189.75,92.24)
  BOTTOM w0.185: UV9.G12 v2(205.06,105.86) ; v2(189.75,92.24) 189.75,92.07 189.49,91.82 184.58,91.82 184.29,91.53 182.36,91.53 181.44,90.61 180.89,90.61 UV1.C18
FBC_WE#_L: length 30.3
  TOP w0.102: 196.5,83.07 197.49,82.08 204.23,82.08 205.27,81.04 205.27,80.64 205.46,80.44 205.46,79.48 v2(205.06,79.08)
  TOP w0.185: 196.5,83.07 196.49,83.06 196.48,83.06 v4(192.15,83.06) 191.73,83.06 v2(191.51,83.28)
  BOTTOM w0.185: v2(191.51,83.28) 191.51,83.73 191.18,84.06 185.53,84.06 183.91,85.69 182.28,85.69 181.46,86.51 180.89,86.51 UV1.C14 ; UV8.L12 v2(205.06,79.08)
FBVDD_EN: length 105
  TOP w0.114: v2(171.23,74.03) 171.23,73.81 DV13.1 170.19,71.71 RV209.1 171.31,70.6 173.11,70.6 173.67,70.04 173.67,69.19 175.87,67 177.07,67 178.6,68.52 179.78,68.52 180.07,68.81 180.07,71.75 180.43,72.1 180.76,72.1 181.19,72.53 184.54,72.53 184.92,72.91 v4(195.65,72.91) 203.16,72.91 204.2,71.87 204.61,71.87 205,72.27 QZ6.5
  IN1 w0.094: v2(171.23,74.03) 172.45,74.03 172.6,74.18 172.6,75.67 172.03,76.24 172.03,79.82 171.49,80.37 171.49,81.19 170.7,81.98 170.7,82.42 170.29,82.83 169.77,82.83 169.15,82.22 165.57,82.22 165.22,81.86 163.91,81.86 162.84,82.94 161,82.94 160.81,82.75 159.9,82.75 159.59,82.44 154.66,82.44 152.42,84.68 152.42,85.18 149.68,87.93 149.68,100.2 142.63,107.25 v2(142.63,108.96)
  BOTTOM w0.114: v2(142.63,108.96) 142.5,109.08 PR903.1
FBVDDQ_SENSE: length 71.6
  TOP w0.254: v2(145.27,106.44) 144.21,106.44 v3(142.58,108.07) 141.19,108.07 139.91,109.34 139.91,109.74 140.4,110.23 141.74,110.23 142.1,110.58 PR912.2
  IN1 w0.254: v2(178.39,74.91) 177.67,74.91 177.35,75.23 177.35,75.94 176.64,76.65 176.64,78.28 176.34,78.58 176.34,80.74 175.62,81.45 174.99,81.45 173.67,82.77 173.14,82.77 172.18,81.81 171.58,81.81 171.3,82.09 171.3,82.48 170.48,83.3 169.57,83.3 168.96,82.69 165.37,82.69 165.02,82.34 164.27,82.34 164.02,82.59 164.02,83.34 163.74,83.62 162.06,83.62 161.49,84.19 161.13,84.19 160.33,83.39 159.81,83.39 159.47,83.73 159.47,84.17 159.17,84.47 155.38,84.47 150.76,89.09 150.76,100.68 149.27,102.16 149.27,104.84 147.67,106.44 v2(145.27,106.44)
  BOTTOM w0.254: UV1.F1 178.17,76.11 178.39,75.89 v2(178.39,74.91)
FCCM_GT: length 75.3
  IN4 w0.254: v2(91.96,132.71) 91.35,132.1 90.37,132.1 88.5,130.23 88.5,127.47 85.05,124.02 64.45,124.02 63.61,123.18 63.61,109.79 v2(64.2,109.21)
  BOTTOM w0.203: 67.75,91.81 68.2,91.37 PU1100.11
  BOTTOM w0.254: PR1515.1 67.35,109.44 v4(65.45,109.44) 64.42,109.44 v2(64.2,109.21) 64.2,108.49 64.72,107.97 66.56,107.97 68.21,106.31 68.21,102.56 65.8,100.14 65.8,94.25 67.75,92.29 67.75,91.81 ; PR1503.1 v2(91.96,132.71)
FCCM_SA: length 108.9
  TOP w0.114: v2(130.67,130.24) v4(130.67,131.32)
  IN4 w0.254: v2(130.67,130.24) 129.55,131.36 123.49,131.36 123.31,131.18 110.38,131.18 109.98,131.59 105.04,131.59 104.25,130.8 95.8,130.8 95.51,130.51 95.51,129.27 94.66,128.41 93.02,128.41 92.36,127.76 92.36,126.76 92.36,126.76 92.36,126.34 90.14,124.12 89.46,124.12 86.31,120.97 71.73,120.97 71.05,120.3 71.05,114.86 68.69,112.5 68.69,108.09 69.5,107.28 69.5,104.82 71,103.32 71,99.1 72.07,98.03 74.13,98.03 77.63,94.53 77.63,92.47 75.14,89.98 75.14,88.66 v2(75.63,88.18)
  BOTTOM w0.203: v2(75.63,88.18) 75.61,88.17 PU1100.34
  BOTTOM w0.254: PR1530.1 130.74,130.17 v2(130.67,130.24)
FCCM_VCORE: length 102.5
  TOP w0.254: v2(111.92,132.81) 111.15,133.58 102.38,133.58 v4(102.14,133.33) 101.91,133.11 v2(101.91,132.81)
  IN1 w0.254: v2(122.9,132.73) 122.9,132.45 122.64,132.2 114.87,132.2 113.67,133.39 112.51,133.39 v2(111.92,132.81)
  IN4 w0.254: v2(74.3,93.34) 73.9,92.93 69.86,92.93 65.92,96.87 65.92,112.61 69.02,115.71 69.02,121.14 70.88,123 85.47,123 89.52,127.05 89.52,129.81 90.79,131.08 93.21,131.08 95.55,133.42 101.33,133.42 101.91,132.83 v2(101.91,132.81)
  BOTTOM w0.203: PU1100.24 73.94,93.12 74.15,93.34 v2(74.3,93.34)
  BOTTOM w0.254: v2(122.9,132.73) 122.9,132.45 122.34,131.89 PR1404.1 ; PR1417.1 111.9,132.78 v2(111.92,132.81) ; PR1431.1 101.91,132.15 v2(101.91,132.81)
FRM_LCK: length 19.2
  TOP w0.102: 183.78,79.34 183.16,79.34 v3(183.16,79.34) 175.45,79.34 v2(175.07,79.72)
  TOP w0.114: RV581.1 188.48,74.96 188.26,75.18 188.26,77.42 186.34,79.34 183.78,79.34
  BOTTOM w0.114: v2(175.07,79.72) 175.07,79.71 173.79,80.99 UV1.L7
GC6_EVENT#_D: length 10.9
  BOTTOM w0.114: RV42.1 175.05,70.64 175.05,72.47 DV9.2 174.63,73.52 v3(174.99,73.88) 174.99,75.71 174.2,76.49 174.2,79.74 UV1.L6
GPU_CORE_PG: length 137.9
  TOP w0.114: v2(174.63,50.16) 175.09,49.7 v4(178.44,49.7) 188.16,49.7 194.87,56.41 197.99,56.41 198.47,55.92 UV21.2 ; DV14.3 150.84,108.32 150.43,107.91 149.17,107.91 148.52,107.26 147.05,107.26 145.61,105.82 145.61,102.31 143.43,100.12 v2(143.11,100.12)
  IN1 w0.094: v2(143.11,100.12) 143.48,99.75 143.48,99.35 143.27,99.15 143.27,84.02 144.54,82.75 144.96,82.75 145.36,82.35 145.36,81.77 145.03,81.44 145.03,80.76 145.67,80.13 145.67,79.89 145.2,79.42 145.2,76.19 146.56,74.82 146.56,73.69 147.34,72.91 147.34,71.25 145.84,69.76 145.84,68.26 144.13,66.55 144.13,64.4 141.56,61.83 141.56,46.55 144.1,44.02 150.86,44.02 154.45,47.61 161.04,47.61 162.1,48.67 166.7,48.67 167,48.98 169.6,48.98 170.83,50.21 174.58,50.21 v2(174.63,50.16)
  BOTTOM w0.114: PR1619.2 174.86,50.16 v2(174.63,50.16)
GPU_EVENT#: length 94.3
  IN1 w0.094: v2(146.34,71.87) 145.88,71.41 145.18,71.41 144.99,71.22 144.99,68.61 143.28,66.9 143.28,64.85 140.78,62.35 140.78,46.23 150.96,36.05 150.96,32.92 153.06,30.83 153.74,30.83 154.43,30.14 160.08,30.14 160.36,29.86 162.01,29.86 162.88,28.99 163.59,28.99 165.23,27.35 166.45,27.35 v2(166.81,26.99)
  BOTTOM w0.089: UH2.AR24 166.89,26.91 v2(166.81,26.99)
  BOTTOM w0.114: DV9.1 174.05,70.91 167.78,70.91 167.12,71.57 160.96,71.57 160.63,71.24 158.01,71.24 v3(157.83,71.42) 157.62,71.63 149.92,71.63 149.58,71.29 146.75,71.29 146.34,71.71 v2(146.34,71.87)
GPU_GC6_FB_EN: length 21.2
  TOP w0.114: v2(172.21,75.11) 171.91,75.11 RV37.1 ; QV10.3 176.61,65.68 v3(176.17,66.12) 176.17,66.39 173.44,69.12 173.44,69.89 172.98,70.35 170.77,70.35 169.59,71.52 169.59,73.08 169.83,73.32 170.16,73.32 170.72,73.88 170.72,74.08 171.31,74.67 RV37.1 ; DV13.3 171.71,73.81 171.71,74.41 RV37.1
  BOTTOM w0.114: v2(172.21,75.11) 172.58,75.48 172.58,76.42 172.69,76.53 173.15,76.53 173.36,76.75 173.36,77.28 172.99,77.66 UV1.M3
GPU_HPD_RT: length 103.1
  TOP w0.114: RM600.2 260.31,37.96 v2(259.98,38.29) ; v2(188.26,57.28) 187.08,58.46 v3(182.09,58.46) 181.12,58.46 180.32,59.25 180.06,59.25 179.59,59.72 177.3,59.72 176.95,59.38 175.61,59.38 174.67,60.32 174.67,61.5 174.95,61.79 174.95,64.02 175.42,64.49 RV610.2 175.36,64.67 UV22.1
  IN1 w0.094: v2(188.26,57.28) 189.01,56.53 193.27,56.53 199.66,50.13 199.68,50.13 200.42,49.39 203.97,49.39 205.7,47.67 208.82,47.67 212.14,44.35 213.94,44.35 214.18,44.11 214.18,43.73 214.49,43.42 218.21,43.42 218.47,43.16 228.15,43.16 228.63,43.64 239.85,43.64 240.64,42.84 257.14,42.84 259.98,40.01 v2(259.98,38.29)
GPU_JTAG_TCK: length 5.3
  BOTTOM w0.114: UV1.AM10 156.09,83.56 155.66,83.12 151.65,83.12 T98.1
GPU_JTAG_TDI: length 6.3
  BOTTOM w0.114: UV1.AM11 156.29,84.27 156.67,83.89 156.67,83.4 156.36,83.08 156.13,83.08 155.86,82.81 155.86,82.55 155.65,82.33 155.61,82.33 155.58,82.31 154.31,82.31 153.85,81.85 152.51,81.85 T99.1
GPU_JTAG_TDO: length 2.2
  BOTTOM w0.114: T100.1 152.59,85.08 154.56,85.08 UV1.AP12
GPU_JTAG_TMS: length 3.8
  BOTTOM w0.114: T101.1 151.93,85.04 152.38,84.6 154.5,84.6 UV1.AP11
GPU_JTAG_TRST#: length 4.6
  BOTTOM w0.114: UV1.AN11 154.93,83.85 153.79,83.85 153.46,83.52 v4(152.71,83.52) 151.56,83.52 RV63.1
GPU_LEVEL: length 6.5
  TOP w0.114: RV60.1 173.36,74.04 173.36,75.04 173.75,75.43 DV11.2 173.49,75.81 173.25,76.05 173.25,77.32 172.57,78 v2(172.57,78.1) v3(172.94,78.47)
  BOTTOM w0.114: v2(172.57,78.1) 172.53,78.1 UV1.N3
GPU_PEX_RST_HOLD#: length 31.3
  TOP w0.114: UV18.2 152.69,73.12 v3(152.53,72.96) 152.11,72.54 151.76,72.54 v2(151.35,72.95)
  IN1 w0.094: v2(170.04,82.24) 169.63,81.83 165.73,81.83 165.38,81.47 163.52,81.47 163.15,81.85 161.22,81.85 160.77,81.4 158.85,81.4 157.5,80.06 156.33,80.06 155.33,79.06 155.33,78.36 151.32,74.36 151.32,73.91 151.35,73.89 v2(151.35,72.95)
  BOTTOM w0.114: RV41.1 148.31,74.75 148.9,74.16 149.13,74.16 149.81,73.48 150.81,73.48 v2(151.35,72.95) ; v2(170.04,82.24) 169.64,81.84 UV1.T8
GPU_PSI: length 67.1
  TOP w0.114: v2(186.6,57.31) 186.15,56.86 v4(183.79,56.86) 181.06,56.86 PR1601.2 ; PR1701.2 200.32,51.11 v2(199.64,51.11) ; RV574.1 173.95,77.71 173.95,80 v2(173.36,80.58)
  IN1 w0.094: v2(173.36,80.58) 173.49,80.58 173.95,80.13 175.24,80.13 175.45,79.92 175.45,78.33 175.53,78.26 175.53,77.18 175.47,77.13 175.47,76.39 175.1,76.02 174.24,76.02 174,75.78 174,74.69 174.33,74.36 174.44,74.36 175.13,73.68 179.44,73.68 180.02,73.09 180.02,68.57 179.64,68.19 178.44,68.19 178.15,67.89 178.15,64.72 182.68,60.19 185.47,60.19 186.6,59.06 v2(186.6,57.31)
  IN3 w0.127: v2(186.6,57.31) 186.6,57.57 187.08,58.05 190.37,58.05 196.99,51.44 199.31,51.44 v2(199.64,51.11)
  BOTTOM w0.114: v2(173.36,80.58) 172.99,80.96 UV1.M7
GPU_PWR_LEVEL: length 92.3
  TOP w0.114: DV11.1 174.21,74.88 v2(174.38,74.88) ; v2(212.79,26.28) 212.24,25.73 212.24,22.31 212.93,21.62 214.47,21.62 215.92,23.07 218.36,23.07 219.28,22.14 UE1.21
  IN1 w0.094: v2(174.38,74.88) 174.38,74.79 175.24,73.93 179.46,73.93 180.22,73.17 180.22,68.44 179.77,67.99 178.52,67.99 178.34,67.81 178.34,64.8 182.75,60.39 185.76,60.39 187.75,58.4 187.75,56.97 188.6,56.12 193.02,56.12 200.77,48.38 204.48,48.38 205.5,47.36 206.92,47.36 208.49,45.79 208.49,44.95 v2(208.47,44.92)
  BOTTOM w0.114: v2(212.79,26.28) 212.91,26.4 212.91,26.4 213.9,27.39 213.9,28.81 213.18,29.53 213.18,33.15 212.17,34.16 212.17,38.66 210.47,40.35 209.78,40.35 v4(208.47,41.66) v2(208.47,44.92)
GPU_THM_SMBCLK: length 248.6
  TOP w0.114: v2(221.57,26.12) 221.19,25.74 UE1.12 ; v2(53.1,49.14) 53.1,49.14 v4(53.67,48.56) 54.21,48.03 54.35,48.03 55.08,48.76 65.16,48.76 v2(65.41,49.01)
  IN1 w0.094: v2(150.66,24.58) 150.46,24.77 145.56,24.77 143.68,26.65 143.68,28.36 142.79,29.25 142.79,41.02 138.44,45.37 138.44,51.03 137.76,51.72 137.76,52.11 v2(138.15,52.5) 138.34,52.69 138.34,64.99 142.96,69.61 v2(142.96,74.18)
  IN4 w0.094: v2(224.2,21.22) 223.98,21.45 220.52,21.45 219.29,22.68 215.33,22.68 214.08,23.93 212.68,23.93 211.87,23.12 199.65,23.12 198.05,21.53 195.81,21.53 195.09,20.81 195.09,19.46 194.14,18.5 182.08,18.5 181.06,17.48 178.96,17.48 178.52,17.92 176.51,17.92 176.15,17.56 170.32,17.56 169.71,18.18 156.26,18.18 152.55,21.89 152.55,22.68 v2(150.66,24.58)
  BOTTOM w0.114: v2(150.66,24.58) 151.11,25.03 151.77,25.03 151.92,25.18 QH5.6 ; v2(65.41,49.01) 65.67,48.76 66.56,48.76 66.81,49.01 66.81,50.48 67.97,51.64 136.43,51.64 137.08,52.29 137.94,52.29 v2(138.15,52.5) ; QV1.6 147.52,73.46 147.63,73.58 147.63,74.22 147.33,74.53 146.54,74.53 146.1,74.09 143.06,74.09 v2(142.96,74.18) ; v2(224.2,21.22) 224.38,21.4 224.38,23.47 224.27,23.59 223.73,23.59 RE46.1 222.64,24.25 221.57,25.32 v2(221.57,26.12) ; v2(53.1,49.14) 53.1,49.57 RT7.2 52.4,49.28 QT2.3
GPU_THM_SMBDAT: length 252
  TOP w0.114: v2(222.23,26.11) 221.8,26.53 221.4,26.53 221.01,26.14 UE1.11 ; v2(65.41,48.38) 65.26,48.53 55.18,48.53 54.32,47.67 54.32,46.51 v2(54.37,46.46)
  IN1 w0.094: v2(142.94,74.82) 143.04,74.82 143.39,74.46 143.39,74.01 143.18,73.79 143.18,69.52 138.56,64.9 138.56,52.29 138.42,52.16 138.42,52.15 v2(138.16,51.89) 138.16,51.67 138.71,51.12 138.71,45.44 143.02,41.13 143.02,29.3 143.88,28.44 143.88,26.73 145.63,24.98 150.93,24.98 v2(151.32,24.59)
  IN4 w0.094: v2(151.32,24.59) 152.78,23.13 152.78,21.94 156.29,18.43 169.73,18.43 170.4,17.76 176.07,17.76 176.43,18.11 178.65,18.11 179.09,17.67 180.89,17.67 181.92,18.7 191.47,18.7 194.49,21.72 197.97,21.72 199.57,23.32 211.79,23.32 212.6,24.13 214.16,24.13 215.41,22.87 219.37,22.87 220.6,21.64 224.39,21.64 v2(224.81,21.22)
  BOTTOM w0.114: v2(224.81,21.22) 224.61,21.43 224.61,23.34 v3(225.18,23.91) 225.18,24.5 224.93,24.76 223.58,24.76 RE45.1 v2(222.23,26.11) ; v2(65.41,48.38) 65.57,48.53 66.65,48.53 67.07,48.94 67.07,50.43 68.06,51.43 136.53,51.43 137.17,52.06 138,52.06 v2(138.16,51.89) ; v2(54.37,46.46) 54.37,46.33 54,45.96 RT6.2 53.81,46.85 QT2.6 ; QV1.3 148.39,72.16 148.07,72.48 148.07,74.1 147.1,75.06 145.79,75.06 145.61,74.88 142.99,74.88 v2(142.94,74.82) ; v2(151.32,24.59) 150.9,24.17 150.73,24.17 150.62,24.06 QH5.3
GVDD: length 16
  TOP w0.508: v2(266.33,24.63) 268.41,24.63 v2(269.86,23.18)
  BOTTOM w0.254: UA2.2 262.28,21.97 262.11,22.14 ; 261.78,22.16 UA2.1
  BOTTOM w0.508: RA63.1 v2(266.33,24.63) 266.33,24.88 265.82,25.39 v4(262.39,25.39) 261.88,24.88 RA65.1 261.71,23.94 260.94,23.18 CD93.1 ; v2(269.86,23.18) 269.55,23.49 RA61.1 RA60.1
H_CATERR#: length 5.5
  TOP w0.114: RH144.2 v4(88.95,94.99) 90.05,94.99 v2(90.56,95.49)
  BOTTOM w0.114: v2(90.56,95.49) 90.56,95.47 90.24,95.15 UH1.BM30
H_CPUPWRGD: length 187.7
  TOP w0.114: v2(79.18,95.72) v4(78.46,95.72)
  IN4 w0.094: v2(79.18,95.72) 78.61,96.3 78.61,98.65 87.35,107.39 128.86,107.39 152.33,83.93 152.33,81.69 153.89,80.13 155.45,80.13 156.14,79.44 156.14,77.21 157.25,76.1 164.79,76.1 165.82,75.07 167.25,75.07 168.73,73.59 169.57,73.59 172.38,70.77 172.38,66.29 191.66,47.02 191.66,38.92 v2(191.3,38.57)
  BOTTOM w0.076: UH2.AM3 177.85,28.35 178.09,28.58 180.36,28.58 180.53,28.76 181.19,28.76 181.57,29.13 181.57,29.94
  BOTTOM w0.102: 181.57,29.94 183.43,31.79
  BOTTOM w0.114: 183.43,31.79 183.68,31.79 184.41,32.53 184.41,33.42 184.88,33.89 185.48,33.89 186.71,35.11 186.71,35.51 188.8,37.6 189.43,37.6 190.07,38.24 190.98,38.24 v2(191.3,38.57) ; v2(79.18,95.72) 79.43,95.72 80.61,96.9 85.42,96.9 86.41,95.91 UH1.BT31
H_DRAMRST#: length 93.1
  IN3 w0.127: v2(96.28,18.71) 97.28,19.71 100.05,19.71 100.06,19.73 138.06,19.73 138.97,20.64 141.56,20.64 v2(141.86,20.93)
  IN4 w0.094: v2(141.86,20.93) 148.02,27.09 151.77,27.09 154.26,24.61 154.26,22.78 156.52,20.53 161.67,20.53 162.61,21.46 164.4,21.46 165.1,22.17 166.64,22.17 166.7,22.11 171.61,22.11 172.19,21.53 172.19,21.16 172.59,20.76 v2(172.71,20.76)
  BOTTOM w0.076: v2(172.71,20.76) 172.99,21.03 172.99,22.22 172.88,22.33 172.88,22.83 UH2.BC14
  BOTTOM w0.114: v2(96.28,18.71) 95.03,17.47 v3(95.03,17.1) 95.03,16.74 95.15,16.63 CD69.1 96.05,16.58 RD31.2 RD35.2
H_PM_DOWN: length 183.9
  IN3 w0.127: v2(181.7,31.94) 181.7,32.84 184.18,35.32 185.11,35.32 185.4,35.61 185.4,37.02 178.53,43.88 178.53,45.44 176.93,47.04 171.36,47.04 170.53,46.21 151.22,46.21 149.16,44.15 143.57,44.15 140.76,46.96 140.76,65.64 143.89,68.76 143.89,72.73 143.46,73.17 143.46,73.75 143.61,73.9 143.61,76.42 144.45,77.26 144.45,78.48 139.89,83.04 139.89,96.29 130.98,105.2 105.91,105.2 104.8,104.08 89.91,104.08 86.54,100.7 86.54,98.43 85.63,97.53 v2(84.77,97.53)
  BOTTOM w0.076: UH2.AH2 178.66,29.91 179.92,29.91 180.45,30.44 180.45,30.77 181.62,31.94 v2(181.7,31.94)
  BOTTOM w0.114: v2(84.77,97.53) 84.64,97.65 v3(83.07,97.65) 81.8,97.65 81.21,98.24 RH155.1
H_PM_DOWN_R: length 8.4
  BOTTOM w0.076: UH1.BP31 88.59,96.23 88.11,96.23 88.07,96.19 86.82,96.19 85.29,97.72
  BOTTOM w0.114: 85.29,97.72 84,99.01 v3(83.13,99.01) 82.85,99.01 RH155.2
H_PM_SYNC_R: length 165.6
  TOP w0.114: v4(89.16,97.81) 89.77,97.81 v2(89.85,97.88)
  IN3 w0.127: v2(184.75,36.31) 183.05,38.01 182.56,38.01 180.87,39.7 180.79,39.7 179.26,41.24 179.26,41.37 176.96,43.67 162.56,43.67 162.29,43.93 162.29,45.43 162.04,45.68 157.01,45.68 155.01,43.69 143.38,43.69 140.31,46.77 140.31,65.94 143.43,69.07 143.43,72.51 142.05,73.89 142.05,76.06 143.95,77.96 143.95,78.33 143.3,78.98 142.07,78.98 138.97,82.09 138.97,95.87 132.81,102.03 132.02,102.03 130.9,103.14 90.27,103.14 89.14,102.01 89.14,100.11 89.85,99.4 v2(89.85,97.88)
  BOTTOM w0.114: v2(184.75,36.31) 184.32,35.88 RH189.2 ; v2(89.85,97.88) 90.18,97.55 UH1.BM34
H_PROCHOT#: length 325.9
  TOP w0.114: v2(69.1,82.41) 68.77,82.74 68.77,82.79 PR1109.1
  IN1 w0.094: v2(239.69,21.86) 239.45,21.86 238.08,20.49 235.32,20.49 233.79,18.96 230.67,18.96 228.35,16.64 223.35,16.64 222.89,17.1 221.38,17.1 220.97,17.5 217.23,17.5 215,15.27 200.94,15.27 198.56,12.88 196.58,12.88 195.22,11.53 185.22,11.53 182.63,8.93 178.87,8.93 178.55,8.61 171.43,8.61 167.19,12.85 161.26,12.85 159.5,11.09 118.67,11.09 114.39,15.37 94.27,15.37 93.62,16.01 75.69,16.01 75.14,15.46 64.83,15.46 57.74,22.55 57.74,24.88 55.61,27.02 v2(54.67,27.02)
  IN3 w0.127: v2(56.59,51) 61.99,56.4 61.99,69.27 65.45,72.74 66.64,72.74 68.89,74.99 68.89,79.73 67.74,80.88 67.74,81.48 68.67,82.41 v2(69.1,82.41) 70.42,83.73 72.49,83.73 77.78,89.02 77.78,91.67 80.13,94.02 v2(81.15,94.02) ; v2(54.21,44.7) 54.01,44.5 54.01,27.6 54.38,27.23 54.46,27.23 v2(54.67,27.02)
  IN4 w0.094: v2(56.59,51) 56.02,50.43 56.02,46.9 54.21,45.09 v2(54.21,44.7)
  BOTTOM w0.114: v2(81.15,94.02) 82.64,94.02 83.02,94.4 RH165.2 83.17,94.76 83.51,94.76 83.85,94.76 84.01,94.61 RH158.1 ; CE86.1 236.71,25.77 236.95,26.01 UE6.4 237.64,26.01 238.26,25.4 238.26,24.58 238.5,24.34 238.51,24.34 239.74,23.11 239.74,21.89 239.71,21.86 v2(239.69,21.86) ; v2(56.59,51) 56,50.41 v4(49.9,50.41) 48.79,50.41 47.69,49.3 PR217.2 44.46,48.89 43.11,47.54 PR215.2 PR216.2 43.11,46.05 42.9,45.84 38.13,45.84 36.15,43.86 32.34,43.86 31.79,43.3 31.79,42.51 PR326.2
H_PROCHOT#_R: length 4.3
  BOTTOM w0.076: v3(85.47,95.65) 85.3,95.48 RH158.2 85.71,94.61 85.94,94.83 88,94.83 88.23,95.07 UH1.BR30
H_PROCHOT_EC: length 7
  TOP w0.114: v2(237.2,26.56) 237.07,26.43 237.07,25.36 236.94,25.23 236.94,25.22 236.77,25.06 236.76,25.06 236.65,24.94 UE1.83
  BOTTOM w0.114: v3(240.18,26.22) 239.74,26.66 UE6.2 238.67,26.66 238.39,26.94 237.58,26.94 v2(237.2,26.56) 237.09,26.66 RE27.2
H_THERMTRIP#: length 8.4
  BOTTOM w0.076: UH2.AJ3 178.26,30.37 178.55,30.37 178.84,30.09 179.85,30.09 180.25,30.49 180.25,30.82 181.24,31.81 181.24,32.12
  BOTTOM w0.102: 182.31,33.53 182.31,33.19 v3(181.64,32.52) 181.24,32.12
  BOTTOM w0.114: RH191.1 182.51,34.33 182.51,33.73 182.31,33.53
H_THERMTRIP#_R: length 122.1
  TOP w0.114: v2(122.84,96.17) 122.25,95.58 RH163.2
  IN3 w0.127: v2(122.84,96.17) 123.31,96.64 123.31,97.74 123.31,98.45 126.09,101.23 127.54,101.23 128.47,102.16 130.65,102.16 131.64,101.16 132.4,101.16 134.41,99.15 134.41,82.98 137.2,80.2 137.2,74.46 136.6,73.87 136.6,69.57 139.21,66.96 139.21,46.16 142.8,42.57 155.42,42.57 155.58,42.41 156.65,42.41 157.29,43.04 160.8,43.04 161.74,42.1 172.3,42.1 174.65,39.76 178.86,39.76 182.23,36.39 v2(182.64,36.39)
  BOTTOM w0.076: UH1.J31 123.2,95.81 v2(122.84,96.17)
  BOTTOM w0.114: RH191.2 183.14,36.1 182.85,36.39 v2(182.64,36.39)
H_VCCST_PWRGD: length 3.8
  TOP w0.114: v3(129.72,76.83) 130.13,76.41 RH154.1 RH164.2 131.92,76.41 132.49,76.97 UC16.4
HDA_BITCLK: length 11.9
  BOTTOM w0.114: RP15.7 181.12,17.38 180.3,18.2 CH50.2 180.3,18.84 179.89,19.25 179.05,19.25 178.17,18.37 v3(177.78,18.37) 175.55,20.59 175.55,22.16 175.65,22.27 175.65,23.2 UH2.BA9
HDA_BITCLK_AUDIO: length 110.1
  IN4 w0.094: v2(185.77,12.55) 185.93,12.39 194.82,12.39 200.2,17.76 210.79,17.76 212.08,16.47 213.86,16.47 215.06,17.67 215.06,18.16 215.38,18.48 216.47,18.48 217.17,17.78 217.87,17.78 218.07,17.58 219.92,17.58 220.91,16.6 223.36,16.6 223.97,15.98 228.6,15.98 228.84,16.23 231.91,16.23 232.25,16.58 234.69,16.58 236.18,18.06 246.2,18.06 247.57,19.42 250.91,19.42 253.57,22.08 256.66,22.08 257.41,22.84 257.41,24.4 257.87,24.86 261.57,24.86 263.41,23.02 265.64,23.02 266.72,21.94 268.03,21.94 268.84,22.75 270.82,22.75 270.95,22.63 271.37,22.63 272.06,23.32 v2(272.06,23.67)
  BOTTOM w0.114: v2(185.77,12.55) 185.46,12.87 184.62,12.87 v4(183.45,14.03) 182.06,14.03 181.12,14.97 RP15.2 ; RA31.1 CA32.1 274.61,23.92 RA35.2 274.53,23.31 274.08,22.85 272.99,22.85 272.19,23.65 272.09,23.65 v2(272.06,23.67)
HDA_CODEC_SDIN0: length 3.1
  TOP w0.114: HDA1.8 277.88,24.15 277.75,24.28 276.47,24.28 276.47,24.27 276.44,24.27 275.9,23.74 RA32.2
HDA_SDIN0: length 9.1
  BOTTOM w0.089: UH2.BE7 175.89,21.19 176.07,21.01
  BOTTOM w0.102: 178.55,20.92 176.16,20.92 176.07,21.01
  BOTTOM w0.114: 178.55,20.92 180.17,20.92 RH96.2 182.05,18.75 v3(182.72,18.07)
HDA_SDIN0_AUDIO: length 105.9
  TOP w0.114: v2(273.9,23.36) 273.9,23.57 274.07,23.74 RA32.1
  IN4 w0.094: v2(273.9,23.36) 273.18,24.08 271.83,24.08 271.19,23.44 270.36,23.44 270.22,23.58 268.64,23.58 268.2,23.14 266.37,23.14 265.89,23.62 263.92,23.62 262.07,25.47 257.63,25.47 256.81,24.65 256.81,23.09 256.41,22.68 251.7,22.68 249.09,20.08 242.09,20.08 241.2,19.19 238.97,19.19 238.45,18.66 237.26,18.66 237.26,18.66 235.9,18.66 234.42,17.18 232,17.18 231.66,16.83 228.59,16.83 228.35,16.59 224.22,16.59 223.61,17.2 221.16,17.2 219.83,18.52 217.28,18.52 216.61,19.19 214.33,19.19 213.87,18.74 210.54,18.74 210.17,18.37 198.89,18.37 195.26,14.73 188.94,14.73 187.21,12.99 v2(186.28,12.99)
  BOTTOM w0.114: v2(186.28,12.99) 186.28,13.87 v3(183.84,16.32) 183.39,16.77 183.39,18.62 RH96.1
HDA_SDOUT: length 21.6
  TOP w0.114: CH51.2 176.2,24.62 v2(175.52,23.94) 175.52,23.33 176.22,22.63 176.22,22.09 176.74,21.57 176.74,21.5 177.3,20.95 179.33,20.95 v2(180.1,20.18) ; RH18.2 186.4,15.43 186.18,15.22 186.18,14.52 v3(185.64,13.98) 185.47,13.81 v2(185.47,13.37)
  BOTTOM w0.089: v2(175.52,23.94) 175.81,23.65 UH2.BB7
  BOTTOM w0.114: v2(180.1,20.18) 180.98,19.29 180.98,18.47 181.62,17.83 RP15.8 182.63,16.89 185.47,14.04 v2(185.47,13.37)
HDA_SDOUT_AUDIO: length 104.6
  IN4 w0.094: v2(184.82,13.38) 186.37,14.92 188.15,14.92 188.65,15.43 194.97,15.43 198.61,19.06 205.5,19.06 206.55,20.11 213.63,20.11 213.85,19.89 216.9,19.89 217.57,19.22 220.12,19.22 221.44,17.9 228.2,17.9 228.51,17.59 229.53,17.59 230.42,18.47 234.02,18.47 235.36,19.82 238.31,19.82 239.28,20.79 241.82,20.79 242.54,21.5 244.79,21.5 246.11,22.82 247.38,22.82 247.56,22.65 249.69,22.65 251.02,23.97 254.18,23.97 256.38,26.17 265.45,26.17 267.22,24.4 v2(267.22,23.97)
  BOTTOM w0.114: v2(184.82,13.38) 184.82,13.93 184.03,14.72 182.38,14.72 181.62,15.48 RP15.1 ; v2(267.22,23.97) 267.22,24.1 267.95,24.84 268.06,24.84 268.39,25.16 268.39,25.35 268.73,25.69 v3(271.08,25.69) 271.46,25.69 272.13,26.36 273.36,26.36 273.64,26.08 CA31.1 RA29.1
HDA_SYNC: length 9.6
  BOTTOM w0.114: UH2.BD9 174.91,22.34 175.33,21.92 175.33,19.93 177.85,17.41 v3(178.86,17.41) 180.45,17.41 180.62,17.25 RP15.6
HDA_SYNC_AUDIO: length 109.7
  TOP w0.114: HDA1.10 277.04,23.36 v2(276.96,23.27)
  IN4 w0.094: v2(271,23.84) 270.91,23.93 268.46,23.93 268.06,23.52 266.56,23.52 266.02,24.06 265.19,24.06 263.43,25.82 256.52,25.82 254.33,23.63 251.41,23.63 248.22,20.44 239.42,20.44 238.45,19.47 235.51,19.47 234.17,18.13 231.8,18.13 231.57,17.9 231.57,17.4 231.34,17.18 228.45,17.18 228.2,16.93 224.36,16.93 223.75,17.55 221.3,17.55 219.98,18.87 217.43,18.87 216.76,19.54 214.19,19.54 213.74,19.09 210.4,19.09 210.02,18.71 198.75,18.71 195.11,15.08 188.8,15.08 188.29,14.58 187.25,14.58 185.61,12.93 183.96,12.93 v2(183.8,12.78)
  BOTTOM w0.114: v2(276.96,23.27) v3(276.35,22.67) 275.91,22.23 272.73,22.23 271.93,23.03 271.82,23.03 v2(271,23.84) ; RP15.3 180.62,14.53 181.74,13.41 183.17,13.41 v2(183.8,12.78)
HDD_DEVSLP: length 57.3
  TOP w0.114: RD62.1 194.07,18.91 v4(193.81,19.17) 193.52,19.46 v2(193.52,20.18)
  IN3 w0.127: v2(193.52,20.18) 193.24,19.9 188.17,19.9 187.01,18.75 183.32,18.75 180.32,15.75 178.89,14.32 171.73,14.32 171.5,14.54 171.5,17.18 170.43,18.25 169.41,18.25 169.18,18.48 165.96,18.48 162.87,21.57 162.51,21.57 159.82,24.26 158.31,24.26 156.82,25.75 155.88,25.75 154.92,26.7 154.92,29.43 v2(156.07,30.57)
  BOTTOM w0.102: UH2.AG43 158.02,31.01 157.82,31.21 157.48,31.21 157.22,30.95 156.6,30.95
  BOTTOM w0.114: 156.6,30.95 156.45,30.95 v2(156.07,30.57)
HDD_DEVSLP_R: length 4.8
  TOP w0.114: v2(194.04,13.88) 194.48,14.33 v3(194.48,14.57) 194.48,16.13 RD62.2
  BOTTOM w0.114: JHDD1.5 193.67,13.25 194.04,13.61 v2(194.04,13.88)
HDMI_CEC: length 79.4
  TOP w0.114: RM1.2 v2(271.47,29.62)
  IN3 w0.127: v2(271.47,29.62) 271.68,29.83 271.68,30.86 272.01,31.19 272.89,31.19 275.63,33.92 277.53,33.92 278.5,34.89 278.5,36.06 279.03,36.59 279.97,36.59 280.25,36.87 280.25,38.88 281.67,40.3 289.49,40.3 290.51,41.32 290.51,42.87 290.03,43.35 290.03,45.94 291.42,47.34 291.42,57.62 293.91,60.11 293.91,61 297.67,64.76 297.67,77 v2(296.99,77.69)
  BOTTOM w0.114: JHDMI1.13 301.29,72.74 301.29,77.92 300.86,78.35 v4(297.96,78.35) CV601.2 296.38,78.3 v2(296.99,77.69)
HDMI_HPD_PCH: length 85.9
  IN2 w0.127: v2(230.21,17.6) 229.47,17.6 228.19,16.32 224.09,16.32 222.81,17.6 218.82,17.6 218.65,17.44 215.31,17.44 215.02,17.73 215.02,18.49 213.7,19.81 213.7,21.29 211.08,23.9 v2(207.17,23.9)
  IN3 w0.127: v2(207.17,23.9) 206.75,23.48 204.6,23.48 203.81,24.27 191.43,24.27 186.59,19.43 183.03,19.43 181.26,17.66 178.83,17.66 178.61,17.88 177.98,18.51 172.98,18.51 172.37,19.12 171.97,19.12 171.79,18.94 169.95,18.94 169.6,19.28 167.29,19.28 166.91,19.66 166.91,19.85 166.01,20.75 165.21,20.75 162.51,23.46 161.59,23.46 160.02,25.03 160.02,25.57 159.57,26.01 v2(159.55,26.01)
  BOTTOM w0.076: v2(159.55,26.01) 159.25,25.71 UH2.AU41
  BOTTOM w0.114: v2(230.21,17.6) 230.21,17.4 QV93.3 231.34,16.9 RV612.1
HDMI_HPLUG: length 128.4
  TOP w0.114: UM1.21 v2(271.71,36.93)
  IN2 w0.127: v2(237.4,30.64) 237.4,29.44 235.93,27.97 234.74,27.97 232.43,25.67 232.43,18.87 v2(231.14,17.58)
  IN4 w0.094: v2(237.4,30.64) 237.4,29.82 237.74,29.48 240.89,29.48 241.48,30.08 245.91,30.08 249.72,26.27 251.95,26.27 252.63,25.59 253.3,25.59 253.53,25.82 253.53,26.15 254.87,27.5 266.11,27.5 266.98,26.63 270.08,26.63 270.69,27.24 271.83,27.24 272.63,28.04 272.63,36.05 271.74,36.93 v2(271.71,36.93) 272.25,37.47 272.25,42.41 273.09,43.25 273.8,43.25 274.53,42.51 274.53,41.85 276.84,39.54 279.71,39.54 282.94,42.76 287.69,42.76 290.87,45.94 291.93,45.94 293.08,47.08 293.08,57.67 v2(296.17,60.77)
  BOTTOM w0.114: v2(231.14,17.58) 231.37,17.81 231.37,18.57 231.84,19.04 CV923.1 231.75,19.22 RV611.2 ; JHDMI1.19 301.19,69.17 298.92,66.89 298.92,63.29 v4(298.17,62.54) 297.44,61.81 CV599.2 296.37,60.97 v2(296.17,60.77)
HDMI_RESERVED: length 4.3
  BOTTOM w0.114: CV600.2 v4(297.72,71.62) 300.61,71.62 JHDMI1.14
HOST_DEBUG_TX: length 81.9
  TOP w0.114: RN5.1 195.15,28.68 RN3.1 195.87,27.98 196.11,27.98 196.28,27.82 v4(196.28,26.66) 196.28,25.11 197.85,23.54 v2(197.85,23.08) ; v2(237.8,24.68) 237.8,24.53 237.42,24.14 UE1.81
  IN1 w0.094: v2(237.8,24.68) 238.05,24.93 238.05,25.43 237.82,25.67 236.05,25.67 235.11,24.73 234.05,24.73 231.72,22.4 227.48,22.4 226.72,23.16 223.68,23.16 222.89,23.95 216.63,23.95 216.38,24.21 216,24.59 212.69,24.59 212.03,23.93 210.38,23.93 209.99,24.32 199.09,24.32 v2(197.85,23.08)
  IN3 w0.127: v2(237.8,24.68) 239.43,26.3 240.34,26.3 241.87,27.83 243.47,27.83 245.42,29.78 255.84,29.78 v2(256.09,30.04)
  BOTTOM w0.114: JDEG1.8 252.72,33.98 253.14,33.56 254.68,33.56 RE64.2 256.09,32.32 256.45,31.97 256.45,30.39 v2(256.09,30.04)
HPD_IFPA: length 6
  BOTTOM w0.114: RV575.1 170.82,74.66 171.06,74.66 171.56,75.16 171.56,75.4 171.85,75.7 171.85,76.66 171.77,76.75 171.77,77.87 172.14,78.25 UV1.N4
HPD_IFPB: length 5
  BOTTOM w0.114: RV576.1 169.41,74.14 169.97,74.14 170.7,74.88 170.97,74.88 171.33,75.24 171.33,75.48 171.64,75.79 171.64,76.56 UV1.P2
HPD_IFPC: length 12.9
  TOP w0.114: v2(170.08,78.07) 169.94,77.93 169.94,76.72 RV580.1 170.27,76.39 170.27,75.64 v3(170.23,75.61) 170.1,75.48 170.1,73.66 169.99,73.55 169.76,73.55 169.38,73.17 169.38,71.43 170.68,70.13 172.31,70.13 QV89.1
  BOTTOM w0.114: UV1.U3 169.03,77.71 169.41,78.09 170.06,78.09 v2(170.08,78.07)
HPD_IFPD: length 1.7
  TOP w0.114: RV577.1 v2(172.63,79.77) v3(173.02,80.17)
  BOTTOM w0.102: UV1.M6 172.99,80.13 172.86,80
  BOTTOM w0.114: 172.86,80 v2(172.63,79.77)
HPD_IFPE: length 4.8
  BOTTOM w0.114: UV1.R1 170.27,75.89 170.27,75.08 169.76,74.57 168.01,74.57 RV578.1
HPD_IFPF: length 4.2
  BOTTOM w0.114: UV1.L2 173.79,76.64 173.36,76.21 173.36,75.22 173.01,74.87 173.01,74.68 171.91,73.57 RV579.1
I2C0_SCK: length 7.5
  TOP w0.114: RH14.2 155.27,26.02 156.95,26.02 157.31,26.38 158.53,26.38 158.94,26.79 160.41,26.79 v3(160.56,26.63) 160.83,26.37 v2(160.83,26.22)
  BOTTOM w0.089: v2(160.83,26.22) 160.6,26.44 UH2.AR38
I2C0_SDA: length 5.7
  TOP w0.114: RH15.2 155.2,25.06 155.2,25.47 155.43,25.7 v3(156,25.7) 157.03,25.7 157.49,26.15 158.89,26.15 v2(159.01,26.28)
  BOTTOM w0.102: v2(159.01,26.28) 158.76,26.28 158.58,26.46 UH2.AT42
I2C1_SCK_TP: length 25.1
  TOP w0.114: v2(159.6,27.3) 159.39,27.09 158.79,27.09 158.33,26.63 157.49,26.63 157.16,26.96 156.65,26.96 156.3,26.61 155.35,26.61 155.3,26.66 RH119.2 154.11,26 152.89,26 152.02,26.87 148.77,26.87 147.43,25.53 v3(147.43,24.83) 147.43,19.23 148.84,17.82 v2(149.58,17.82)
  BOTTOM w0.089: UH2.AR41 159.34,26.73 159.6,27 v2(159.6,27.3)
  BOTTOM w0.114: v2(149.58,17.82) 149.75,17.65 QE19.4
I2C1_SCK_TP_C: length 32.2
  BOTTOM w0.114: RE9.1 CT79.1 149.87,18.74 QE19.3 148.49,17.65 148.24,17.4 148.24,15.63 v2(148.18,15.57) 148.04,15.43 148.04,12.32 147.16,11.45 145.54,11.45 145.33,11.23 DE4.3 145.33,9.44 146.21,8.55 146.21,8.05 146.01,7.85 138.89,7.85 134.38,12.37 134.38,14.32 134.76,14.7 JTP.6
I2C1_SDA_TP: length 23.9
  TOP w0.114: v2(149.64,16.58) 147.08,19.14 147.08,25.48 148.68,27.09 v3(152.31,27.09) 152.43,27.09 152.54,27.19 v2(155.66,27.19)
  BOTTOM w0.076: 155.79,26.99 155.97,26.81 156.91,26.81 156.94,26.79 157.39,26.79 157.63,27.03 UH2.AR44
  BOTTOM w0.114: RH120.2 154.9,26.23 155.36,26.69 155.36,26.89 v2(155.66,27.19) 155.66,27.12 155.79,26.99 ; v2(149.64,16.58) 149.41,16.35 QE19.1
I2C1_SDA_TP_C: length 29
  BOTTOM w0.114: JTP.7 133.76,14.7 134.13,14.33 134.13,12.28 138.8,7.62 146.1,7.62 146.45,7.98 146.45,8.55 147.23,9.32 DE4.1 147.23,11.18 148.53,12.48 v2(148.53,13.44) 148.53,14.46 149.15,15.08 RE7.1 CE80.1 150.73,16.29 QE19.6
I2CB_SCL: length 1.7
  TOP w0.114: v2(170.06,80.56) 170.75,81.24 RV512.1
  BOTTOM w0.114: v2(170.06,80.56) 170.06,80.58 UV1.R7
I2CB_SDA: length 3.2
  TOP w0.114: v2(170.09,79.75) 170.09,79.44 170.48,79.05 170.48,78.71 v3(170.48,78.46) 170.48,77.86 RV513.1
  BOTTOM w0.114: UV1.R6 170.48,80.16 170.09,79.76 v2(170.09,79.75)
I_ADP: length 297.5
  TOP w0.114: v2(28.78,42.85) 28.86,42.77 31.82,42.77 32.64,41.95 v4(34.95,41.95) 35.24,41.95 35.9,42.61 v2(35.9,42.9)
  IN1 w0.094: v2(221.15,15.99) 220.47,16.68 217.53,16.68 215.28,14.43 201.23,14.43 198.89,12.09 196.91,12.09 195.55,10.73 185.62,10.73 182.7,7.81 171.1,7.81 166.86,12.05 161.59,12.05 159.95,10.4 159.83,10.29 156.09,10.29 118.34,10.29 114.11,14.53 103.83,14.53 102.84,13.54 99.08,13.54 98.88,13.74 87.91,13.74 81.69,7.52 27.41,7.52 24.55,10.38 24.55,11.69 20.37,15.87 16.73,15.87 11,21.59 11,34.66 17.68,41.33 34.33,41.33 v2(35.9,42.9)
  BOTTOM w0.114: v2(35.9,42.9) 35.63,42.9 35.06,42.33 PR200.1 ; v2(221.15,15.99) 221.88,16.72 221.88,19.03 222.23,19.38 222.91,19.38 223.56,20.03 224.83,20.03 225.9,21.11 226.41,21.11 227.77,22.47 228.75,22.47 231.28,25 231.78,25 232.61,25.82 RE36.2 ; PR319.1 28.45,42.85 v2(28.78,42.85)
I_ADP_R: length 7.2
  TOP w0.114: v2(231.1,28.16) 231.1,28.23 229.53,29.8 229.38,29.8 228.97,30.21 228.97,30.47 229.05,30.55 UE1.110
  BOTTOM w0.114: v3(231.54,28.6) v2(231.1,28.16) 231.1,27.79 231.39,27.5 CE87.1 RE36.1
ICSP_CLK: length 21.2
  TOP w0.114: UE1.101 232.65,30.4 v2(232.62,30.37)
  IN3 w0.127: v2(232.62,30.37) 232.62,30.39 233.54,31.31 243.61,31.31 245.21,32.91 248.2,32.91 v2(248.52,33.24)
  BOTTOM w0.114: v2(248.52,33.24) 249.41,32.35 249.41,31.79 249.79,31.41 RE109.2
ICSP_CLR: length 26.8
  TOP w0.114: v2(233.79,30.37) 233.79,30.28 234.39,29.69 234.39,28.84 234.73,28.49 234.73,26.81 235,26.54 UE1.87
  IN3 w0.127: v2(233.79,30.37) 233.77,30.39 233.77,30.6 234.22,31.05 243.82,31.05 245.42,32.65 248.6,32.65 248.94,33 248.94,33.38 249.13,33.57 249.87,33.57 v2(250.36,33.09)
  BOTTOM w0.114: v3(250.87,30.51) 251.09,30.72 RE110.2 250.89,31.41 250.58,31.71 250.58,32.86 v2(250.36,33.09)
ICSP_DAT: length 27.3
  TOP w0.114: v2(231.99,30.37) 232.01,30.37 232.25,30.61 UE1.102
  IN3 w0.127: v2(251.72,33.14) 250.48,34.38 246.32,34.38 243.48,31.54 233.11,31.54 231.99,30.42 v2(231.99,30.37)
  BOTTOM w0.114: v3(253.48,30.51) 253.12,30.86 RE112.2 252.74,31.41 252.61,31.54 252.61,32.63 252.48,32.76 252.16,32.76 251.78,33.14 v2(251.72,33.14)
IFP_IOVDDA: length 31.9
  TOP w0.508: RV199.1 CV912.1 144.35,65.64 CV911.1 v4(144.33,71.77) 145.28,72.72 v2(145.61,72.72)
  IN2 w0.508: v2(145.61,72.72) 146.59,73.7 146.59,74.64 148.51,76.56 148.51,77.19 148.89,77.57 149.91,77.57 151.22,76.27 153.08,76.27 154.37,77.56 154.68,77.56 157.26,80.14 157.96,80.14 159.33,81.51 159.33,81.61 v2(160,82.29)
  BOTTOM w0.305: UV1.AG9 160,82.32 v2(160,82.29) 160,82.19 UV1.AG8
IFP_IOVDDB: length 45.9
  TOP w0.508: CV915.1 144.35,59.67 ; 144.35,59.67 CV916.1 RV200.1 ; 144.35,59.67 144.78,59.67 145.04,59.93 v4(145.04,66.88) 145.04,70.37 v2(145.53,70.86)
  IN2 w0.508: v2(145.53,70.86) 145.62,70.95 146.51,70.95 147.83,72.27 147.83,74.88 148.98,76.04 150.35,76.04 150.73,75.66 155.76,75.66 157.19,74.23 160.32,74.23 163.54,77.45 v2(163.54,83.14)
  BOTTOM w0.305: v2(163.54,83.14) 163.54,82.41 163.79,82.16 UV1.AC8 UV1.AC7
IFPC_CLK_CN: length 3.7
  TOP w0.089: CV825.2 262.14,32.92 262.6,32.92 262.76,32.76 v1(263.05,32.76) 263.33,32.76 263.61,33.04 263.61,33.67 263.75,33.81 263.9,33.81 263.98,33.73 UM1.48
IFPC_CLK_CP: length 3.7
  TOP w0.089: CV826.2 262.16,33.16 262.7,33.16 262.86,33 263.23,33 263.37,33.14 263.37,33.77 263.65,34.05 263.94,34.05 264.02,34.13 UM1.47
IFPC_CLK_N: length 130.9
  TOP w0.089: v2(251.8,39.77) 252.06,39.51 252.06,38.91 257.11,33.86 259.07,33.86 260.09,32.83 260.68,32.83 CV825.1
  IN1 w0.089: v2(160.89,78.12) 161.12,78.35 165.14,78.35 168.79,74.69 168.79,73.72 171.97,70.54 171.97,66.88 184.43,54.42 192.56,54.42 201.24,45.73 204.6,45.73 205.92,44.41 207.82,42.51 207.83,42.51 207.83,42.39 207.54,42.11 207.54,41.7 207.99,41.26 208.39,41.26 208.67,41.54 208.8,41.54 209.74,40.59 217.92,40.59 218.38,41.05 222.87,41.05 223.15,41.34 223.15,41.62 223.24,41.7 223.6,41.7 223.69,41.62 223.69,41.34 223.97,41.05 224.6,41.05 224.89,41.34 224.89,41.62 224.98,41.7 225.33,41.7 225.42,41.62 225.42,41.34 225.7,41.05 226.48,41.05 226.77,41.34 226.77,41.55 226.85,41.64 227.21,41.64 227.3,41.55 227.3,41.34 227.58,41.05 228.78,41.05 229.13,40.7 249.05,40.7 249.27,40.48 249.27,39.43 249.59,39.1 250.14,39.1 250.47,39.43 250.47,40.59 250.64,40.77 252.07,40.77 252.27,40.57 252.27,39.8 252.08,39.61 251.9,39.61 251.8,39.72 v2(251.8,39.77)
  BOTTOM w0.089: v2(160.89,78.12) 160.88,78.12 UV1.AG4
IFPC_CLK_P: length 130.9
  TOP w0.089: CV826.1 260.91,33.21 260.78,33.07 260.19,33.07 259.17,34.1 257.21,34.1 252.3,39.01 252.3,39.53 252.54,39.77 v2(252.7,39.77)
  IN1 w0.089: v2(160.89,78.91) 161.12,78.68 165.27,78.68 169.13,74.83 169.13,73.86 172.3,70.68 172.3,67.02 184.57,54.75 192.69,54.75 201.38,46.07 204.74,46.07 208.16,42.65 208.16,42.25 207.88,41.97 207.88,41.84 208.13,41.59 208.25,41.59 208.54,41.87 208.94,41.87 209.88,40.93 217.78,40.93 218.24,41.38 222.73,41.38 222.82,41.47 222.82,41.75 223.11,42.04 223.74,42.04 224.02,41.75 224.02,41.47 224.11,41.38 224.47,41.38 224.55,41.47 224.55,41.75 224.84,42.04 225.47,42.04 225.75,41.75 225.75,41.47 225.84,41.38 226.34,41.38 226.43,41.47 226.43,41.69 226.72,41.98 227.35,41.98 227.63,41.69 227.63,41.47 227.72,41.38 228.91,41.38 229.27,41.03 249.19,41.03 249.6,40.62 249.6,39.56 249.73,39.44 250.01,39.44 250.13,39.56 250.13,40.73 250.51,41.1 252.2,41.1 252.6,40.7 252.6,39.87 v2(252.7,39.77)
  BOTTOM w0.089: UV1.AG5 160.49,79.31 v2(160.89,78.91)
IFPC_I2C_CLK: length 150.9
  TOP w0.114: RM3.2 265.55,42.54 265.55,42.69 265.32,42.92 v2(265.31,42.92) ; QV90.1 190.07,61.47 RV589.2 189.65,61.06 189.65,60.95 189.41,60.7 189.41,59.72 189.01,59.32 189.01,54.75 186.23,51.97 182.81,51.97 v2(182.22,52.57)
  IN1 w0.094: v2(265.31,42.92) 265.53,42.7 265.53,42.29 258.72,35.49 256.27,35.49 255.65,36.11 248.43,36.11 246.66,37.87 227.41,37.87 226.09,39.19 219.33,39.19 218.84,38.7 207.92,38.7 203.89,42.73 200.51,42.73 191.3,51.94 182.56,51.94 182.14,52.36 182.14,52.49 v2(182.22,52.57) 182.19,52.57 181.89,52.87 181.89,53.12 181.25,53.76 178.96,53.76 175.89,56.84 175.89,58.42 170.12,64.18 170.12,69.66 166.91,72.87 166.91,73.49 165.43,74.96 164.34,74.96 163.78,75.52 163.16,75.52 v2(162.72,75.08)
  BOTTOM w0.114: v2(162.72,75.08) 162.75,75.12 162.75,75.3 162.58,75.47 160.56,75.47 160.11,75.92 160.11,77.33 UV1.AG3
IFPC_I2C_CLK_R: length 6.7
  TOP w0.114: RM583.1 264.55,42.82 264.55,41.65 RM3.1 264.39,40.46 v3(264.39,40.19) 264.63,39.94 265.53,39.94 266.11,39.36 UM1.34
IFPC_I2C_DAT: length 151.5
  TOP w0.114: v2(265.95,42.92) 265.79,42.76 265.79,42.21 RM2.2 ; QV90.4 193.37,60.17 193.43,60.24 RV588.2 193.94,59.45 193.68,59.2 193.25,59.2 191.98,57.93 191.98,56.62 191.03,55.67 190.44,55.67 186.43,51.67 182.52,51.67 v2(181.62,52.57)
  IN1 w0.094: v2(163.33,75.09) 163.54,75.3 163.69,75.3 164.25,74.74 165.34,74.74 166.69,73.4 166.69,72.78 169.9,69.57 169.9,64.09 175.66,58.32 175.66,56.75 178.87,53.54 181.16,53.54 181.67,53.03 181.67,52.62 v2(181.62,52.57) 182.47,51.72 191.21,51.72 200.42,42.51 203.8,42.51 207.83,38.48 218.93,38.48 219.42,38.97 226,38.97 227.32,37.65 246.57,37.65 248.34,35.89 255.56,35.89 256.18,35.27 258.82,35.27 265.75,42.2 265.75,42.72 v2(265.95,42.92)
  BOTTOM w0.114: UV1.AG2 160.49,76.64 160.89,76.23 160.89,75.97 161.16,75.71 162.68,75.71 163.3,75.09 v2(163.33,75.09)
IFPC_I2C_DAT_R: length 5.4
  TOP w0.114: UM1.33 266.51,39.44 v3(265.73,40.22) 265.67,40.28 265.67,40.86 RM2.1 266.46,41.65 266.46,43.36 RM582.1
IFPC_TX0_CN: length 3.7
  TOP w0.089: UM1.45 263.86,34.93 263.78,35.01 263.41,35.01 263.28,34.89 v1(263.28,34.66) 263.28,34.45 263,34.17 262.57,34.17 262.29,34.45 262.29,34.61 262.23,34.67 262.15,34.67 CV831.2
IFPC_TX0_CP: length 3.7
  TOP w0.089: UM1.44 263.86,35.33 263.78,35.25 263.31,35.25 263.04,34.99 263.04,34.55 262.9,34.41 262.67,34.41 262.53,34.55 262.53,34.71 262.33,34.92 262.2,34.92 CV832.2
IFPC_TX0_N: length 130.9
  TOP w0.089: v2(255.11,41.72) 255.31,41.53 255.31,37.01 257.61,34.72 260.59,34.72 CV831.1
  IN1 w0.089: v2(160.06,78.93) 160.06,79.07 160.63,79.64 161.35,79.64 161.57,79.42 165.56,79.42 165.79,79.19 166.72,79.19 167.83,78.08 169.47,78.08 170.29,77.26 170.29,73.72 173.03,70.98 173.03,67.32 184.66,55.69 192.82,55.69 201.69,46.83 205.14,46.83 210.31,41.65 217.46,41.65 218.57,42.76 228.31,42.76 228.79,43.24 234.47,43.24 235.78,41.93 252.62,41.93 253.25,41.3 255.45,41.3 255.7,41.55 255.7,41.88 255.52,42.05 255.27,42.05 255.11,41.9 v2(255.11,41.72)
  BOTTOM w0.089: v2(160.06,78.93) 159.64,78.52 UV1.AH4
IFPC_TX0_P: length 130.8
  TOP w0.089: CV832.1 260.63,34.96 257.71,34.96 255.55,37.11 255.55,41.55 255.72,41.72 v2(256.15,41.72)
  IN1 w0.089: v2(160.06,78.07) 160.06,78.32 160.49,78.76 160.49,79.03 160.76,79.31 161.21,79.31 161.43,79.09 165.43,79.09 165.66,78.86 166.58,78.86 167.7,77.74 169.34,77.74 169.95,77.13 169.95,73.59 172.7,70.84 172.7,67.19 184.52,55.36 192.68,55.36 201.55,46.49 205,46.49 210.18,41.32 217.6,41.32 218.71,42.43 228.45,42.43 228.93,42.91 234.33,42.91 235.65,41.6 252.48,41.6 253.11,40.97 255.58,40.97 256.03,41.42 256.03,41.6 v2(256.15,41.72)
  BOTTOM w0.089: UV1.AH3 160,78.07 v2(160.06,78.07)
IFPC_TX1_CN: length 3.6
  TOP w0.089: UM1.42 264,36.13 263.92,36.21 263.76,36.21 263.44,36.53 263.36,36.53 263.26,36.43 263.26,36.13 263.03,35.91 v1(262.81,35.91) 262.6,35.91 262.33,36.17 262.33,36.35 262.24,36.44 262.14,36.44 CV830.2
IFPC_TX1_CP: length 3.7
  TOP w0.089: UM1.41 264.02,36.53 263.94,36.45 263.86,36.45 263.54,36.77 263.26,36.77 263.01,36.53 263.01,36.23 262.93,36.15 262.7,36.15 262.57,36.27 262.57,36.45 262.34,36.68 262.21,36.68 CV829.2
IFPC_TX1_N: length 130.8
  TOP w0.089: CV830.1 260.61,36.48 260.54,36.48 260.44,36.38 260.44,35.92 260.16,35.64 259.59,35.64 259.29,35.94 259.29,36.83 259.19,36.92 258.96,36.92 v2(258.8,36.77)
  IN1 w0.089: v2(258.8,36.77) 258.68,36.89 258.23,36.89 257.95,37.18 257.95,38.39 257.72,38.62 256.48,38.62 256.35,38.5 256.35,37.99 256.03,37.67 255.48,37.67 255.16,37.99 255.16,38.37 255.03,38.5 254.75,38.5 254.62,38.37 254.62,37.94 254.34,37.66 253.71,37.66 253.42,37.94 253.42,38.39 253.3,38.52 253.02,38.52 252.89,38.39 252.89,37.94 252.61,37.66 251.97,37.66 251.69,37.94 251.69,38.55 251.56,38.67 251.28,38.67 251.16,38.55 251.16,37.94 250.87,37.66 250.24,37.66 249.96,37.94 249.96,38.12 249.87,38.21 249.22,38.21 247.51,39.92 227.22,39.92 226.83,40.32 218.73,40.32 218.28,39.87 208.35,39.87 203.71,44.51 201.31,44.51 192.21,53.61 184.19,53.61 171.24,66.55 171.24,70.22 168.07,73.4 168.07,73.93 165.08,76.92 161.65,76.92 161.2,76.47 160.17,76.47 159.71,76.92 159.09,76.92 158.96,76.8 158.66,76.8 v2(158.39,76.53)
  BOTTOM w0.089: v2(158.39,76.53) 158.42,76.53 UV1.AJ2
IFPC_TX1_P: length 130.9
  TOP w0.089: CV829.1 260.61,36.72 260.44,36.72 260.19,36.48 260.19,36.02 260.06,35.88 259.69,35.88 259.53,36.04 259.53,36.93 259.29,37.16 259.02,37.16 v2(258.8,37.38)
  IN1 w0.089: v2(158.4,77.29) 158.55,77.13 158.82,77.13 158.95,77.26 159.85,77.26 160.31,76.8 161.06,76.8 161.52,77.26 165.21,77.26 168.4,74.07 168.4,73.54 171.58,70.36 171.58,66.69 184.33,53.94 192.35,53.94 201.45,44.85 203.84,44.85 208.49,40.2 218.14,40.2 218.59,40.65 226.97,40.65 227.36,40.25 247.65,40.25 249.36,38.54 250.01,38.54 250.29,38.26 250.29,38.08 250.38,37.99 250.74,37.99 250.82,38.08 250.82,38.69 251.15,39.01 251.7,39.01 252.02,38.69 252.02,38.08 252.11,37.99 252.47,37.99 252.56,38.08 252.56,38.53 252.88,38.85 253.43,38.85 253.76,38.53 253.76,38.08 253.84,37.99 254.2,37.99 254.29,38.08 254.29,38.51 254.61,38.83 255.17,38.83 255.49,38.51 255.49,38.13 255.61,38 255.89,38 256.02,38.13 256.02,38.63 256.34,38.96 257.86,38.96 258.28,38.53 258.28,37.32 258.37,37.23 258.65,37.23 v2(258.8,37.38)
  BOTTOM w0.089: UV1.AJ3 158.79,77.68 v2(158.4,77.29)
