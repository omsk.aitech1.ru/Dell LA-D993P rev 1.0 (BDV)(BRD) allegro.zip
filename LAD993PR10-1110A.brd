# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
IFPC_TX2_CN: length 3.7
  TOP w0.089: CV828.2 262.15,39.25 262.24,39.25 262.84,38.65 262.84,38.37 v1(263.37,37.84) 263.8,37.41 263.97,37.41 264.05,37.33 UM1.39
IFPC_TX2_CP: length 3.7
  TOP w0.089: UM1.38 264.04,37.73 263.96,37.65 263.9,37.65 263.08,38.47 263.08,38.75 v1(262.8,39.02) 262.34,39.49 262.2,39.49 CV827.2
IFPC_TX2_N: length 131
  TOP w0.089: CV828.1 260.64,39.25 259.08,39.25 258.19,38.36 258.19,37.01 257.72,36.54 257.15,36.54 257.05,36.44 v2(257.05,36.19)
  IN1 w0.089: v2(257.05,36.19) 257.07,36.21 257.07,36.59 256.97,36.69 249.68,36.69 247.21,39.16 234.88,39.16 234.52,38.8 233.93,38.8 233.57,39.16 233.1,39.16 233.01,39.07 233.01,38.71 232.69,38.39 232.13,38.39 231.81,38.71 231.81,39.07 231.72,39.16 231.37,39.16 231.28,39.07 231.28,38.68 231,38.39 230.36,38.39 230.08,38.68 230.08,39.07 229.99,39.16 226.93,39.16 226.51,39.59 219.09,39.59 218.64,39.14 208.05,39.14 203.44,43.75 201.04,43.75 198.27,46.52 197.32,46.52 190.97,52.87 183.22,52.87 181.41,54.68 180.2,54.68 170.52,64.36 170.52,69.83 167.33,73.02 167.33,73.65 164.86,76.11 161.93,76.11 161.53,75.71 158.28,75.71 158.08,75.51 158.08,75.1 v2(158.33,74.84)
  BOTTOM w0.089: UV1.AJ1 158.54,75.86 158.54,75.58 158.14,75.18 158.14,75.03 v2(158.33,74.84)
IFPC_TX2_P: length 131.1
  TOP w0.089: CV827.1 260.59,39.49 258.98,39.49 257.95,38.46 257.95,37.11 257.62,36.78 257.21,36.78 257.05,36.95 v2(257.05,37.18)
  IN1 w0.089: v2(257.05,37.18) 256.9,37.03 249.82,37.03 247.35,39.5 234.74,39.5 234.38,39.13 234.07,39.13 233.71,39.5 232.96,39.5 232.68,39.21 232.68,38.85 232.55,38.73 232.27,38.73 232.15,38.85 232.15,39.21 231.86,39.5 231.23,39.5 230.95,39.21 230.95,38.81 230.86,38.73 230.5,38.73 230.41,38.81 230.41,39.21 230.13,39.5 227.07,39.5 226.65,39.92 218.95,39.92 218.5,39.47 208.19,39.47 203.58,44.08 201.18,44.08 198.41,46.86 197.45,46.86 191.11,53.2 183.36,53.2 181.55,55.01 180.34,55.01 170.85,64.5 170.85,69.97 167.66,73.16 167.66,73.78 165,76.45 161.8,76.45 161.39,76.04 158.14,76.04 157.74,75.64 v2(157.74,74.87)
  BOTTOM w0.089: v2(157.74,74.87) 157.9,75.02 157.9,75.28 158.3,75.68 158.3,75.8 UV1.AK1
ILIM_HI1: length 1.9
  TOP w0.114: RI45.1 284.3,36.17 US1.16
ILIM_LO1: length 1.7
  TOP w0.114: US1.15 284.69,35.67 RI49.1
ILIM_SEL_R: length 3.1
  TOP w0.114: US1.4 281.2,37.29 281.04,37.46 280.73,37.46 280.18,38 v3(279.91,38) 279.09,38 RI30.2
ILMT_1VALWP: length 4.9
  BOTTOM w0.114: PR606.2 251.13,11.79 v3(251.13,10.35)
  BOTTOM w0.254: PU600.13 250.45,12.46 PR607.1 PR606.2
ILMT_+0.95VSP: length 3.3
  TOP w0.254: PU700.13 67.5,65.52 66.88,64.9 v2(66.52,64.9) 66.38,64.76 PR709.1 PR707.2
ILMT_+1.0VSP: length 4.1
  BOTTOM w0.114: v3(225.13,41.05) 225.13,40.67 224.79,40.33 PR809.2
  BOTTOM w0.254: PU800.13 223.16,40.54 PR810.1 PR809.2
ILMT_+1.8VSP: length 4.9
  BOTTOM w0.114: v3(209.13,113.36) 208.59,113.9 208.59,114.83 PR1009.2
  BOTTOM w0.203: PU1000.13 207.02,115.98 207.23,115.77 PR1010.1
  BOTTOM w0.254: PR1009.2 208.12,115.29 PR1010.1
ILMT_DDR: length 4.7
  BOTTOM w0.254: PU500.17 100.25,9.65 v3(99.82,9.22) 99.63,9.03 98.03,9.03 97.77,8.78 PR504.2 PR506.1
IMVP_VR_ON: length 63
  TOP w0.114: v2(233.78,21.17) 233.89,21.28 234.67,21.28 235.01,20.94 UE1.73 ; v2(187.92,17.16) 188.2,17.44 v4(188.2,18.85) 189.28,19.94 189.28,21.26 189.39,21.36 RH499.2 188.33,22.9 187.82,23.41 UZ21.1
  IN4 w0.094: v2(187.92,17.16) 188.52,16.56 194.5,16.56 200.09,22.14 213.42,22.14 214.54,21.02 219.33,21.02 219.87,20.47 220.84,20.47 221.29,20.02 225.01,20.02 225.4,19.63 227.67,19.63 229.24,21.19 233.76,21.19 v2(233.78,21.17)
  BOTTOM w0.114: v2(233.78,21.17) 233.47,21.48 CE82.1 RE23.1
IMVP_VR_PG: length 203.7
  TOP w0.114: v2(67.09,82.41) 67.09,82.77 67.42,83.1 PR1117.1 ; UH14.1 190.07,27.47 189.79,27.75 188.67,27.75 RH102.1 187.78,27.84 188.45,28.51 v4(188.45,31.21) 188.45,32.51 192.96,37.02 v2(193.22,37.02)
  IN3 w0.127: v2(67.09,82.41) 69.18,84.5 71.29,84.5 77.05,90.25 77.05,92.47 79.94,95.37 79.94,97.68 89.99,107.73 132.63,107.73 133.11,107.25 136.74,107.25 137.5,108.02 142.15,108.02 143.24,106.92 143.24,102.29 141.82,100.87 v2(141.82,99.58)
  IN4 w0.094: v2(141.82,99.58) 142.11,99.58 154.31,87.37 154.31,83.24 155.94,81.62 155.94,80.79 159.83,76.9 165.16,76.9 166.19,75.88 167.57,75.88 169.06,74.38 169.9,74.38 173.62,70.66 173.62,67.12 173.62,66.19 177.53,62.28 177.53,62.28 192.45,47.35 192.45,47.33 192.45,37.94 192.4,37.89 192.4,37.3 192.68,37.02 v2(193.22,37.02)
INTRUDER#: length 3.9
  TOP w0.114: RH143.1 175.65,20.39 175.04,20.39 v3(174.69,20.74) 174.02,21.41 v2(173.67,21.41)
  BOTTOM w0.076: UH2.BE11 173.67,21.89 v2(173.67,21.41)
INV_PWM: length 5.8
  TOP w0.114: v2(61.73,31.23) 61.99,30.98 RV537.1 62.87,30.98 63.38,30.47 v3(64.91,30.47) 65.4,30.97 DV2.1
  BOTTOM w0.114: v2(61.73,31.23) 62.01,31.51 JEDP1.16
IR_CAM_DET#: length 108.4
  TOP w0.114: v2(184.85,33.19) v3(184.85,32.67)
  IN3 w0.127: v2(232.41,41.86) 232.41,41.48 230.25,39.32 220.6,39.32 219.92,38.64 217.74,38.64 213.93,34.83 210.7,34.83 210.39,35.13 208.6,35.13 207.01,36.72 194.73,36.72 192.19,39.26 187.29,39.26 186.92,38.89 186.92,38.23 187.18,37.97 187.18,37.45 187.18,34.41 185.6,32.82 185.04,32.82 184.85,33.01 v2(184.85,33.19)
  IN4 w0.094: v2(184.85,33.19) 184.52,32.86 180.35,32.86 179.68,32.19 179.12,32.19 179.03,32.11 176.2,32.11 176.1,32.01 175.04,32.01 175.01,32.04 171.76,32.04 171.47,31.75 163.88,31.75 163.49,32.14 157.33,32.14 157.14,31.95 155.34,31.95 154.11,30.72 152.93,30.72 152.24,30.03 v2(149.84,30.03)
  BOTTOM w0.114: UH2.AL44 157.36,28.64 157.21,28.79 154.85,28.79 154.43,29.21 152.21,29.21 151.75,29.67 150.2,29.67 v2(149.84,30.03) ; RZ96.1 233.02,45.6 JCAM1.9 233.02,42.08 232.8,41.86 v2(232.41,41.86)
IRQ_SERIRQ: length 71.6
  TOP w0.114: UE1.55 230.65,16.94 230.39,17.2 230.02,17.2 229.53,17.69 229.06,17.69 228.29,18.46 228.29,21.43 227.65,22.07 227.65,23.76 v2(227.9,24.01) ; v3(181.37,22.74) 181.37,23.61 v2(181.42,23.66) 181.09,23.99 RH111.1
  IN1 w0.094: v2(181.42,23.66) 183.52,23.66 183.87,24.01 189.22,24.01 189.63,24.42 197.81,24.42 198.29,24.9 210.23,24.9 210.67,25.34 216.24,25.34 217.1,24.48 223.12,24.48 223.91,23.68 227.58,23.68 v2(227.9,24.01)
  IN3 w0.127: v2(181.42,23.66) 181.41,23.67 179.24,23.67 177.51,21.94 176.21,21.94 175.22,22.93 172.44,22.93 v2(171.46,23.91)
  BOTTOM w0.089: UH2.BA17 171.42,23.86 v2(171.46,23.91)
ISEN1_GT: length 18.9
  TOP w0.254: v2(64.32,100.42) v4(63.59,101.16) 63.59,103.47 64.5,104.38 PR1526.2
  IN4 w0.254: v2(64.32,100.42) 64.32,94.25 67.24,91.33 v2(67.24,91.1)
  BOTTOM w0.203: v2(67.24,91.1) 67.51,91.1 68.04,90.57 PU1100.9
  BOTTOM w0.254: PC1129.2 66.99,91.43 67.24,91.18 v2(67.24,91.1) ; v2(64.32,100.42) 63.94,100.8 PR1510.2
ISEN1_VCORE: length 22.9
  TOP w0.254: v2(71.64,101.21) 72.27,101.21 v4(72.55,100.94) 72.78,100.7 72.78,94.22 v2(72.65,94.1)
  IN1 w0.254: v2(77.1,100.45) 76.84,100.19 75.88,100.19 75.55,100.52 72.32,100.52 v2(71.64,101.21)
  BOTTOM w0.203: PU1100.21 72.74,94.01 v2(72.65,94.1)
  BOTTOM w0.254: PR1409.2 77.86,101.21 v2(77.1,100.45) ; v2(71.64,101.21) 72.32,101.21 PR1426.2 71.89,100.52 71.89,99.69 71.64,99.43 70.29,99.43 70.04,99.69 PR1440.2 ; PC1128.1 73.03,94.35 72.78,94.1 v2(72.65,94.1)
ISEN2_GT: length 19.6
  TOP w0.254: v2(66.56,101.78) 66.18,101.78 v4(65.95,102) 65.39,102.57 65.39,102.93 PR1525.2
  BOTTOM w0.203: PC1126.2 66.63,92.29 67.05,91.88 67.18,91.88 68.09,90.97 PU1100.10
  BOTTOM w0.254: PR1522.2 67.52,102.75 v2(66.56,101.78) 65.29,100.51 65.29,93.97 66.63,92.62 PC1126.2
ISEN2_VCORE: length 21.7
  TOP w0.254: v2(73.54,94.1) 73.42,94.22 v4(73.42,98.33) 73.42,100.45 v2(74.05,101.08)
  IN1 w0.254: v2(76.34,100.7) 75.96,101.08 v2(74.05,101.08) 73.03,101.08 72.15,101.97 70.62,101.97 69.42,100.76 v2(69.42,100.51)
  BOTTOM w0.203: PU1100.22 73.14,93.51
  BOTTOM w0.254: 76.34,101.08 PR1412.2 ; 76.34,101.08 76.84,101.08 77.23,101.46 PR1423.2 ; 76.34,101.08 v2(76.34,100.7) ; 73.14,93.51 73.14,93.7 v2(73.54,94.1) 73.92,94.48 PC1127.1 ; PR1441.2 69.99,101.08 v2(69.42,100.51)
ISEN3_VCORE: length 17.3
  TOP w0.254: v2(74.05,104.26) 74.56,103.75 74.56,100.45 v2(74.05,99.94) v4(74.05,95.82) 74.05,94.33 v2(74.3,94.07)
  BOTTOM w0.203: PU1100.23 73.54,93.31 v2(74.3,94.07)
  BOTTOM w0.254: PR1427.2 72.45,99.69 72.7,99.43 73.72,99.43 74.05,99.76 v2(74.05,99.94) 74.18,100.07 PR1413.2 ; PR1437.2 73.92,104.38 v2(74.05,104.26) ; PC1125.1 74.81,94.58 v2(74.3,94.07)
ISOLATEB: length 7.4
  BOTTOM w0.114: UL1.20 286.21,42.16 286.9,41.47 286.9,39.54 286.59,39.22 v3(286.59,38.8) 286.59,38.57 287.02,38.14 RL33.2 RL30.1 RL1.2
ISUMN_GT: length 68.5
  TOP w0.254: v2(65.06,90.54) 65.68,90.54 PR1132.1 PR1136.1
  BOTTOM w0.254: PR1511.2 PR1523.2 63,104.38 ; PR1131.2 PC1124.1 ; PR1131.2 PC1129.1 ; PR1131.2 PC1117.2 v2(65.06,90.54) PC1118.2 ; PC1124.1 PC1126.1 ; PC1124.1 64.35,92.95 v4(63.26,94.04) 63,94.3 63,104.38 ; 63,104.38 63,123.14 64.32,124.45 81.4,124.45 83.75,122.1 87.2,122.1 87.77,121.53 PH1102.2
ISUMN_SA: length 80.5
  TOP w0.254: v2(129.04,116.83) 129.47,116.4 131.3,116.4 PR1529.2
  IN1 w0.254: v2(79.44,88.76) 79.44,88.74 79.69,88.48 79.69,88.19 80.11,87.77 80.89,87.77 81.29,88.17 81.29,89.15 81.06,89.38 81.06,91.71 82.18,92.83 82.18,95.88 89.7,103.39 104.43,103.39 106.08,105.04 109.87,105.04 110.2,105.37 120.89,105.37 121.93,106.42 125.01,106.42 128.41,109.81 128.41,116.55 128.69,116.83 v2(129.04,116.83)
  BOTTOM w0.254: v2(129.04,116.83) 129.93,116.83 130.36,117.26 PH1101.1 ; v2(79.44,88.76) PC1112.1 ; PC1112.1 PC1113.1 PR1126.1 PC1111.1 ; PC1112.1 78.48,88.13 PR1124.2 78.36,88 PR1121.2
ISUMN_VCORE: length 84.9
  IN1 w0.254: v2(119.64,112.26) 119.99,111.92 119.99,108.02 118.61,106.64 110.02,106.64 109.87,106.49 88.48,106.49 82.08,100.09 78.85,100.09 77.86,101.08 76.72,101.08 75.7,102.1 74.18,102.1 v2(74.05,101.97)
  BOTTOM w0.254: 72.48,103.56 74.42,103.56 74.74,103.24 PR1411.2 74.18,102.1 v2(74.05,101.97) ; 72.48,103.56 72.45,103.53 PR1425.2 ; 72.48,103.56 70.99,103.56 70.04,102.61 PR1439.2 68.91,100.97 68.91,99.37 69.35,98.92 v3(74.84,98.92) 75.19,98.92 75.57,98.54 ; v2(119.64,112.26) 119.77,112.39 PH1103.1 ; 75.57,98.54 75.57,96.69 ; 75.57,98.54 PC1130.1 ; 75.57,96.69 PR1138.1 PC1132.1 PC1131.1 PC1128.2 PC1127.2 PC1125.2 74.86,95.75 PR1137.2 ; 75.57,96.69 PR1139.2
ISUMP_GT: length 71.2
  IN4 w0.254: v2(67.27,90.39) 66.76,90.39 65.49,89.12 63.66,89.12 v2(63.03,89.75) 63.03,90.29 63.64,90.9 63.64,102.71 v2(64.09,103.16) 63.64,103.62 63.64,104.84 v2(64.14,105.35)
  BOTTOM w0.203: PU1100.7 68.09,89.77 68.06,89.73 67.62,89.73 67.27,90.08 v2(67.27,90.39) 67.19,90.39 67.04,90.54 PC1118.1
  BOTTOM w0.254: PR1131.1 PC1117.1 63.43,90.01 63.18,89.75 v2(63.03,89.75) ; v2(64.09,103.16) 63.95,103.03 PR1509.2 ; v2(64.14,105.35) 63.64,105.86 63.64,106.54 ; 63.64,106.54 PR1521.2 ; 63.64,106.54 63.51,106.67 63.51,122.93 64.53,123.94 80.76,123.94 v4(82.08,122.61) 83.35,121.35 PR1130.1
ISUMP_SA: length 82.4
  TOP w0.254: PR1528.2 v3(129.91,117.21) 129.47,117.21 129.22,117.47 v2(129.04,117.47)
  IN1 w0.254: v2(80.33,88.78) 80.26,88.78 80.08,88.6 80.08,88.34 80.26,88.15 80.65,88.15 80.91,88.41 80.91,88.99 80.68,89.22 80.68,91.87 81.8,92.99 81.8,96.03 89.54,103.77 104.27,103.77 105.92,105.43 109.71,105.43 110.04,105.76 120.73,105.76 121.77,106.8 124.85,106.8 128.03,109.97 128.03,116.93 128.56,117.47 v2(129.04,117.47)
  BOTTOM w0.203: PU1100.32 75.22,88.97 75.27,89.02 75.91,89.02
  BOTTOM w0.254: v2(129.04,117.47) 128.51,117.47 128.25,117.72 PR1125.2 ; 75.91,89.02 76.36,88.56 78.34,88.56 79,89.22 79.89,89.22 v2(80.33,88.78) 80.35,88.76 PC1112.2 PC1113.2 PR1126.2
ISUMP_VCORE: length 85.5
  TOP w0.254: v2(79.99,100.96) 78.88,102.07 78.88,103.88 76.58,106.18 v2(76.34,106.18) 74.07,106.18 70.75,102.86 v4(70.75,101.21) 70.75,99.81 72.27,98.29 v2(72.27,96.89)
  IN1 w0.254: v2(119.26,112.89) 119.26,112.77 119.14,112.64 119.14,112 119.52,111.62 119.52,108.09 118.45,107.03 109.86,107.03 109.71,106.87 88.33,106.87 82.28,100.83 80.12,100.83 v2(79.99,100.96)
  BOTTOM w0.203: PU1100.19 71.94,93.26 71.84,93.36 71.84,94.15 72.02,94.33
  BOTTOM w0.254: 72.02,94.33 72.5,94.81 72.5,96.66 v2(72.27,96.89) 72.27,97.35 72.53,97.6 PC1131.2 PC1132.2 PR1138.2 ; v2(76.34,106.18) 76.2,106.04 PR1438.2 ; PR1410.2 78.83,102.87 78.83,104.18 77.48,105.53 76.02,105.53 PR1438.2 ; PR1424.2 75.51,104.38 PR1438.2 ; PR1140.2 118.88,113.27 v2(119.26,112.89)
JACK_PLUG: length 19.7
  TOP w0.114: v2(294.7,13.07) 294.28,13.07 v3(294.13,12.92)
  IN1 w0.254: v2(294.7,13.07) 294.7,12.46 295.53,11.64 296.01,11.64 296.99,10.66 296.99,9.97 298.84,8.12 305.04,8.12 JHP1.6
  BOTTOM w0.254: RA56.1 291.6,15.31 292.67,14.24 DA5.2 293.53,14.24 v2(294.7,13.07)
JTAG_CLK: length 2.8
  BOTTOM w0.114: JDEG1.4 250.72,33.89 251.22,33.39 v3(251.22,33.32) 251.22,33.01 251.9,32.32 RE111.1
JTAG_TDI: length 2.2
  BOTTOM w0.114: RE109.1 249.87,32.53 v3(249.87,33.31) 249.72,33.46 JDEG1.2
JTAG_TDO: length 9.4
  BOTTOM w0.114: v3(245.98,36.26) 246.17,36.07 250.06,36.07 251.22,34.91 JDEG1.5 251.22,34.02 251.47,33.77 251.67,33.77 252.47,32.98 252.64,32.98 253.12,32.5 RE112.1
JTAG_TMS: length 7.3
  BOTTOM w0.114: v3(246.49,34.94) 247.18,35.63 249.64,35.63 250.22,35.05 JDEG1.3 250.22,33.88 250.9,33.2 250.9,32.51 RE110.1
KB_BL_DET: length 56
  TOP w0.114: v2(120.15,14.7) 120.15,14.93 119.76,15.31 RE4.2 119.76,15.66 RE3.1
  IN3 w0.127: v2(156.58,36.62) 155.15,35.19 155.15,32.96 151.97,29.77 151.09,29.77 v2(149.84,28.53)
  BOTTOM w0.102: UH2.T45 157.12,36.12 156.62,36.62 156.6,36.62
  BOTTOM w0.114: 156.6,36.62 v2(156.58,36.62) ; v2(149.84,28.53) 142.43,28.53 142,28.1 142,21.87 141.28,21.16 141.28,17.78 140.94,17.44 128.48,17.44 v4(127.73,16.69) 125.33,14.28 120.56,14.28 v2(120.15,14.7)
KB_DET#: length 50.3
  TOP w0.114: JKB1.30 196.66,33.71 196.16,34.2 196.16,35.96 193.79,38.32 191.96,38.32 191.48,37.84 191.48,36.46 187.7,32.69 187.7,31.51 187.44,31.25 187.44,28.55 186.56,27.66 185.37,27.66 183.65,25.95 183.65,21.83 v4(183.47,21.66) v2(183.47,20.89)
  IN3 w0.127: v2(169.42,21.55) 169.81,21.94 170.47,21.94 170.65,21.76 172.82,21.76 173.17,21.4 173.17,21.24 173.45,20.96 174.42,20.96 175.34,20.04 178.17,20.04 178.78,19.43 181.39,19.43 182.86,20.89 v2(183.47,20.89)
  BOTTOM w0.076: v2(169.42,21.55) 169.24,21.73 169.13,21.73 168.61,22.25 UH2.BD22
  BOTTOM w0.102: v2(169.42,21.55) 169.42,21.45 169.18,21.21 169.18,19.98 169.59,19.57 169.86,19.57 RH128.1
KB_LED_PWM: length 124.2
  TOP w0.114: v2(117.48,15.94) 117.05,16.36 QE5.2 ; v2(226.1,14.19) 226.24,14.33 226.24,14.72 226.25,14.73 UE1.44
  IN3 w0.127: v2(226.1,14.19) 225.66,14.19 224.28,15.57 221.78,15.57 221.55,15.35 220.38,15.35 219.4,14.37 210.78,14.37 209.19,15.95 199.71,15.95 194.33,10.58 185.6,10.58 182.97,7.95 171.56,7.95 171.45,8.06 171.38,8.06 167.62,11.82 162.56,11.82 161.05,10.32 152.96,10.32 151.83,11.44 151.83,13.43 148.72,16.54 145.31,16.54 145.07,16.79 135.11,16.79 134.82,17.07 123.96,17.07 122.83,15.94 117.48,15.94 v2(117.48,15.94)
  BOTTOM w0.114: v2(226.1,14.19) v4(225.22,14.19)
KB_LED_PWM#: length 5.7
  TOP w0.114: QE5.1 118.56,15.17 119.03,14.7 v2(119.49,14.7) 119.49,14.22 119.01,13.74 v4(117.99,13.74)
  BOTTOM w0.114: v2(119.49,14.7) 118.88,14.7 118.59,14.99 JBL1.4
KSI0: length 46.4
  TOP w0.114: UE1.98 233.85,32.82 234.12,33.09 v2(234.12,33.16) 234.12,33.39 234.69,33.96 RPE2.4 ; v2(206.82,42.51) v4(206.35,42.05) 204.01,39.7 202.44,39.7 201.94,39.21 198.28,39.21 197.38,40.11 JKB1.22
  IN4 w0.094: v2(206.82,42.51) 210.55,38.78 214.34,38.78 217.84,35.27 232.28,35.27 234.12,33.42 v2(234.12,33.16)
KSI1: length 42.9
  TOP w0.114: UE1.99 233.45,33.08 v2(233.54,33.16) 233.54,33.37 234.19,34.02 RPE2.3 ; v2(211.4,38.08) 210.97,38.51 v4(208.77,38.51) JKB1.24
  IN4 w0.094: v2(233.54,33.16) 233.54,33.73 232.23,35.04 230.81,35.04 230.81,35.04 229.44,35.04 229.44,35.05 217.71,35.05 214.23,38.52 211.8,38.52 211.4,38.13 v2(211.4,38.08)
KSI2: length 46.2
  TOP w0.114: RPE2.2 233.69,34.36 233.05,33.72 v2(233.05,33.65) ; v2(203.26,37.29) 203.24,37.29 202.44,36.49 198.33,36.49 198.31,36.52 v4(198.24,36.52) 197.85,36.91 JKB1.26 ; UE1.6 219.03,28.14 v2(218.98,28.18)
  IN3 w0.127: v2(218.98,28.18) 219.16,28.36 219.79,28.36 220.99,29.56 227.11,29.56 229.67,32.12 232.5,32.12 233.05,32.68 v2(233.05,33.65)
  IN4 w0.094: v2(203.26,37.29) 203.78,37.29 209.56,31.51 214.24,31.51 216.55,29.2 217.69,29.2 217.96,28.93 218.59,28.93 218.98,28.54 v2(218.98,28.18)
KSI3: length 51.2
  TOP w0.114: v3(216.1,28.25) 216.34,28.49 v2(218.37,28.49) 218.37,28.21 218.84,27.74 UE1.7 ; v2(196.13,37.2) 196.13,38.87 196.57,39.31 JKB1.23 ; RPE2.1 233.19,34.55 232.47,33.82 v2(232.47,33.65)
  IN3 w0.127: v2(218.37,28.49) 218.68,28.79 219.86,28.79 220.86,29.79 227.01,29.79 229.73,32.5 231.84,32.5 231.96,32.63 231.96,33.14 v2(232.47,33.65)
  IN4 w0.094: v2(196.13,37.2) 197.27,36.06 204.66,36.06 209.46,31.26 214.21,31.26 216.52,28.95 217.66,28.95 218.12,28.49 v2(218.37,28.49)
KSI4: length 40.1
  TOP w0.114: JKB1.27 206.41,36.11 207.88,37.58 211.2,37.58 v4(211.3,37.49) 211.48,37.31 v2(211.48,36.95) ; UE1.104 231.45,32.98 v2(231.51,33.04)
  IN4 w0.094: v2(231.51,33.04) 231.63,33.16 231.63,33.9 230.72,34.81 229.35,34.81 229.35,34.82 217.57,34.82 216.97,35.42 213.47,35.42 211.98,36.91 211.52,36.91 v2(211.48,36.95)
  BOTTOM w0.114: v2(231.51,33.04) 231.51,32.93 231.26,32.69 RPE3.4
KSI5: length 38.9
  TOP w0.114: v2(210.65,38.05) v4(206.73,38.05) 197.91,38.05 197.57,37.71 JKB1.25 ; UE1.105 231.05,32.91 230.95,33.01 230.95,33.01 v2(230.92,33.04)
  IN4 w0.094: v2(230.92,33.04) 229.39,34.56 217.47,34.56 216.86,35.17 213.36,35.17 212.12,36.41 211.36,36.41 211.07,36.7 211.07,37.62 v2(210.65,38.05)
  BOTTOM w0.114: v2(230.92,33.04) 230.89,33.04 230.76,32.91 RPE3.3
KSI6: length 38.1
  TOP w0.114: v2(210.64,36.9) 210.64,36.94 210.3,37.28 209.71,37.28 209.6,37.18 208.15,37.18 v4(207.29,36.31) 206.78,35.8 199.91,35.8 199.41,35.31 JKB1.28 ; UE1.107 230.25,32.87 v2(230.08,33.04)
  IN4 w0.094: v2(210.64,36.9) 210.67,36.88 210.67,36.58 212.43,34.82 216.86,34.82 217.39,34.28 228.83,34.28 v2(230.08,33.04)
  BOTTOM w0.114: v2(230.08,33.04) 230.26,32.85 RPE3.2
KSI7: length 38.4
  TOP w0.114: v2(209.99,36.85) 209.96,36.82 208.58,36.82 207.31,35.55 200.54,35.55 199.5,34.51 v4(198.4,34.51) JKB1.29 ; v2(229.5,33.04) 229.5,33.01 229.85,32.66 UE1.108
  IN4 w0.094: v2(209.99,36.85) 210.35,36.48 210.49,36.48 212.41,34.56 216.73,34.56 218.59,32.71 222.91,32.71 223.85,31.77 228.23,31.77 v2(229.5,33.04)
  BOTTOM w0.114: v2(229.5,33.04) 229.5,32.98 229.77,32.72 RPE3.1
KSO0: length 45.7
  TOP w0.114: v2(197.77,47.34) 197.75,47.31 JKB1.13 ; v3(217.8,27.3) 217.8,26.35 v2(217.59,26.14) 217.59,25.98 217.07,25.45 RPE4.8 ; v2(220.95,30.6) 221.09,30.46 221.06,30.43 221.12,30.43 221.28,30.26 221.28,29.88 221.15,29.74 UE1.2
  IN3 w0.127: v2(217.59,26.14) 217.59,29.53 218.17,30.11 220.47,30.11 v2(220.95,30.6)
  IN4 w0.094: v2(197.77,47.34) 199.37,45.74 199.37,43.96 200.85,42.48 201.64,42.48 201.84,42.28 201.84,41.87 202.12,41.6 204.97,41.6 207.91,38.66 207.91,36.04 208.65,35.3 210.01,35.3 212.29,33.02 216.12,33.02 217.91,31.23 220.51,31.23 220.95,30.79 v2(220.95,30.6)
KSO1: length 45.3
  TOP w0.114: v2(198.04,45.79) 197.96,45.71 JKB1.15 ; v2(222.83,27.8) 222.93,27.7 222.93,25.92 221.95,24.94 UE1.14 219.25,24.94 218.7,25.49 v3(218.22,25.49) 217.69,25.49 217.15,24.95 RPE4.7
  IN4 w0.094: v2(222.83,27.8) 222.77,27.86 222.77,28.57 222.31,29.03 220.31,29.03 219.16,30.19 217.44,30.19 215.59,32.03 211.36,32.03 209.93,33.47 208.92,33.47 206.89,35.5 206.89,38.17 204.35,40.71 201.6,40.71 198.04,44.27 v2(198.04,45.79)
KSO2: length 47.5
  TOP w0.114: v2(223.18,28.31) 223.18,28.03 223.36,27.84 223.36,26.05 221.86,24.54 UE1.15 220.19,24.58 217.47,24.58 217.35,24.45 RPE4.6 ; v3(199.4,45.76) 199.07,45.43 v2(198.56,45.43) 198.56,45.99 198.04,46.51 JKB1.14
  IN4 w0.094: v2(223.18,28.31) 223.18,28.61 222.48,29.31 220.34,29.31 219.21,30.44 217.54,30.44 215.7,32.29 211.39,32.29 209.93,33.75 209,33.75 207.15,35.6 207.15,38.2 204.41,40.93 201.69,40.93 198.32,44.3 198.32,45.19 v2(198.56,45.43)
KSO3: length 46.3
  TOP w0.114: RPE4.5 217.13,23.95 217.4,23.69 v3(218.26,23.69) 218.91,23.69 219.36,24.14 UE1.16 221.76,24.14 223.71,26.09 v2(223.71,28.07) ; JKB1.16 196.96,44.94 v2(198.88,44.94)
  IN4 w0.094: v2(223.71,28.07) 223.71,28.6 222.75,29.57 220.45,29.57 219.31,30.7 217.65,30.7 215.8,32.54 211.41,32.54 209.99,33.97 209.14,33.97 207.4,35.71 207.4,38.3 204.54,41.16 201.74,41.16 198.88,44.02 v2(198.88,44.94)
KSO4: length 52.6
  TOP w0.114: JKB1.20 197.48,41.71 197.91,42.14 201.37,42.14 v2(201.43,42.08) ; v2(224.75,28.13) 224.75,26.08 223.76,25.09 223.76,20.97 224.53,20.2 224.53,18.44 224.28,18.19 224.17,18.19 223.45,17.47 223.45,16.12 UE1.37 223.45,15.15 223.61,14.99 223.61,14.28 v3(223.74,14.15) 224.43,13.46 RPE5.8
  IN4 w0.094: v2(201.43,42.08) 201.43,41.93 201.99,41.37 204.69,41.37 207.65,38.41 207.65,35.82 209.19,34.28 210.05,34.28 211.53,32.8 215.98,32.8 217.8,30.98 219.39,30.98 220.55,29.82 222.91,29.82 224.6,28.13 v2(224.75,28.13)
KSO5: length 53.7
  TOP w0.114: RPE5.7 224.93,14.18 223.85,15.26 UE1.38 223.85,17.57 224.26,17.97 224.37,17.97 225.23,18.83 225.23,27.77 v2(225.59,28.14) ; v2(202.24,42.08) 201.83,41.67 v3(198.46,41.67) 198.23,41.67 197.48,40.91 JKB1.21
  IN4 w0.094: v2(225.59,28.14) 225.09,28.64 224.45,28.64 223.05,30.04 221.57,30.04 221.37,30.24 221.37,30.95 220.84,31.49 218.01,31.49 216.22,33.28 212.31,33.28 210.09,35.5 209.68,35.5 209.66,35.52 208.78,35.52 208.16,36.14 208.16,38.91 205.28,41.8 202.52,41.8 v2(202.24,42.08)
KSO6: length 56.5
  TOP w0.114: RPE5.6 225.43,14.04 v3(225.55,14.15) 225.55,14.37 225.04,14.87 224.58,14.87 224.25,15.21 UE1.39 224.25,16.89 224.11,17.04 224.11,17.52 224.35,17.76 224.46,17.76 225.45,18.75 225.45,26.78 v2(226.81,28.13) ; JKB1.18 199.9,43.31 v2(200.26,43.68)
  IN4 w0.094: v2(226.81,28.13) 226.81,28.21 226.12,28.9 224.55,28.9 223.45,30 223.45,30.77 222.49,31.74 218.12,31.74 216.33,33.53 212.33,33.53 210.17,35.69 209.76,35.69 209.74,35.72 209.58,35.72 208.95,35.72 208.42,36.25 208.42,39.26 205.67,42 202.93,42 202.24,42.69 200.97,42.69 200.26,43.4 v2(200.26,43.68)
KSO7: length 59.5
  TOP w0.114: v2(228.6,28.13) 226.72,26.26 226.72,24.88 227,24.6 227,21.8 227.64,21.16 227.64,18.2 228.65,17.18 UE1.50 228.65,15.13 228.37,14.85 228.37,14.37 228.04,14.04 v3(227.31,14.04) 226.56,14.04 225.93,13.41 RPE5.5 ; JKB1.19 197.34,42.51 197.66,42.83 200.76,42.83 v2(201.25,43.32)
  IN4 w0.094: v2(228.6,28.13) 228.6,28.27 226.98,29.89 226.76,29.89 226.5,30.14 226.5,30.65 225.92,31.23 223.72,31.23 222.65,32.3 218.28,32.3 216.54,34.04 212.38,34.04 210.33,36.09 209.92,36.09 209.9,36.11 209.41,36.11 209.27,36.11 208.92,36.46 208.92,39.46 205.98,42.41 203.13,42.41 202.42,43.12 201.46,43.12 v2(201.25,43.32)
KSO8: length 67.4
  TOP w0.114: UE1.46 227.05,17.17 226.79,17.43 226.79,20.38 v2(227.17,20.77) 227.17,21.19 226.79,21.57 226.79,24.49 226.51,24.77 226.51,26.65 v2(227.99,28.13) ; RPE7.8 238.49,22.61 238.26,22.38 v2(238.26,21.55) ; JKB1.17 v3(198.45,44.11) v2(199.83,44.11)
  IN3 w0.127: v2(238.26,21.55) 238.26,21.96 237.98,22.24 234.9,22.24 234.66,22.48 233.45,22.48 232.16,21.19 232.03,21.19 227.59,21.19 v2(227.17,20.77)
  IN4 w0.094: v2(227.99,28.13) 227.99,28.18 226.92,29.25 224.85,29.25 224.42,29.68 224.42,30.6 224.04,30.98 223.61,30.98 222.57,32.02 218.2,32.02 216.43,33.78 212.36,33.78 210.25,35.89 209.84,35.89 209.82,35.92 209.49,35.92 209.11,35.92 208.67,36.36 208.67,39.33 205.8,42.2 203.06,42.2 202.37,42.89 201.08,42.89 200.67,43.3 200.67,43.88 200.44,44.11 v2(199.83,44.11)
KSO9: length 73.9
  TOP w0.114: v2(237.09,19.07) 236.97,18.94 UE1.68 234.85,18.94 234.73,19.06 234.73,19.34 233.14,20.93 233.14,22.26 232.64,22.76 232.64,24.23 231.94,24.92 231.94,28.92 v2(231.59,29.27) ; v2(203.08,45.25) 203.08,45.28 202.37,45.99 201.93,45.99 199.28,48.64 199.28,49.58 198.57,50.3 198.57,52.41 198.4,52.58 v3(198.37,52.58) 198,52.58 197.53,52.11 JKB1.7
  IN4 w0.094: v2(203.08,45.25) 203.41,45.58 204.65,45.58 205.11,45.11 206.18,45.11 210.38,40.91 210.89,40.4 231.24,40.4 236.1,35.54 236.1,30.32 234.63,28.85 232.01,28.85 v2(231.59,29.27)
  BOTTOM w0.114: RE30.1 236.99,19.17 v2(237.09,19.07)
KSO10: length 70.4
  TOP w0.114: v2(232.22,29.25) 232.22,28.95 232.16,28.9 232.16,25.01 232.85,24.32 232.85,24.18 232.85,22.95 233.35,22.45 233.35,21.01 233.91,20.46 234.77,20.46 234.86,20.54 UE1.72 237.3,20.54 237.75,21 v2(237.75,21.1) ; JKB1.5 198.28,53.71 199.01,52.98 199.01,50.47 199.71,49.76 199.71,48.82 202.11,46.42 204.48,46.42 205.55,45.35 v4(205.55,45.28) v2(205.55,43.81)
  IN4 w0.094: v2(232.22,29.25) 231.59,29.88 231.59,30.73 231.96,31.11 232.63,31.11 234.52,33 234.52,33.33 232.35,35.5 217.97,35.5 214.36,39.11 210.78,39.11 206.09,43.81 v2(205.55,43.81)
  BOTTOM w0.114: v2(237.75,21.1) 237.75,20.87 237.21,20.32 RPE6.8
KSO11: length 66.4
  TOP w0.114: JKB1.6 197.42,52.91 197.7,53.19 198.31,53.19 198.8,52.7 198.8,50.38 199.5,49.67 199.5,48.73 202.02,46.21 203.25,46.21 v4(203.67,45.78) 204.43,45.02 v2(204.43,44.95) ; v2(233.13,29.28) 233.13,28.9 232.59,28.36 232.59,25.21 233.28,24.52 233.28,24.36 233.28,23.15 235.1,21.34 UE1.74 236.8,21.34 v2(237.14,21)
  IN4 w0.094: v2(233.13,29.28) 233.68,29.83 234.4,29.83 234.88,30.31 234.88,30.85 235.46,31.43 235.46,33.22 228.87,39.82 210.92,39.82 209.99,40.75 206.04,44.69 204.68,44.69 v2(204.43,44.95)
  BOTTOM w0.114: RPE6.7 236.97,20.82 v2(237.14,21)
KSO12: length 58.5
  TOP w0.114: v2(233.05,28.21) 233.05,25.06 233.5,24.61 233.5,24.45 233.5,23.24 235,21.74 UE1.75 236.96,21.74 237.04,21.66 v2(237.12,21.66) ; v2(202.85,43.27) 202.85,43.63 201.26,45.23 v4(201.26,45.45) 201.26,45.75 198.89,48.11 JKB1.12
  IN4 w0.094: v2(233.05,28.21) 231.73,28.21 231.12,28.82 231.12,29.63 231.35,29.86 231.35,30.75 230.59,31.51 223.8,31.51 222.8,32.51 218.43,32.51 216.64,34.29 212.4,34.29 210.41,36.28 210.05,36.28 210.03,36.31 209.98,36.31 209.98,36.31 209.44,36.31 209.18,36.57 209.18,39.49 206.03,42.64 203.21,42.64 202.85,42.99 v2(202.85,43.27)
  BOTTOM w0.114: RPE6.6 236.86,21.32 237.12,21.58 v2(237.12,21.66)
KSO13: length 65.8
  TOP w0.114: v2(201.79,45.28) 201.79,45.52 198.64,48.67 v4(198.64,48.99) 198.64,49.57 197.7,50.51 JKB1.9 ; v2(237.7,21.78) 237.34,22.14 UE1.76 235.06,22.14 233.72,23.49 233.72,23.64 233.72,24.7 233.41,25.01 233.41,27.65 233.56,27.81 233.56,29.1 v2(233.74,29.28)
  IN4 w0.094: v2(201.79,45.28) 202.22,44.85 203.31,44.85 203.81,45.35 204.6,45.35 205.03,44.92 206.1,44.92 210.18,40.83 210.94,40.07 230.55,40.07 233.92,36.71 233.92,36.55 235.9,34.57 235.9,30.39 234.78,29.28 v2(233.74,29.28)
  BOTTOM w0.114: v2(237.7,21.78) 237.37,22.12 236.97,22.12 236.68,21.82 RPE6.5
KSO14: length 66.7
  TOP w0.114: RPE7.6 238.39,23.61 238.23,23.46 238.23,22.92 237.85,22.54 UE1.77 235.04,22.54 233.93,23.65 233.93,24.79 233.62,25.1 233.62,27.42 234.05,27.85 v2(234.05,28.18) ; JKB1.8 197.74,51.31 v3(198.23,50.82) 198.23,50.33 199.03,49.53 199.03,48.59 201.9,45.71 202.07,45.71 v2(202.45,45.33)
  IN4 w0.094: v2(234.05,28.18) 234.24,28.18 236.3,30.24 236.3,35.62 231.26,40.66 210.91,40.66 210.57,40.99 206.26,45.31 205.19,45.31 204.61,45.89 202.75,45.89 202.45,45.58 v2(202.45,45.33)
KSO15: length 78
  TOP w0.114: v3(241.5,21.25) 240.82,21.94 v2(240.27,21.94) 239.93,22.28 239.56,22.28 239.38,22.46 239.38,22.95 239.22,23.11 RPE7.7 ; JKB1.10 195.96,49.71 v2(195.67,49.42) ; v2(233.21,30.37) 233.72,29.86 233.87,29.86 234.17,29.56 234.17,28.71 234.5,28.38 234.5,26.57 234.93,26.14 UE1.86
  IN4 w0.094: v2(195.67,49.42) 195.67,48.76 196.05,48.38 197.68,48.38 201.59,44.46 201.82,44.23 205.95,44.23 209.6,40.59 210.87,39.31 228.82,39.31 234.72,33.41 234.72,31.88 v2(233.21,30.37)
  BOTTOM w0.114: v2(240.27,21.94) 241.11,22.77 241.11,26.82 240.28,27.65 239.98,27.65 239.47,28.16 239.47,30.88 238.81,31.54 234.38,31.54 v2(233.21,30.37)
KSO16: length 68.9
  TOP w0.114: v2(234.38,30.37) 234.6,30.14 234.6,28.93 234.99,28.54 UE1.92 ; JKB1.11 196.17,48.91 v2(196.15,48.89) ; RPE7.5 239.07,24.11 v2(239.66,24.7) 239.68,24.7 239.94,24.44 240.4,24.44 241.36,23.47 v3(241.36,23.02)
  IN4 w0.094: v2(234.38,30.37) 234.38,30.62 235.26,31.51 235.26,33.14 228.84,39.56 210.9,39.56 209.79,40.67 206.03,44.43 201.9,44.43 197.42,48.91 196.17,48.91 v2(196.15,48.89)
  BOTTOM w0.114: v2(239.66,24.7) 239.66,24.72 240.66,25.73 240.66,26.94 240.18,27.42 239.91,27.42 239.25,28.07 239.25,30.79 238.91,31.13 235.11,31.13 234.38,30.39 v2(234.38,30.37)
L_BKLT_EN_EC: length 103.9
  TOP w0.114: v2(239,33.4) 239,33.22 v3(239.36,32.86) 240.39,31.83 240.39,29.51 239.82,28.95 238.95,28.95 RE114.2 237.07,28.44 236.77,28.14 UE1.91
  IN3 w0.127: v2(161.6,35.02) 161.6,34.33 164.61,31.32 169.64,31.32 170.24,31.92 170.24,33.33 171.33,34.42 172.73,34.42 175.7,31.44 175.7,30.81 176.21,30.3 177.8,30.3 179.94,28.16 181.91,28.16 185.37,31.63 186.43,31.63 189.38,34.57 205.81,34.57 208.38,32.01 216.23,32.01 216.88,32.65 220.14,32.65 221.05,33.56 222.22,33.56 223.16,32.62 224.52,32.62 226.83,34.93 226.83,35.73 227.94,36.83 231.56,36.83 233.23,35.16 233.74,35.16 236.35,32.54 238.39,32.54 239,33.15 v2(239,33.4)
  BOTTOM w0.102: v2(161.6,35.02) 162.05,34.57 UH2.W35
LAN_CLKREQ#: length 174.3
  TOP w0.114: v2(166.76,24.98) 166.76,24.93 166.51,24.68 165.82,24.68 165.55,24.41 165.55,24.36 164.91,23.72 164.91,22.52 v3(164.76,22.37) 164.27,21.88 164.27,21.06 163.56,20.35 163.56,19.68 162.4,18.52 RP3.5
  IN1 w0.094: v2(293.74,50.07) 293.74,49.6 292.67,48.53 292.67,43.37 293.43,42.61 293.43,40.71 291.07,38.34 291.07,37.58 284.59,31.11 279.49,31.11 277.17,33.42 275.78,33.42 272.07,29.71 272.07,26.54 271.26,25.73 267.74,25.73 267.7,25.69 263.26,25.69 262.9,25.33 257.25,25.33 256.06,24.13 250.68,24.13 250.03,24.78 245.18,24.78 244.93,24.53 242.27,24.53 242.13,24.68 240.59,24.68 240.12,24.2 236.41,24.2 235.86,23.65 233.82,23.65 231.97,21.8 227.23,21.8 226.47,22.56 223.44,22.56 222.86,23.14 216.47,23.14 215.63,23.99 212.94,23.99 212.28,23.33 206.74,23.33 206.6,23.46 199.18,23.46 198.3,22.57 193.38,22.57 193.01,22.94 187.89,22.94 187.29,22.34 181.23,22.34 180.73,21.84 178.62,21.84 178.47,21.99 177.06,21.99 176.67,22.38 170.66,22.38 170.45,22.59 168.66,22.59 167.55,23.7 167.55,23.97 166.76,24.76 v2(166.76,24.98)
  BOTTOM w0.089: UH2.AT24 167.33,25.86 166.79,25.31 166.79,25.01 v2(166.76,24.98)
  BOTTOM w0.114: v2(293.74,50.07) 293.42,50.38 291.68,50.38 291.42,50.13 291.42,47.25 291.02,46.84 291.02,45.76 290.8,45.54 289.98,45.54 289.69,45.25 289.39,45.25 289.04,44.89 UL1.12
LAN_DISABLE#_R: length 142.5
  IN4 w0.094: v2(165.77,28.62) 166.4,29.25 171.35,29.25 171.63,29.53 172.63,29.53 172.68,29.48 174.84,29.48 174.84,29.48 175.32,29 179.65,29 180.54,29.89 181.47,29.89 183.44,31.85 186.66,31.85 188.4,33.59 192.35,33.59 192.67,33.28 192.95,33.28 193.72,34.05 196.64,34.05 198.88,31.8 204.43,31.8 205.38,30.85 213.99,30.85 215.35,29.5 216.46,28.39 217.58,28.39 218.28,27.7 218.39,27.59 221.06,27.59 221.12,27.52 222.21,27.52 222.68,27.05 223.56,27.05 223.68,27.16 223.68,27.16 223.89,27.38 223.9,27.38 224.04,27.53 229.7,27.53 229.89,27.34 232.97,27.34 232.99,27.36 234.85,27.36 236.15,28.67 236.36,28.67 236.36,28.67 236.75,28.67 236.75,28.67 241.44,28.67 242.06,29.29 245.87,29.29 250.25,24.91 253.8,24.91 255.01,26.13 255.99,27.1 265.95,27.1 266.9,26.15 273.73,26.15 274.79,27.21 274.79,32.86 275.68,33.75 277.01,33.75 278.89,35.63 279.74,35.63 280.45,36.34 280.45,38.06 281.11,38.73 v2(281.59,38.73)
  BOTTOM w0.102: UH2.AL27 166.15,28.99 v2(165.77,28.62)
  BOTTOM w0.114: RL43.1 280.93,39.39 v2(281.59,38.73) 281.67,38.65 282.38,38.65 282.71,38.32 282.71,37.07 v3(282.97,36.82) 283.14,36.64 284.77,36.64 RL1.1
LAN_EN: length 75.5
  TOP w0.114: UE1.3 219.22,29.34 v2(218.96,29.61)
  IN3 w0.127: v2(272.55,47.74) 271.96,47.15 270.94,47.15 267.14,43.35 262.35,43.35 262.23,43.22 262.23,42.13 261.77,41.67 259.64,41.67 252.99,35.02 252.62,35.02 252.57,34.97 246.38,34.97 243.25,31.84 236.27,31.84 236.08,31.84 233.86,34.06 228.73,34.06 227.82,33.15 227.82,32.87 225.76,30.81 224.73,30.81 224.48,30.57 224.48,30.45 224.05,30.01 220.71,30.01 220.3,29.61 v2(218.96,29.61)
  BOTTOM w0.114: v2(272.55,47.74) 272.92,47.74 v4(273.5,48.32) 277.47,52.29 RL27.2 278.71,51.52 UL2.4
LAN_WAKE#: length 10.2
  BOTTOM w0.076: UH2.BD11 173.77,22.44 174.04,22.18 174.04,21.21 173.72,20.89 v3(173.72,20.56) 173.72,19.51
  BOTTOM w0.102: 173.27,18.43 173.27,19.06 173.72,19.51
  BOTTOM w0.114: 173.27,18.43 173.26,18.42 173.26,17.78 172.47,16.98 172.32,16.98 172.09,16.76 RH181.1 172.58,15.84 172.58,15 173.36,14.21 RH11.1
LAN_WAKE#_R: length 4.9
  TOP w0.114: RL42.2 286.55,40.68 286.79,40.92 v3(286.79,41.07) 286.79,41.23 286.62,41.39 v2(286.39,41.39)
  BOTTOM w0.114: UL1.21 285.81,41.03 RL2.2 286.39,40.96 v2(286.39,41.39)
LCD_TST: length 186.2
  TOP w0.114: UE1.26 219.2,20.14 219.07,20.01 218.44,20.01 v2(218.06,20.4) ; 66.05,29.2 UZ23.2 ; 66.05,29.2 66.05,28.95 65.48,28.38 64.76,28.38 64.7,28.44 63.76,28.44 63.51,28.18 63.51,27.68 63.71,27.47 63.71,26.99 ; 66.05,29.2 66.56,28.69 66.94,28.69 67.19,28.95 67.19,29.96 66.56,30.6 66.56,31.36 DV2.3 ; 63.71,26.99 RV538.1 ; 63.71,26.99 63.26,27.45 62.49,27.45 62.12,27.08 62.12,26.42 61.76,26.05 v2(61.68,26.05) v3(61.21,26.52)
  IN1 w0.094: v2(218.06,20.4) 217.81,20.64 213.82,20.64 213.11,21.35 211.89,21.35 210.34,19.79 200.07,19.79 197.6,17.32 188.64,17.32 188.04,17.91 183.61,17.91 180.25,14.55 173.29,14.55 170.76,17.08 170.76,17.25 169.23,18.79 161.11,18.79 159.56,17.24 146.86,17.24 144.93,19.17 138.21,19.17 137.89,19.48 103.12,19.48 101.86,18.23 74.6,18.23 73.82,17.44 66.36,17.44 62.21,21.59 62.21,25.52 v2(61.68,26.05)
LCD_TST_R: length 9.9
  TOP w0.114: v2(61.08,26.02) 61.47,25.63 61.89,25.63 62.24,25.99 62.24,26.2 62.35,26.31 62.35,26.51 62.75,26.91 RV538.2 62.8,26.44 62.77,26.41 RV567.1 63.24,25.49 v3(64.88,25.49) 65.4,26.01 UZ23.4
  BOTTOM w0.114: v2(61.08,26.02) 61.48,25.62 61.88,25.62 62.28,26.01 JEDP1.5
LCD_VCC_TEST_EN: length 185.4
  TOP w0.114: UE1.113 227.85,33.54 v3(227.61,33.78) 227.42,33.98 224.48,33.98 v2(223.69,33.19) ; v2(68.21,30.83) 68.09,30.95 68.09,32.03 68.45,32.39 68.45,32.82 68.02,33.25 DV3.2
  IN3 w0.127: v2(68.21,30.83) 68.67,31.28 69.76,31.28 70.42,31.94 106.35,31.94 109.68,28.61 140.95,28.61 142.52,30.18 145.97,30.18 147.14,31.35 152.49,31.35 154.31,33.18 154.31,35.65 156.92,38.26 157.3,38.26 158.77,36.78 159.97,36.78 160.96,35.79 161.42,35.79 162.02,35.19 162.02,34.23 164.71,31.55 169.55,31.55 170.01,32.01 170.01,33.42 171.24,34.65 172.82,34.65 175.51,31.96 176.71,31.96 180.27,28.4 181.83,28.4 184.98,31.55 185.28,31.85 186.34,31.85 189.28,34.8 189.31,34.8 205.91,34.8 208.47,32.24 216.13,32.24 216.78,32.88 220.05,32.88 220.95,33.78 222.48,33.78 223.08,33.19 v2(223.69,33.19)
LDO2_CAP: length 2.8
  TOP w0.203: HDA1.39 282.71,28.77 v2(282.79,28.84)
  BOTTOM w0.114: v2(282.79,28.84) v3(282.79,28.06)
  BOTTOM w0.203: v2(282.79,28.84) 283.09,29.15 CA22.2
LDO_1VALWP: length 2.6
  BOTTOM w0.102: v3(248.38,10.4) 248.38,12.3 PC611.1
LDO_+0.95VSP: length 0.9
  TOP w0.127: PC710.1 v3(70.49,67.77)
LDO_+1.0VSP: length 0.9
  TOP w0.127: v2(220.84,42) 221.24,42.41 v4(221.54,42.41)
LDO_+1.8VSP: length 1.2
  BOTTOM w0.127: PC1011.1 v4(202.79,116.93)
LED1: length 14.3
  TOP w0.114: JLED.3 247.49,24.19 247.74,23.94 248.62,23.94 249.84,25.16 v3(250.9,25.16) 252.74,25.16 253.48,25.9 253.48,26.25 253.12,26.61 QE20.6 253.13,27.04 253.76,27.04 254.01,27.3 254.01,28.57 254.64,29.2 255.79,29.2 256.52,28.47 QE21.3
LED2: length 3.8
  TOP w0.114: QE23.3 248.45,26.63 248.57,26.51 v3(248.57,26.16) 248.26,25.85 246.98,25.85 246.49,25.36 JLED.2
LG_3V: length 19.9
  TOP w0.127: v2(50.05,20.36) v3(50.05,21.14)
  IN1 w0.635: v2(50.05,20.36) v2(50.05,19.68) 50.05,18.66 49.54,18.15 49.54,13.96 54.24,9.26 v2(59.32,9.26) v2(60.08,9.26)
LG_5V: length 12.4
  TOP w0.635: 49.92,35.3 v4(49.92,33.72) 49.92,30.03 49.03,29.14 49.03,25.77 49.48,25.32 49.48,23.41 49.48,23.41
  vias: v2(49.36,22.72) v2(49.82,36.31) v2(49.84,36.9) v2(49.96,22.71)
LG_+1.35VS_VGAP: length 20
  TOP w0.114: v2(143.65,130.24) v4(143.65,129.59)
  IN1 w0.635: 143.29,129.45 139.25,129.45 138.81,129.01 138.81,125.73 139.86,124.68 139.86,121.83 139.2,121.17 139.2,115.36 139.41,115.15
  vias: v2(139.28,114.87) v2(139.3,114.29) v2(144.08,130.7)
LID_CL_SIO#: length 291
  TOP w0.114: JIO1.25 v2(4.96,34.75) ; v2(244.13,22.49) 244.13,23.05 243.56,23.62 243.56,25.47 v3(243.21,25.82) 242.22,26.81 RE68.2
  IN4 w0.094: v2(4.96,34.75) 1.47,31.26 1.47,16.87 2.21,16.13 12.05,16.13 17.27,10.91 21.05,10.91 23.72,8.23 49,8.23 55.16,14.4 59.48,14.4 61.52,16.45 109.89,16.45 110.24,16.09 115.31,16.09 115.56,16.34 118.41,16.34 118.52,16.23 123.49,16.23 124.2,16.94 145.89,16.94 146.08,17.13 150.16,17.13 150.57,16.72 161.1,16.72 162.26,15.57 164.41,15.57 169.32,10.66 175.2,10.66 175.73,10.12 179.98,10.12 185.13,15.27 188.01,15.27 188.51,15.77 194.83,15.77 198.46,19.41 205.36,19.41 206.52,20.57 211.07,20.57 211.86,21.36 213.09,21.36 214.22,20.23 217.05,20.23 217.71,19.57 220.27,19.57 221.59,18.24 228.35,18.24 228.66,17.94 229.39,17.94 230.27,18.82 233.88,18.82 235.41,20.36 238.08,20.36 239.12,21.4 241.06,21.4 241.77,22.11 243.75,22.11 v2(244.13,22.49)
LID_CLOSE#: length 15.8
  TOP w0.114: UE1.96 235.13,30.14 235.03,30.24 235.03,31 236.23,32.19 237.29,32.19 237.62,32.52 237.62,32.94 238.49,33.82 239.17,33.82 239.9,33.09 239.9,32.69 240.85,31.73 v3(240.85,28.96) CE8.1 RE68.1 RE25.2
LINE1-L_R: length 1.1
  TOP w0.114: RA51.1 292.57,13.79 v3(292.26,13.49)
LINE1_L: length 20.3
  TOP w0.203: HDA1.22 282.71,21.25 282.98,20.98 283.29,20.98 v2(283.4,20.87)
  TOP w0.508: v2(295.67,18.47) 295.43,18.7 294.69,18.7 v4(294.33,18.34) 294.33,17.29 295.41,16.21 CA64.1
  IN4 w0.508: v2(283.4,20.87) 283.92,20.35 286.23,20.35 286.71,19.87 288.11,19.87 290.59,17.39 293.6,17.39 294.71,18.51 295.63,18.51 v2(295.67,18.47)
LINE1_R: length 14.9
  TOP w0.203: v2(282.81,20.56) 282.31,21.05 HDA1.21
  IN4 w0.508: v2(282.81,20.56) 283.64,19.73 285.91,19.73 286.46,19.18 287.9,19.18 290.32,16.75 293.52,16.75 293.89,16.38 v2(293.89,16.25)
  BOTTOM w0.114: v2(282.81,20.56) v3(282.81,21.16)
LINE1_VREFO_L: length 22.2
  TOP w0.203: v2(286.27,24.76) 286.26,24.76 286.07,24.95 HDA1.31
  IN1 w0.508: v2(286.27,24.76) 286.72,24.76 291.91,19.57 291.91,15.41 292.87,14.44 295.95,14.44 296.66,13.73 296.66,12.77 296.2,12.31 v2(295.79,12.31)
  BOTTOM w0.114: v2(286.27,24.76) v3(285.46,24.76)
LINE1_VREFO_R: length 22.8
  TOP w0.203: HDA1.30 285.78,24.55 286.27,24.07 v2(286.27,23.99)
  IN4 w0.508: v2(293.25,16.12) 290.06,16.12 287.72,18.46 286.22,18.46 285.63,19.04 282.92,19.04 282.5,19.46 282.5,19.87 282.05,20.31 282.05,21.02 282.58,21.55 283.73,21.55 283.96,21.33 284.52,21.33 284.92,21.73 284.92,22.29 286.27,23.64 v2(286.27,23.99)
  BOTTOM w0.114: v2(286.27,23.99) v3(286.84,23.99)
LINE2_L: length 44.9
  TOP w0.254: RA71.1 284.06,17.44 RA72.2 283.41,17.45 283.41,16.9 280.3,13.79 280.3,12.74 v3(279.72,12.16) 278.01,10.45 256.65,10.45 256.04,11.06 256.04,20.77 v2(256.3,21.02)
  BOTTOM w0.254: CD91.2 257.52,21.78 256.75,21.02 v2(256.3,21.02)
LPC_LAD0: length 104
  TOP w0.114: UE1.59 232.25,16.94 232.5,17.19 232.5,17.67 230.88,19.29 230.48,19.29 229.48,20.3 229.48,21.1 229.48,21.72 228.98,22.22 228.98,23.93 v2(230.15,25.1) ; v3(169.81,26.12) v2(169.25,26.12)
  IN4 w0.094: v2(169.25,26.12) 169.36,26.12 170.09,25.39 170.37,25.39 170.54,25.21 171.72,25.21 172.12,24.82 172.12,24.42 173.3,23.25 175.81,23.25 176.05,23.01 176.49,23.01 176.89,23.41 178.18,23.41 178.89,24.11 184.97,24.11 185.22,24.36 187.43,24.36 v2(190.71,27.65) 191.6,28.54 203.76,28.54 204.19,28.11 208.35,28.11 209.12,27.34 211.12,27.34 211.53,27.76 214.53,27.76 216.59,25.7 220.54,25.7 221.14,25.11 224,25.11 224.47,25.58 229.16,25.58 229.64,25.1 v2(230.15,25.1) 230.15,25.3 230.41,25.56 233.06,25.56 233.58,25.56 233.7,25.68 235.75,25.68 235.75,25.68 236.68,26.62 237.05,26.99 238.85,26.99 239.43,26.41 243.25,26.41 244.56,27.71 245.59,27.71 v2(246.09,27.21)
  BOTTOM w0.089: UH2.AT22 169.22,26.15 v2(169.25,26.12)
  BOTTOM w0.114: JNGFF1.18 190.56,27.8 v2(190.71,27.65) ; v2(246.09,27.21) 246.09,27.22 246.09,31.33 246.02,31.4 246.02,32.24 JLPDE1.3
LPC_LAD1: length 102.6
  TOP w0.114: UE1.60 232.65,16.87 232.94,17.16 232.94,17.64 230.32,20.27 230.21,20.27 229.98,20.5 229.98,21.92 229.51,22.38 229.51,23.76 230.77,25.02 v2(230.77,25.09)
  IN4 w0.094: v2(245.46,27.22) 244.74,27.22 243.45,25.93 238.23,25.93 238.02,26.14 236.88,26.14 236.6,25.86 235.47,24.73 231.61,24.73 231.25,25.09 v2(230.77,25.09) 230.31,24.62 227.45,24.62 227.34,24.73 224.42,24.73 224.33,24.63 220.94,24.63 220.35,25.22 216.39,25.22 214.33,27.28 211.73,27.28 211.32,26.87 204.94,26.87 203.95,25.88 193.12,25.88 v2(191.38,27.62) 187.65,23.89 185.41,23.89 184.73,23.21 180.98,23.21 180.55,23.64 179.13,23.64 178.39,22.9 177.05,22.9 176.96,22.81 176.68,22.53 175.86,22.53 175.61,22.77 173.31,22.77 171.8,24.28 171.3,24.28 171.3,24.28 171.21,24.28 170.96,24.54 170.02,24.54 v2(169.28,25.28)
  BOTTOM w0.089: v2(169.28,25.28) 169.17,25.39 UH2.AV22
  BOTTOM w0.114: JLPDE1.4 245.52,30 245.59,29.93 245.59,27.35 v2(245.46,27.22) ; JNGFF1.20 191.06,28.33 191.38,28.01 v2(191.38,27.62)
LPC_LAD2: length 102.7
  TOP w0.114: v3(233.64,14.39) 233.64,14.75 233.05,15.34 UE1.61 233.05,16.86 233.48,17.29 233.48,17.8 230.84,20.44 230.84,21.76 230.01,22.59 230.01,23.56 231.27,24.82 231.27,26.46 v2(230.97,26.76)
  IN4 w0.094: v2(245.09,28.68) 244.96,28.82 242.28,28.82 241.66,28.19 237.05,28.19 236.55,28.19 235.25,26.89 233.18,26.89 233.06,26.76 v2(230.97,26.76) 229.67,26.76 229.4,27.04 224.22,27.04 224.15,26.97 223.75,26.56 221.38,26.56 220.83,27.11 218.19,27.11 217.8,27.5 217.38,27.91 216.26,27.91 214.91,29.27 213.46,29.27 213.1,29.62 208.32,29.62 208.03,29.33 204.67,29.33 204.26,29.74 194.21,29.74 192.86,31.09 191.54,31.09 191.04,30.6 v2(189.84,30.6) 189.38,30.14 188.34,30.14 185.58,27.39 185,27.39 183.91,26.3 182.85,26.3 182.34,26.81 181.68,26.81 181.32,26.45 174.14,26.45 174.07,26.53 172.24,26.53 172.05,26.34 169.86,26.34 v2(169.25,26.95)
  BOTTOM w0.089: UH2.AT19 169.77,26.42 169.25,26.94 v2(169.25,26.95)
  BOTTOM w0.114: JLPDE1.5 245.02,28.75 v2(245.09,28.68) ; JNGFF1.16 190.06,30.37 v2(189.84,30.6)
LPC_LAD3: length 100
  TOP w0.114: UE1.62 233.45,16.95 233.7,17.19 233.7,18.23 232.63,19.29 232.63,19.37 231.66,20.33 231.66,21.67 230.56,22.77 v2(230.56,22.81)
  IN4 w0.094: v2(170.55,20.05) 170.55,20.05 170.95,19.65 177.91,19.65 179.56,21.3 187.36,21.3 188.56,20.1 190.58,20.1 191.18,20.7 v2(191.18,20.71) 191.19,20.71 191.82,21.34 191.82,21.45 194.56,24.2 204.65,24.2 205.4,24.95 208.08,24.95 208.32,25.19 214.05,25.19 215.69,23.54 219.65,23.54 220.55,22.65 223.82,22.65 224.01,22.45 229.66,22.45 230.01,22.81 v2(230.56,22.81) 230.56,22.8 232.03,22.8 232.63,23.41 235.98,23.41 236.53,23.97 239.79,23.97 240.6,24.78 242,24.78 242.28,24.5 243.65,24.5 244.23,25.09 v2(244.82,25.09)
  BOTTOM w0.076: UH2.BD16 171.5,22.35 170.99,21.85 170.99,20.5 v2(170.55,20.05)
  BOTTOM w0.114: JNGFF1.19 190.81,21.08 v2(191.18,20.71) ; v2(244.82,25.09) 245.03,25.31 245.03,26.38 244.87,26.54 244.87,28.2 244.52,28.55 JLPDE1.6
LPC_LFRAME#: length 97.4
  TOP w0.114: v2(228.25,22.93) 228.25,22.16 228.98,21.43 228.98,20.6 228.98,20.09 230.68,18.39 230.92,18.39 231.54,17.77 231.54,17.29 231.85,16.98 UE1.58
  IN4 w0.094: v2(244.62,26.04) 244.23,26.04 243.65,25.46 243.36,25.46 243.35,25.45 238.04,25.45 237.82,25.67 237.07,25.67 235.3,23.89 231.91,23.89 231.33,23.31 229.84,23.31 229.46,22.93 v2(228.25,22.93) 224.21,22.93 224.01,23.12 220.74,23.12 219.85,24.02 215.89,24.02 214.25,25.66 208.12,25.66 207.88,25.42 205.2,25.42 204.45,24.67 194.37,24.67 191.35,21.65 191.35,21.54 v2(190.5,20.69) 189.41,21.77 179.2,21.77 177.55,20.13 v2(171.33,20.13)
  BOTTOM w0.076: v2(171.33,20.13) 171.16,20.3 171.16,21.64 UH2.BE16
  BOTTOM w0.114: JLPDE1.7 244.02,28.34 244.34,28.02 244.34,26.31 v2(244.62,26.04) ; v2(190.5,20.69) 190.31,20.88 JNGFF1.17
LX1_NVVDD: length 4.5
  BOTTOM w0.635: PC1626.2 167.77,57.95 167.75,57.97
  vias: v2(157.59,56) v2(158.95,56) v2(159.5,61.89) v2(160.26,61.94) v2(160.27,59.32) v2(161.02,61.92) v2(160.97,59.35) v2(161.76,61.94) v2(162.52,61.99) v2(163.28,61.97) v2(163.99,61.97) v2(164.16,56) v2(164.73,61.99) v2(165.44,61.97) v2(165.52,56) v2(165.95,59.05) v2(166.61,59.05) v4(159.1,60.4)
LX1_NVVDDS: length 10.4
  IN1 w0.635: 202.89,55.83 202.57,56.15 202.57,58.23 202.14,58.66 202.14,64.77 v2(201.3,65.61)
  vias: v2(189.6,64.86) v2(189.69,68.9) v2(189.69,68.21) v2(189.64,67.48) v2(189.69,66.79) v2(189.69,66.11) v2(189.72,65.47) v2(189.75,64.2) v2(190.23,64.86) v2(190.21,63.64) v2(190.33,64.23) v2(190.91,64.84) v2(190.84,63.59) v2(190.99,64.18) v2(191.48,63.54) v2(191.65,64.79) v2(191.67,64.13) v2(192.36,64.84) v2(192.36,64.13) v2(193.09,64.89) v2(193.05,64.13) v2(193.68,64.2) v2(193.91,64.91) v2(195.39,67.95) v2(195.39,65.61) v2(200.16,67.95) v2(200.16,65.61) v2(201.3,67.95) v2(203.49,55.34) v2(203.9,54.9) v4(190.75,69.22)
LX2_NVVDD: length 27.1
  IN3 w0.635: 148.49,49.76 150.15,48.1 168.82,48.1 172.98,52.26 172.98,52.42 172.96,52.44
  vias: v2(146.02,56.35) v2(146.24,51.62) v2(146.29,50.22) v2(147.61,56.38) v2(147.6,51.62) v2(148,50.22) v2(149.49,61.36) v2(149.49,60.75) v2(150.1,61.38) v2(150.12,60.75) v2(151.55,62.09) v2(152.18,62.09) v2(152.92,62.09) v2(153.65,62.12) v2(154.44,62.12) v2(155.08,62.12) v2(155.81,62.14) v2(156.6,62.14) v2(172.91,52.95) v2(173.36,53.38) v4(150.64,58.99)
LX_1VALWP:
  vias: v2(248.29,17.64) v2(248.29,17.01) v2(252.49,17.01) v2(252.99,17.39) v4(251.98,17.53)
LX_3V: length 9.1
  IN1 w0.635: v2(60.84,12.44) v2(60.84,13.2) 59.78,13.2 58.63,14.34 55.64,14.34 53.73,16.25
  vias: v2(53.4,17.49) v2(53.4,16.86) v4(65.43,13.79)
LX_5V: length 18
  IN4 w0.635: 51.83,25.36 51.83,30.22 50.05,31.99 45.35,31.99 44.71,31.36 v2(44.71,30.6) v2(43.95,30.6)
  BOTTOM w0.127: PL403.1 41.67,29.19 40.52,28.04 v3(40.52,26.91)
  vias: v2(45.6,30.98) v2(51.87,24.42) v2(52.28,23.99)
LX_+0.95VSP:
  vias: v2(66.05,68.95) v2(69.06,69.59) v2(69.06,68.93) v2(69.69,69.59) v2(69.69,68.93) v2(70.29,69.56) v2(70.29,68.93) v2(70.32,68.3) v2(70.93,69.03) v2(70.93,68.33) v2(71.42,68.67) v4(68.6,70.21)
LX_+1.0VSP: length 3
  TOP w0.254: PR802.1 224.67,43.7 224.27,44.11 224.27,45.02 224.19,45.1
  vias: v2(221.24,45.63) v2(221.21,45.05) v2(224.98,45.68) v2(224.98,45.05) v4(223.35,45.43)
LX_+1.8VSP: length 3.7
  TOP w0.508: v2(205.27,119.8) 205.6,119.47 205.6,117.52 PR1002.1
  vias: v2(205.04,120.36) v2(208.71,120.44) v2(208.67,119.83) v4(207.19,119.8)
LX_CHG: length 13
  IN1 w0.635: 28.39,32.76 28.39,32.44 26.35,30.39 v2(26.35,21.33) v2(26.35,20.64)
  vias: v2(24.85,23.92) v2(28.48,34.23) v2(28.48,33.59) v4(26.55,27.22)
LX_DDR: length 0.8
  BOTTOM w0.114: 105.79,7.17 v3(104.99,7.17)
M_CLK_DDR0: length 49.6
  IN4 w0.094: v2(107.06,67.08) 107.06,67 107.18,66.89 107.19,66.89 107.2,66.87 107.62,66.87 107.82,66.67 107.82,48.88 106.95,48.01 106.95,44.34 106.74,44.13 106.36,44.13 106.27,44.04 106.27,43.66 106.36,43.57 106.74,43.57 106.95,43.36 106.95,42.82 106.74,42.6 106.36,42.6 106.27,42.51 106.27,42.13 106.36,42.04 106.74,42.04 106.95,41.83 106.95,40.53 106.26,39.84 106.26,37.88 105.93,37.56 105.62,37.56 v2(105.48,37.41)
  BOTTOM w0.076: UH1.AG1 109.16,73.86 109.29,73.99 109.39,73.99 109.49,73.89 109.49,71.6 109.37,71.48
  BOTTOM w0.114: JDIMM1.137 104.65,40.03 104.69,40 104.69,37.88 105.04,37.53 105.36,37.53 v2(105.48,37.41) ; v2(107.06,67.08) 107.3,66.84 107.76,66.84 107.84,66.76 108.77,66.76 108.95,66.94 108.95,67.3 108.84,67.41 107.84,67.41 107.58,67.67 107.58,68.1 107.84,68.36 108.84,68.36 108.95,68.48 108.95,71.06 109.37,71.48
M_CLK_DDR1: length 52.1
  IN4 w0.094: v2(105.46,36.22) 105.46,36.07 105.24,35.86 104.99,35.86 104.66,36.19 104.66,40.04 105.57,40.96 105.57,48.34 106.56,49.34 106.56,66.52 106.31,66.77 106.31,69.94 105.72,70.53 105.72,73.14 105.85,73.27 106.16,73.27 106.29,73.14 106.29,70.8 106.56,70.53 106.92,70.53 v2(107.08,70.37)
  BOTTOM w0.076: v2(107.08,70.37) 106.93,70.53 106.72,70.53 106.49,70.75 106.49,72.07 106.19,72.36 106.19,73.96 106.38,74.14 106.5,74.14 106.65,74.29 UH1.AK2
  BOTTOM w0.114: JDIMM1.138 104.9,33.61 105,33.71 105,34.36 104.69,34.66 104.69,35.77 104.97,36.05 105.29,36.05 v2(105.46,36.22)
M_CLK_DDR2: length 65
  IN1 w0.076: 106.62,67.64 106.62,67.72 106.61,67.73 106.61,67.79 106.61,75.1 106.86,75.34 106.86,77.01 106.47,77.41 105.87,77.41 105.53,77.74 105.53,78.89 105.28,79.15 105.17,79.15 v2(104.99,79.33)
  IN1 w0.094: v2(105.57,25.1) 105.76,25.29 106.04,25.29 106.28,25.54 106.28,27.6 104.53,29.35 104.53,32.04 104.62,32.13 104.79,32.13 105.04,32.37 105.04,32.84 104.79,33.09 104.66,33.09 104.53,33.21 104.53,33.49 105.03,33.99 105.03,39.33 105.97,40.27 105.97,51.39 108.59,54.01 108.59,54.45 108.68,54.54 108.93,54.54 109.14,54.75 109.14,55.29 108.93,55.5 108.68,55.5 108.59,55.6 108.59,63.4 106.62,65.36 106.62,67.64
  BOTTOM w0.076: UH1.AM9 v2(104.99,79.33)
  BOTTOM w0.114: JDIMM2.137 104.66,27.31 104.77,27.2 104.77,26.91 104.48,26.62 104.48,25.88 105.11,25.25 105.43,25.25 v2(105.57,25.1)
M_CLK_DDR3: length 66.5
  IN1 w0.076: v2(105.89,77.97) 105.89,78.18 105.99,78.28 106.18,78.28 107.17,77.29 107.17,75.33 107.56,74.94 107.56,73.02 107.55,73.01 107.55,72.99
  IN1 w0.094: v2(105.69,22.71) 105.9,22.49 106.08,22.49 106.16,22.57 106.16,24.66 106.78,25.28 106.78,28.26 105.67,29.37 105.67,33.57 105.88,33.77 105.88,39.29 106.47,39.89 106.47,50.32 106.88,50.73 106.88,50.86 106.69,51.05 106.69,51.35 107.07,51.73 107.37,51.73 107.56,51.54 107.69,51.54 108.21,52.07 108.21,52.2 108.04,52.38 108.04,52.72 108.37,53.06 108.72,53.06 108.9,52.88 109.03,52.88 109.64,53.49 109.64,55.87 109.26,56.25 109.26,57.01 109.64,57.39 109.64,63.08 107.55,65.17 107.55,72.99
  BOTTOM w0.076: UH1.AM7 105.43,77.84 105.56,77.97 v2(105.89,77.97)
  BOTTOM w0.114: JDIMM2.138 104.91,20.89 104.97,20.95 104.96,20.95 104.96,22.29 105.23,22.56 105.54,22.56 v2(105.69,22.71)
M_CLK_DDR#0: length 49.6
  IN4 w0.094: v2(105.47,38.18) 105.47,37.94 105.62,37.79 105.88,37.79 106.05,37.97 106.05,39.92 106.75,40.61 106.75,41.75 106.66,41.84 106.28,41.84 106.07,42.05 106.07,42.59 106.28,42.81 106.66,42.81 106.75,42.9 106.75,43.27 106.66,43.37 106.28,43.37 106.07,43.58 106.07,44.12 106.28,44.33 106.66,44.33 106.75,44.43 106.75,48.09 107.62,48.96 107.62,66.59 107.54,66.67 107.29,66.67 v2(107.06,66.45)
  BOTTOM w0.076: 109.54,71.3 109.55,71.31 109.55,71.43 109.65,71.53 109.65,73.96 109.46,74.16 109.26,74.16 109.16,74.26 UH1.AG2
  BOTTOM w0.114: JDIMM1.139 105.15,40.12 104.94,39.9 104.94,37.98 105.14,37.78 105.26,37.78 105.47,37.99 v2(105.47,38.18) ; 109.54,71.3 109.2,70.96 109.2,68.37 108.94,68.12 107.94,68.12 107.83,68 107.83,67.77 107.94,67.66 108.94,67.66 109.2,67.4 109.2,66.84 108.87,66.51 107.74,66.51 107.65,66.6 107.21,66.6 v2(107.06,66.45)
