# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+3VALW_EC: length 142.8
  TOP w0.203: CE65.1 217.38,22.72 218.17,22.72 219.15,21.74 UE1.22 ; UE1.103 231.85,32.7 231.96,32.81 231.96,34.28 CE63.2 ; v2(221.5,28.13) 221.5,28.26 221.22,28.54 UE1.5 ; UE1.19 221.49,22.94 221.83,22.61 v2(221.83,22.24) ; UE1.43 225.85,17.06 225.9,17.11 225.9,17.12 v2(226.2,17.41) ; UE1.82 237.01,24.54 v2(237.17,24.7) ; v2(226.96,30.34) 227.05,30.44 UE1.115
  TOP w0.508: v2(217.95,22.2) 217.94,22.22 217.56,22.6 CE65.1 ; v2(231.2,33.62) 231.2,33.87 CE63.2 ; RE53.2 222.73,13.02 223.24,13.53 v2(223.24,13.91) ; v2(228.99,25.17) 228.99,26.01 230.49,27.51 v2(230.49,28.13) 229.36,29.26 228.04,29.26 v2(226.96,30.34)
  IN2 w0.508: v2(226.2,17.41) 226.27,17.41 227.95,19.1 227.95,20.17 228.99,21.21 v2(228.99,25.17)
  IN3 w0.508: v2(231.2,33.62) 231.18,33.65 229.25,33.65 228.89,33.29 228.89,32.5 226.96,30.57 v2(226.96,30.34) ; v2(228.99,25.17) 228.99,26.89 228.58,27.3 225.92,27.3 224.72,26.1 v2(224.72,25.17) 224.72,24.27 v2(224.65,24.2) 223.78,24.2 v2(221.83,22.24) 218,22.24 v2(217.95,22.2) 217.95,23.83 220.85,26.72 220.85,27.49 v2(221.5,28.13)
  IN4 w0.508: v2(250.05,30.47) 249.23,31.28 248.75,31.28 247.28,32.76 247.28,34.31 v2(245.26,36.32) 240.33,36.32 v2(237.7,33.7)
  BOTTOM w0.508: v2(224.65,24.2) 224.6,24.25 RE46.2 ; v2(226.2,17.41) 226.2,19.43 226.91,20.15 227.42,20.15 227.88,20.61 229.56,20.61 230.26,19.92 232.28,19.92 232.89,19.31 232.89,17.4 233.41,16.88 235.09,16.88 236.18,17.97 CE68.1 236.26,18.35 238.97,18.35 v2(239.4,18.79) 239.45,18.83 239.45,19.22 238.72,19.95 RE119.2 238.39,20.82 238.87,21.3 238.87,22.75 237.17,24.45 v2(237.17,24.7) 236.99,24.88 CE62.1 ; v2(250.05,30.47) 251.19,29.32 254.09,29.32 ; v2(221.83,22.24) 221.05,23.03 CE79.1 ; RE43.2 RE44.2 RE45.2 224.63,25.26 v2(224.72,25.17) ; RE13.1 230.49,28.65 v2(230.49,28.13) ; 254.09,29.32 254.01,29.4 RE63.1 RE65.1 RE64.1 ; 254.09,29.32 256.24,29.32 256.93,30.01 256.93,33.21 RE118.1 ; v2(228.99,25.17) 228.99,26.46 CE81.1 ; CE69.1 220.99,28.64 v2(221.5,28.13) ; v2(237.7,33.7) 237.42,33.98 v4(233.89,33.98) 233.59,34.28 231.86,34.28 v2(231.2,33.62) ; CE66.1 v2(226.96,30.34) 226.68,30.62 226.68,30.65 226.32,31 RE125.1 ; RE60.2 244.54,35.6 v2(245.26,36.32)
+3VALWP: length 22.6
  BOTTOM w0.254: PC401.1 PR401.1 57.16,18.23 PR410.1 57.62,18.53 60.08,18.53 63,15.61 75.12,15.61 76.03,14.7 76.03,14.54
  vias: v4(75.99,8.98)
+3VLP: length 208.2
  TOP w0.127: v2(140.94,21.55) 142.03,21.55 v4(142.39,21.91)
  IN2 w0.508: v2(152.3,15.61) 152.3,16.59 151.7,17.19 146.28,17.19 145.54,16.45 136.81,16.45 135.86,17.4 135.86,19.29 136.71,20.14 138.64,20.14 139.38,20.88 140.43,20.88 140.94,21.39 v2(140.94,21.55)
  IN3 w0.508: v2(140.94,21.55) 140.94,21.73 140.43,22.24 139.52,22.24 138.24,20.96 138.24,20.95 137.74,20.45 74.38,20.45 71.38,23.45 71.38,24.18 70.21,25.34 70.04,25.34 70,25.38 65.76,25.38 64.78,24.4 63.28,24.4 62.8,23.92 61.33,23.92 60.74,24.5 v2(59.57,24.5) ; v2(152.3,15.61) 152.47,15.43 158.43,15.43 160.94,12.93 169.23,12.93 171.21,10.95 173.45,10.95 175.35,9.06 178.76,9.06 184.59,14.89 195.65,14.89 197.88,17.12 210.03,17.12 211.63,15.52 215.22,15.52 215.84,16.14 218.04,16.14 219.83,17.94 224.25,17.94 225.16,18.84 225.16,20.58 v2(226.15,21.57)
  BOTTOM w0.508: v2(59.57,24.5) 57.93,22.86 57.93,21.58 57.43,21.07 PR400.1 ; RE20.2 225.18,25.85 225.77,25.26 225.77,21.96 v2(226.15,21.57)
+3VS: length 762.3
  TOP w0.254: v2(80.4,81.14) 79.92,80.66 79.92,75.2 80.45,74.67 82.18,74.67 84.77,72.08 84.77,65.83 75.22,56.28 66.35,56.28 62.29,52.21 v2(61.1,52.21)
  TOP w0.381: v2(173.56,31.61) 173.56,31.62 173.42,31.76 CH188.1 ; UV21.5 201.1,56.8 200.28,57.62 CV917.1 ; QH4.2 153.74,22.02 154.51,21.26 RH27.1 ; UH14.5 190.07,24.66 189.39,23.97 RH180.1 ; RH26.1 148.52,22.65 149.14,22.02 QH4.5
  TOP w0.406: UV22.5 v2(171.71,64.67)
  TOP w0.508: v2(215.57,18.02) 215.62,17.97 RE108.1 ; CA4.1 289.44,39.03 RA2.1 ; CA4.1 290.33,39.03 290.56,38.8 v2(290.87,38.8) ; CA4.1 290.2,38.6 289.76,38.15 UA1.1 ; RH26.1 148.52,24.32 149.48,25.28 151.77,25.28 152.68,24.37 v2(152.79,24.37) 153.1,24.37 153.35,24.63 RH15.1 RH14.1 ; v2(56.27,46.22) 56.28,46.22 55.39,47.11 v2(54.99,47.11) ; v2(213.47,62.51) 210.56,59.6 RZ109.1 208.05,59.6 RZ108.1 ; v2(61.1,52.21) 59.47,52.21 57.22,49.96 52.47,49.96 v2(51.32,48.81) ; v2(137.75,77.71) 137.93,77.89 139.69,77.89 141.03,79.24 144.04,79.24 145.36,77.92 146.23,77.92 147.27,76.88 v2(147.3,76.88) ; RE122.1 243.77,29.56 Q13.2 243.39,30.79 241.72,32.47 ; RE121.1 Q12.2 57.97,29.53 57.54,29.96 v2(56.98,29.96) ; v2(233.86,41.54) 233.37,42.03 233.37,42.6 232.04,43.93 230.92,43.93 PR811.2 ; v2(138.21,42.74) 137.03,42.74 136.68,43.08 CD16.1 CD17.1 134.91,42.78 v2(134.56,42.43) ; v2(138.11,33.25) 137.2,32.34 134.85,32.34 134.22,31.71 134.22,28.11 134.73,27.6 CD35.1 CD34.1 136.28,26.58 v2(136.84,26.03) ; RH27.1 154.51,20.83 v2(154.87,20.47) 154.87,19.24 157.38,16.73 ; RH180.1 188.94,24.23 v2(188.94,24.45) ; v2(200.02,56.96) 200.26,57.2 CV917.1 ; PR1624.2 v2(175.55,50.16) ; RH179.2 RH500.2 RH85.2 168.79,17.31 168.28,16.8 v2(168.28,16.71) ; v2(153.12,27.64) 153.44,27.64 RH159.1 RH494.1 RH129.2 RH86.1 153.51,30.6 v2(153.04,30.13) 152.82,30.36 RH80.2 152.82,32.1 152.58,32.34 152.58,33.26 152.24,33.59 v2(151.93,33.59) ; v2(177.8,24.87) 177.9,24.87 178.78,23.99 RH141.2 ; RE83.1 RE81.1 v2(52.08,32.55) ; RH87.2 RH111.2 179.03,23.99 RH141.2 ; RH119.1 v2(153.15,26.66) ; UZ23.5 67.25,27.36 69.86,29.97 69.86,32.01 v2(69.23,32.64) ; RH142.2 RH141.2 ; v2(176.08,61.05) 176.43,61.05 RH517.1
  TOP w1.016: 239,36.31 236.31,39 229.57,39 228.74,39.83 219.66,39.83 218.65,38.83
  IN1 w0.508: v2(143.2,101.02) 145.77,101.02 147.58,99.2 147.58,88.04 150.94,84.68 150.94,83.47 152.11,82.31 152.11,81.55 153.68,79.97 153.68,77.47 151.32,75.11 v2(151.32,74.92) ; v2(188.94,24.45) 184.62,24.45 183.74,25.33 180.77,25.33 180.03,24.59 178.08,24.59 v2(177.8,24.87) ; v2(207.02,50.16) 206.93,50.24 204.47,50.24 200.02,54.69 v2(200.02,56.96) ; v2(160.82,16.22) 161.54,15.5 v2(165.87,15.5) 166.08,15.5 167.29,16.71 v2(168.28,16.71) ; v2(96.2,6.77) 96.91,7.48 99.53,7.48 100.19,6.82 v2(102.58,6.82)
  IN2 w0.508: 214.02,29.28 214.87,28.43 214.87,20.41 215.57,19.71 v2(215.57,18.02) 217.26,18.02 217.83,18.6 219.61,18.6 219.96,18.24 222.76,18.24 224.27,16.74 227.64,16.74 229.4,18.51 v2(229.4,18.52)
  IN3 w0.254: v2(68.44,81.19) 68.44,81.17 68.89,80.71 79.97,80.71 v2(80.4,81.14)
  IN3 w0.508: v2(138.11,33.25) 137.36,32.5 116.67,32.5 114.31,30.14 v2(111.29,30.14) 110.83,30.14 110.12,30.85 108.73,30.85 106.94,32.64 v2(69.23,32.64) ; v2(206.34,46.2) 207.02,46.88 v2(207.02,50.16) 207.02,51.63 208.44,53.05 208.44,54.5 212.4,58.46 212.4,60.52 213.47,61.58 v2(213.47,62.51) ; v2(138.22,22.47) 138.22,22.67 136.84,24.06 v2(136.84,26.03) ; 68.51,32.43 68.08,31.99 66.43,31.99 65.03,30.6 57.62,30.6 v2(56.98,29.96) ; v2(233.86,41.54) 233.86,41.08 239.99,34.95 239.99,34.58 241.01,33.57 241.13,33.57 ; v2(188.94,24.45) 189.43,24.95 189.43,27.42 190.32,28.31 197.11,28.31 198.89,30.09 v2(198.89,30.6) ; v2(153.12,27.64) 153.12,26.69 v2(153.15,26.66) 152.79,26.3 v2(152.79,24.37) 152.79,22.55 v2(154.87,20.47) ; v2(171.71,64.67) 171.71,62.84 174.32,60.24 175.18,60.24 175.19,60.25 ; v2(176.08,61.05) 176.06,61.05 175.26,60.25 175.19,60.25 ; 175.19,60.25 175.19,59.36 176.54,58.02 177.02,58.02 178.36,56.68 178.36,49.86 177.85,49.35 176.35,49.35 v2(175.55,50.16) ; v2(173.56,31.61) 173.56,31.28 175.6,29.24 176.74,29.24 178.44,27.54 178.44,25.54 177.8,24.9 v2(177.8,24.87)
  IN3 w1.016: 46.03,48.81 42.81,45.58 39.1,45.58 37.45,43.93 34.58,43.93 34.07,43.43 34.07,42.46 32.27,40.66 17.93,40.66
  IN4 w0.508: v2(238.72,30.5) 238.72,30.58 240.47,32.34 240.47,32.45 241.01,32.45 ; v2(187.31,17.16) 187.31,17.01 186.8,16.5 184.01,16.5 179.27,11.76 171.11,11.76 167.96,14.91 167.96,16.39 v2(168.28,16.71) ; v2(56.98,29.96) 54.67,29.96 v2(52.08,32.55) ; v2(273.44,42.54) 272.93,42.03 272.93,39.92 274.18,38.67 280.3,38.67 281.44,39.82 288.63,39.82 289.34,39.11 289.65,39.11 289.95,38.8 v2(290.87,38.8) ; 139.53,35.65 139.53,37.4 137.68,39.26 137.68,42.2 v2(138.21,42.74) 138.82,43.35 138.82,66.31 133.88,71.25 133.88,75.03 136.56,77.71 v2(137.75,77.71) ; v2(151.47,15.66) 152.03,16.22 v2(157.76,16.22) ; v2(54.99,47.11) 53.02,47.11 v2(51.32,48.81) ; v2(151.32,74.92) 151.09,74.69 149.11,74.69 147.3,76.5 v2(147.3,76.88)
  BOTTOM w0.152: v2(173.56,31.61) 173.56,31.62 173.55,31.64 173.51,31.64 UH2.AD13
  BOTTOM w0.203: 169.28,16.77 169.41,16.64 170.2,16.64 171.46,17.9 RH90.2
  BOTTOM w0.254: UT1.1 61,49.76 60.68,50.08 CT81.1 60.68,51.79 v2(61.1,52.21) ; v2(165.87,15.5) 165.87,15.45 166.49,14.83 UH7.5 ; v2(68.44,81.19) 68.31,81.32 68.31,82.51 68.21,82.62 PR1112.1
  BOTTOM w0.305: v2(134.56,42.43) 135.85,42.43 136.15,42.13 JDIMM1.255 ; JDIMM2.255 136.16,27.05 136.84,26.37 v2(136.84,26.03) ; RT4.1 55.18,48 QT2.5 QT2.2 ; UE6.5 236.55,27.31 CE85.1
  BOTTOM w0.406: v2(151.47,15.66) 151.47,16.53 151,17 QE19.5 150.04,17 149.88,17.15 149.31,17.15 149.16,17 QE19.2
  BOTTOM w0.508: v2(96.2,6.77) 96,6.98 PR500.2 PR501.2 ; v2(54.99,47.11) 55.38,47.5 RT4.1 ; v2(143.2,101.02) 144.06,101.87 144.06,106.77 143.67,107.15 143.67,108.12 PR913.1 144.18,108.63 PR900.1 ; RH79.2 153.48,37.2 151.65,37.2 150.89,36.44 150.89,34.64 v2(151.93,33.59) ; RH160.1 153.72,27.04 v2(153.12,27.64) ; v2(187.31,17.16) 187.31,22.49 188.94,24.12 v2(188.94,24.45) ; RT5.1 v2(51.32,48.81) ; RV613.2 229.41,19.63 229.41,18.53 v2(229.4,18.52) 229.4,18.15 228.81,17.55 QV93.1 ; v2(238.72,30.5) 238.72,29.15 238.01,28.44 236.99,28.44 236.31,27.75 CE85.1 ; RH120.1 153.65,26.15 v2(153.15,26.66) ; RL33.1 289.32,37.81 290.31,38.8 v2(290.87,38.8) ; v2(102.58,6.82) 102.58,6.78 102.79,6.57 155.97,6.57 160.65,11.25 160.65,15.12 160.18,15.59 v2(160.18,16.22) ; v2(56.27,46.22) 56.83,46.22 RT3.1 ; v2(80.4,81.14) 80.49,81.23 RH93.1 ; RH69.2 v2(153.04,30.13) ; RZ38.2 208.34,48.2 QZ9.3 208.9,50.23 CZ43.1 207.58,50.71 v2(207.02,50.16) ; PR110.1 v2(213.47,62.51)
  vias: v2(9,40.17) v2(9.66,40.17) v2(10.3,40.25) v2(68.72,33.8) v2(69.35,33.29) v2(158.39,16.22) v2(189.81,40.43) v2(190.27,40.83) v2(204.11,31.16) v2(204.58,30.8) v2(204.59,30.09) v2(205.07,30.43) v2(205.06,29.75) v2(206.14,30.24) v2(206.44,29.73) v2(206.82,30.24) v2(207.17,29.73) v2(207.48,30.24) v2(213.6,30.27) v2(213.62,29.67) v2(218.3,37.84) v2(218.73,37.25) v2(218.96,37.84) v2(219.44,37.23) v2(219.57,37.84) v2(241.26,33.57) v2(241.36,32.96) v2(241.92,33.57) v2(242,32.91) v2(246.14,22.16) v2(246.09,21.45) v2(246.64,21.83) v2(246.82,30.62) v2(246.77,22.42) v2(247.25,22.04) v2(247.43,30.62) v2(273.44,18.3) v2(273.44,17.67) v2(273.82,42.03) v4(12.04,38.1)
+3VS_CAM: length 0.9
  TOP w0.127: v2(231.05,48.61) v4(231.05,47.68)
+3VS_TP: length 140.2
  TOP w0.508: v2(142.02,17.96) 142.02,17.86 143.1,16.78 v4(143.35,16.78) 145.59,16.78 146.71,15.66 v2(146.71,13.76) ; QE13.2 133.06,14.61 v2(133.15,14.61) 133.45,14.91 RE87.1 CE2.1 134.13,16.11 133.58,16.67 RE93.2
  IN2 w0.508: v2(151.79,19.47) 150.86,18.54 146.59,18.54 145.11,17.06 142.53,17.06 142.02,17.57 v2(142.02,17.96)
  IN3 w0.381: v2(151.79,19.47) 152.87,18.39 155.36,18.39 156.04,17.71 158.04,17.71 159.06,16.68 159.06,15.57 161.09,13.55 169.38,13.55 171.43,11.5 179.3,11.5 183.62,15.81 195.32,15.81 197.43,17.92 210.17,17.92 211.76,16.33 214.08,16.33 215.14,17.39 216.06,17.39 217.97,19.3 220.53,19.3 220.96,19.74 222.91,19.74 223.29,20.12 223.29,21.17 224.34,22.23 231.66,22.23 233.73,24.3 v2(234.48,24.3)
  IN3 w0.508: v2(149.81,13.41) 149.12,14.1 147.05,14.1 v2(146.71,13.76)
  BOTTOM w0.254: RE55.1 RE24.1 234.88,23.1 234.43,23.56 234.43,24.25 v2(234.48,24.3)
  BOTTOM w0.508: v2(151.79,19.47) 151.57,19.69 RE9.2 ; RE7.2 v2(149.81,13.41) ; v2(142.02,17.96) 142.02,17.45 RE123.1 141.59,17.02 133.37,17.02 132.76,16.41 JTP.8 132.76,14.94 133.09,14.61 v2(133.15,14.61) ; DE4.5 146.28,13.33 v2(146.71,13.76)
+3VS_WLAN: length 5.1
  BOTTOM w0.305: v2(185.13,28.26) 185.06,28.33 JNGFF1.4 ; v2(201.89,28.13) 201.89,28.5 202.06,28.67 JNGFF1.64 ; v2(202.47,28.13) 202.56,28.22 JNGFF1.66 ; JNGFF1.2 184.56,28.3 v2(184.52,28.26)
  vias: v2(185.73,28.26) v2(194.43,33.16) v2(195.03,33.16) v4(198.27,29.61) v4(198.35,32.69) v4(199.69,27.5)
+5V_AVDD:
  vias: v4(287.64,17.63)
+5V_CHGUSB_1:
  vias: v2(292.24,30.22) v2(292.24,29.58) v2(292.26,30.85) v2(292.9,30.8) v2(292.87,30.22) v2(292.87,29.58) v2(294.57,44.49) v2(294.6,43.91) v2(294.62,43.32) v2(295.16,44.52) v2(295.23,43.91) v2(295.26,43.3) v4(292.97,34.31)
+5V_CHGUSB_2:
  vias: v2(283.25,34.13) v2(283.27,33.54) v2(283.88,34.13) v2(283.85,33.49) v2(284.52,34.15) v2(284.52,33.49) v2(294.52,46.65) v2(294.52,46.04) v2(294.52,45.43) v2(295.13,46.8) v2(295.11,46.19) v2(295.13,45.56) v4(293.44,47.17)
+5V_PVDD: length 6.9
  TOP w0.203: HDA1.41 281.91,29.33 281.98,29.39 281.98,30.34 281.57,30.75 CA14.1 ; CA12.1 279.41,30.72 279,30.32 279,29.17 279.91,28.26 HDA1.46
  vias: v2(277.35,30.01) v2(277.96,29.99) v2(278.55,30.11) v2(282.33,30.7) v2(293.02,24.4) v2(293.63,24.63) v2(293.63,23.99) v4(277.59,31)
+5VALW: length 313.9
  TOP w0.203: UZ1.4 216.21,12.94 v2(216.24,12.92)
  TOP w0.254: UZ16.4 74.21,48.91
  TOP w0.381: RV534.1 151.43,77.22 v2(151.71,77.5)
  TOP w0.508: 74.21,48.91 74.21,49.94 73.47,50.69 v4(72.04,50.69) v2(68.03,50.69) ; JPW.1 201.09,34.4 200.67,33.98 v2(199.7,33.98) ; v2(144.55,29.26) 145.66,28.15 145.66,26.04 143.48,23.86 143.48,20.32 142.34,19.18 139.01,19.18 138.01,18.18 v2(138.01,18.01) ; RW4.2 v2(204.94,33.34) ; v2(136.98,114.61) 136.43,114.06 v4(136.43,113.41) 136.43,109.08 136.05,108.7 136.05,107.99 130.72,102.66 v2(130.72,100.98) ; v2(251.55,28.21) 251.55,27.98 250.74,27.17 RH504.1 RH505.1 249.56,26.4 248.49,25.33 JLED.4 ; 10.93,20.69 14.61,20.69 15.25,21.33 15.25,25.14 14.31,26.08 PR104.2
  IN2 w0.508: v2(204.94,33.34) 203.29,31.69 203.29,30.65 200.19,27.55 200.19,26.57 199.3,25.68 199.3,21.16 ; v2(151.71,77.5) 147.69,81.52 147.69,82.82 147.18,83.33 v2(144.59,83.33) ; 244.89,16.86 244.89,19.47 245.59,20.17 247.69,20.17 249.18,21.67 249.18,25.1 249.93,25.85 249.93,26.6 v2(251.55,28.21)
  IN3 w0.508: v2(199.7,33.98) 199.81,34.08 204.47,34.08 204.94,33.61 v2(204.94,33.34) ; v2(146.64,111.06) 145.89,110.31 143.56,110.31 142.63,111.24 139.46,111.24 138.16,112.54 138.16,112.64 138.11,112.69 138.11,114.75 v2(137.42,115.43) ; v2(226.37,51.15) 226.58,50.94 227.7,50.94 230.67,47.97 231.07,47.97 233.26,45.79 236.81,45.79 237.67,44.94 v2(237.67,44.66) ; 215.87,11.57 215.87,12.55 v2(216.24,12.92)
  IN4 w0.508: v2(237.67,44.66) 237.67,42.75 239.79,40.63 244.1,40.63 248.22,36.52 250.76,36.52 254.72,32.55 254.72,28.72 253.5,27.5 252.23,27.5 251.8,27.93 251.8,27.96 v2(251.55,28.21) ; v2(130.72,100.98) 130.72,96.22 143.61,83.33 v2(144.59,83.33) ; v2(68.03,50.69) 69.03,49.69 69.03,46.43 66.56,43.96 66.56,29.43 64.98,27.85 64.04,27.85 63.33,27.14 63.33,24.55 61.07,22.29 58.99,22.29 v2(58.73,22.55) ; v2(226.37,51.15) 225.18,49.95 221.78,49.95 219.14,52.59 219.14,57.9 v2(215.2,61.84)
  BOTTOM w0.508: JUART.1 215.14,61.9 v2(215.2,61.84) ; v2(144.55,29.26) 143.2,29.26 142.17,30.29 142.17,33.1 143.6,34.52 143.6,42.1 140.47,45.23 140.47,51.53 139.38,52.62 139.38,63.49 134.83,68.04 134.83,72.96 137.58,75.71 138.15,75.71 139.2,76.77 139.2,77.41 142.2,80.41 142.2,80.94 v2(144.59,83.33) ; RW3.2 v2(285.12,60.06) 284.74,60.06 284.11,59.43 RH506.1
  vias: v2(8.35,21.14) v2(8.38,20.46) v2(9.07,21.15) v2(9.08,20.46) v2(9.78,21.15) v2(9.78,20.46) v2(37.35,31.36) v2(37.35,30.72) v2(37.35,30.09) v2(37.35,29.45) v2(37.35,28.82) v2(37.86,31.04) v2(37.86,30.41) v2(37.86,29.77) v2(37.86,29.14) v2(38.36,31.36) v2(38.36,30.72) v2(38.36,30.09) v2(38.36,29.45) v2(38.36,28.82) v2(38.87,31.04) v2(38.87,30.41) v2(38.87,29.77) v2(137.39,17.99) v2(144.09,17.74) v2(144.68,17.74) v2(157.03,12.66) v2(157.46,13.1) v2(157.9,13.55) v2(157.87,12.64) v2(158.2,12.06) v2(158.4,12.97) v2(158.51,13.55) v2(158.71,12.46) v2(159.01,13.1) v2(159.19,12.06) v2(159.47,12.61) v2(159.88,12.03) v2(215.83,10.33) v2(215.86,10.91) v2(216.47,10.91) v2(216.44,10.33) v2(217.03,10.33) v2(217.05,10.91) v2(217.64,10.91) v2(217.61,10.33) v2(218.22,10.89) v2(218.2,10.3) v2(218.81,10.86) v2(218.78,10.28) v2(244.71,10.66) v2(245.32,10.68) v2(245.98,10.66) v2(246.57,11.27) v2(246.57,10.68) v2(247.2,11.29) v2(247.2,10.66) v2(283.19,37.35) v2(283.5,37.91) v2(283.83,38.45) v2(283.78,37.33) v2(284.16,37.89) v2(284.36,37.33) v2(291.04,41.19) v2(291.09,40.58) v2(291.58,40.17) v2(291.65,40.76) v2(292.24,40.81) v2(292.24,40.17) v4(36.42,29.15)
+5VALWP: length 69.9
  IN1 w0.254: v2(35.7,33.39) 35.7,28.36 40.01,24.04 40.01,18.79 40.78,18.02 42.43,18.02 43.75,19.34 46.67,19.34 49.28,21.95 v2(49.41,21.95) ; v2(35.06,33.39) 35.21,33.24 35.21,28.21 39.63,23.79 39.63,18.53 40.52,17.64 42.68,17.64 43.98,18.94 46.9,18.94 49.34,21.38 50.61,21.38 53.86,24.63 53.86,25.11 54.8,26.05 55.59,26.05 57.01,24.63 v2(57.24,24.63)
  BOTTOM w0.203: PU400.14 v2(49.41,21.95)
  BOTTOM w0.254: v2(57.24,24.63) 57.24,24.73 56.83,25.14 PR402.2 PC402.2
  vias: v2(35.06,34.03) v2(35.7,34.03) v2(36.33,34.03) v2(36.33,33.39) v2(36.97,34.03) v2(36.97,33.39) v2(37.6,34.03) v2(37.6,33.39) v2(38.24,35.3) v2(38.24,34.66) v2(38.24,34.03) v2(38.24,33.39) v2(38.87,35.3) v2(38.87,34.66) v2(38.87,34.03) v2(38.87,33.39) v4(36.78,35.28)
+5VS: length 578.2
  TOP w0.508: v2(171.33,55.87) 171.59,55.62 172.37,55.62 172.81,55.18 173.67,55.18 176.41,57.93 176.41,58.26 177.47,59.31 179.42,59.31 179.89,58.84 180.15,58.84 181.07,57.93 186.92,57.93 187.22,57.62 v2(187.22,57.29) ; v2(238.84,38.35) 237.19,40.01 230.12,40.01 229.27,40.86 218.26,40.86 v2(213.74,36.34) ; PR1531.1 132.34,130.17 131.48,131.03 ; RZ26.1 64.53,33.01 v2(64.78,32.76) ; v2(92.72,132.71) 92.72,132.45 90.69,130.42 v2(90.69,130.29) PR1500.1 90.83,129.47 91.13,129.47 92.11,128.49 92.11,126.76 88.86,123.51 83.07,123.51 82.12,124.45 63.92,124.45 62.87,123.4 62.87,114.04 v2(66.56,110.35) v4(67.84,109.07) v2(70.62,106.29) ; v2(103.13,132.58) 103.08,132.58 100.85,130.34 v2(100.85,130.29) 100.85,129.73 PR1428.1 ; PR1713.2 206.56,57.41 207.01,57.41 207.38,57.04 v2(207.38,56.68) ; v2(242.83,36.95) RE84.1 243.57,36.66 243.07,36.17 RE105.1 243.07,34.9 RE101.1 ; v2(80.43,79.49) 80.43,79.06 83.96,75.53 83.96,74.76 85.28,73.43 85.28,65.41 75.66,55.79 67.4,55.79 67.17,55.57 67.16,55.57 64.3,52.7 v2(64.3,52.44) ; v2(213.74,36.34) 212.74,36.34 211.93,35.53 211.93,33.53 211.8,33.39 QE4.3 ; v2(213.74,36.34) 214.13,35.94 RE1.2 ; v2(127.64,15.59) 127.38,15.84 CE5.1 126.32,15.33 125.96,14.98 F1.2 ; v2(123.71,132.71) 123.71,130.05 123.11,129.45 PR1400.1 122.08,129.45 v2(121.8,129.73) ; v2(111.58,129.47) 111.31,129.73 PR1414.1 110.88,130.8 v2(112.79,132.71) ; 131.48,131.03 131.48,128.67 130.82,128.01 PR1533.1 ; 131.48,131.03 v2(131.48,131.21)
  IN1 w0.508: 261.76,17.95 261.55,17.74 258.46,17.74 258.1,18.1 258.1,18.86 257.67,19.29 257.67,20.23 257.26,20.64 v2(257.24,20.64) ; v2(67.19,97.15) 67.32,97.15 67.68,96.79 67.68,94.76 69.73,92.7 73.8,92.7 79.38,87.11 82.31,87.11 82.81,86.6 82.81,81.4 80.91,79.49 v2(80.43,79.49) ; v2(112.79,132.71) 112.79,132.32 113.55,131.56 122.97,131.56 123.71,132.3 v2(123.71,132.71)
  IN3 w0.508: v2(112.79,132.71) 112.74,132.76 112.74,133.09 112.35,133.47 103.13,133.47 ; v2(187.22,57.29) 187.22,56.86 189.71,54.37 193.02,54.37 200.44,46.95 200.44,45 201.86,43.58 201.86,43.4 203.57,41.7 204.78,41.7 209,37.48 209,36.57 209.36,36.21 211.82,36.21 212.08,36.46 213.61,36.46 v2(213.74,36.34) ; v2(92.72,132.71) 92.72,132.96 93.23,133.47 103.13,133.47 ; 103.13,133.47 v2(103.13,132.58) ; v2(56.37,29.1) 56.37,31.38 57.11,32.12 63.64,32.12 64.27,32.76 v2(64.78,32.76) ; v2(72.78,80) 79.92,80 v2(80.43,79.49) ; v2(260.64,23.82) 260.49,23.66 258.05,23.66 257.34,24.37 253.98,24.37 252.99,25.36 v2(252.99,26.05) ; v2(70.62,106.29) 67.95,103.62 67.95,97.91 v2(67.19,97.15)
  IN3 w1.016: v2(56.37,29.1) 55.97,28.69 55.97,23.82 57.62,22.16 57.62,17.81 59.69,15.74 62.09,15.74 63.59,17.24 92.16,17.24 94.42,14.98 111.08,14.98 112.35,13.71 124.98,13.71 126.63,15.36
  IN4 w0.508: v2(131.48,131.21) 130.03,132.65 130.01,132.65 129.22,133.44 124.22,133.44 123.71,132.93 v2(123.71,132.71) ; v2(252.99,26.05) 252.16,26.89 251.97,26.89 250.73,28.13 250.73,30.65 249.46,31.92 248.98,31.92 247.91,32.98 247.91,34.67 245.64,36.95 v2(242.83,36.95) 240.25,36.95 v2(238.84,38.35) ; v2(64.3,52.44) 64.35,52.39 64.35,46.45 62.77,44.87 62.77,34.51 64.53,32.76 v2(64.78,32.76)
  IN4 w1.016: 195.69,10.87 195.46,10.64 185.21,10.64 181.9,7.33 171.72,7.33 165.74,13.31 161.27,13.31 159.28,15.31 153.35,15.31 152.74,14.7 147.2,14.7 145.63,16.27 129.83,16.27 129.17,15.61
  BOTTOM w0.305: v2(257.24,20.64) 257.24,20.67 257.46,20.89 RA74.1
  BOTTOM w0.381: v2(123.71,132.71) 123.66,132.65 123.65,132.65 123.49,132.49 123.49,132.11 PR1402.1
  BOTTOM w0.508: PR1101.1 v2(72.78,80) ; PR1403.1 v2(121.8,129.73) ; PR1418.1 111.31,129.73 v2(111.58,129.47) ; v2(90.69,130.29) 90.69,129.67 PR1504.1 ; PR1430.1 v2(103.13,132.58) ; v2(70.62,106.29) PR1516.1 PR1512.1 ; PR1502.1 92.72,132.02 v2(92.72,132.71) ; PR1613.2 v2(171.33,55.87) ; PR1432.1 100.91,130.23 v2(100.85,130.29) ; v2(207.38,56.68) 207.38,52.67 206.16,51.45 202.8,51.45 199.78,54.47 189.71,54.47 187.22,56.96 v2(187.22,57.29) ; PR1514.1 v2(66.56,110.35) ; PR1416.1 v2(112.79,132.71)
  vias: v2(128.28,15.61) v2(196.59,10.76) v2(197.2,10.77) v2(197.48,11.31) v2(208.04,11.5) v2(208.01,10.89) v2(208,10.26) v2(208.05,13.17) v2(208.53,11.83) v2(208.53,11.17) v2(208.53,10.57) v2(208.63,13.17) v2(209.15,12.86) v2(209.15,12.26) v2(209.8,12.83) v2(209.8,12.25) v2(270.14,21.22) v2(270.52,21.76) v2(270.8,21.2) v2(271.1,21.76) v2(276.18,32.04) v2(276.29,32.63) v2(276.77,32.04) v2(276.87,32.81) v2(277.38,32.3) v2(293,62.09) v2(293.63,62.09)
+5VS_HDD: length 7.1
  TOP w0.127: v2(195.42,13.86) 196.71,15.14 v4(197.05,15.14) ; v2(195.42,13.86) 195.22,14.06 195.22,15.98 v4(195.78,16.54) ; v2(195.42,13.86) 196.05,13.24 v4(197.15,13.24)
+5VS_KBL: length 6.1
  TOP w0.102: v4(121.53,13.93) 121.92,14.32 v2(121.92,14.82)
  TOP w0.508: F1.1 122.96,15.63 CE6.1 122.26,15.97 122.06,15.76 CE4.1 121.67,15.08 v2(121.92,14.82)
  BOTTOM w0.508: JBL1.1 121.59,15.16 v2(121.92,14.82)
+5VS_TS: length 3.6
  TOP w0.127: v4(60.67,33.06) 61,32.73 v2(61.53,32.73)
  TOP w0.508: v2(61.53,32.73) 61.81,33.01 RZ26.2
  BOTTOM w0.254: v2(61.53,32.73) 61.86,32.73 62.14,33.01 JEDP1.19
+19VB_1VALWP:
  vias: v2(253.02,18.99) v2(253.65,18.96) v2(254.24,18.99) v2(254.85,19.01) v4(255.66,19.47)
+19VB_+0.95VSP:
  vias: v4(68.51,72.9)
+19VB_+1.0VSP:
  vias: v2(223.24,48.91) v2(223.27,48.3) v2(223.3,47.72) v4(223.56,49.39)
+19VB_+1.8VSP:
  vias: v2(209.56,122.06) v2(210.17,122.67) v2(210.19,122.06) v2(210.86,122.06) v4(210.14,123.32)
+VCC_CORE: length 23.7
  BOTTOM w0.102: 121.98,82.62 UH1.L14 ; UH1.L14 122.21,81.96 UH1.K14 122.92,82.01 ; UH1.L14 121.55,81.91 ; 122.69,81.32 UH1.K13 122.72,81.85 ; 121.51,81.31 121.66,81.31 UH1.L13 122.33,81.55 v2(122.44,81.66)
  BOTTOM w0.152: 116.09,81.89 UH1.V14 ; UH1.V14 UH1.V13 116.19,81.55 116.08,81.66 ; UH1.V14 116.72,82.51 ; UH1.V14 116.09,82.51 ; UH1.P13 119.06,81.46 118.32,81.46 UH1.R13 118.56,81.87 v2(118.69,81.87) 118.82,81.87 ; UH1.P13 118.82,81.87 ; UH1.P13 119.47,81.55 ; 119.46,82.51 UH1.P14 ; UH1.P14 119.46,81.89 ; UH1.P14 118.82,81.87 ; 111.52,81.89 UH1.AD14 ; UH1.AD14 111.52,82.51 ; UH1.AD14 111.93,82.2 v2(112.25,81.87) ; 111.23,82.51 UH1.AE14 ; UH1.AE14 UH1.AE13 111.19,81.55 111.24,81.6 ; UH1.AE14 111.23,81.89 ; v2(112.25,81.87) 112.58,82.2 UH1.AC14 ; v2(112.25,81.87) 112.29,81.87 112.61,81.55 UH1.AC13 UH1.AC14 ; v2(112.25,81.87) 111.93,81.55 UH1.AD13 111.58,81.55 111.51,81.62 ; UH1.W14 115.8,81.89 ; UH1.W14 115.8,82.51 ; UH1.W14 115.18,82.51 ; UH1.W14 UH1.W13 115.7,81.55 115.83,81.67 ; UH1.AC14 112.88,82.2 v2(113.21,81.87) 113.53,81.55 UH1.AA13 113.82,81.55 114.04,81.76 ; UH1.AC14 112.75,82.71
  BOTTOM w0.254: RH197.1 108.12,106.3 109.28,105.15 v2(109.28,104.46)
  vias: v2(103.77,113.27) v2(103.77,112.64) v2(103.77,112) v2(103.77,111.37) v2(104.4,113.27) v2(104.4,112.64) v2(104.4,112) v2(104.4,111.37) v2(105.04,113.27) v2(105.04,112.64) v2(105.04,112) v2(105.04,111.37) v2(105.67,113.27) v2(105.67,112.64) v2(105.67,112) v2(105.67,111.37) v2(106.31,113.27) v2(106.31,112.64) v2(106.31,112) v2(106.31,111.37) v2(106.94,113.27) v2(106.94,112.64) v2(106.94,112) v2(106.94,111.37) v2(107.58,112) v2(107.58,111.37) v2(108.21,112) v2(108.21,111.37) v2(108.98,112) v2(108.98,111.37) v2(109.48,90.8) v2(109.48,90.16) v2(109.48,89.53) v2(109.48,88.76) v2(109.61,112) v2(109.61,111.37) v2(109.64,92.09) v2(109.66,91.43) v2(110.11,101.83) v2(110.27,100.75) v2(110.25,100.03) v2(110.25,99.38) v2(110.25,98.73) v2(110.25,98.14) v2(110.25,96.13) v2(110.42,101.34) v2(110.74,101.83) v2(110.85,92.51) v2(111.04,100.68) v2(111.03,100.04) v2(111.04,99.38) v2(111.03,98.77) v2(111.04,98.08) v2(111.01,96.15) v2(111.06,101.29) v2(111.38,101.83) v2(111.4,81.86) v2(111.52,111.62) v2(111.49,111.01) v2(111.69,101.34) v2(111.77,100.75) v2(111.83,100.03) v2(111.8,99.38) v2(111.83,98.73) v2(111.82,98.11) v2(111.82,96.81) v2(111.83,96.13) v2(111.9,110.23) v2(111.9,109.46) v2(111.9,108.83) v2(112.01,101.83) v2(112.13,111.01) v2(112.15,111.62) v2(112.53,110.23) v2(112.53,109.46) v2(112.53,108.83) v2(112.63,98.75) v2(112.61,98.08) v2(112.61,96.78) v2(112.61,96.15) v2(112.61,95.49) v2(112.76,111.01) v2(112.75,92.51) v2(112.91,111.62) v2(112.86,91.91) v2(112.94,91.3) v2(112.91,85.59) v2(112.96,112.31) v2(112.94,90.72) v2(112.94,90.08) v2(112.94,89.45) v2(112.94,88.81) v2(113.17,110.23) v2(113.17,109.46) v2(113.17,108.83) v2(113.32,101.95) v2(113.4,111.01) v2(113.34,101.34) v2(113.4,100.73) v2(113.4,100.03) v2(113.4,99.38) v2(113.4,98.73) v2(113.4,98.14) v2(113.4,96.76) v2(113.4,96.13) v2(113.55,85.59) v2(113.67,113.53) v2(113.67,112.89) v2(113.67,112.26) v2(113.67,111.62) v2(113.8,110.23) v2(113.8,109.46) v2(113.8,108.83) v2(113.92,101.83) v2(114.06,111.01) v2(114.18,101.29) v2(114.19,100.68) v2(114.18,100.07) v2(114.19,99.38) v2(114.18,98.75) v2(114.19,98.08) v2(114.18,97.45) v2(114.19,96.78) v2(114.21,96.15) v2(114.31,113.53) v2(114.31,112.89) v2(114.31,112.26) v2(114.31,111.62) v2(114.55,101.83) v2(114.59,92.51) v2(114.59,91.84) v2(114.56,91.15) v2(114.69,111.01) v2(114.94,113.53) v2(114.94,112.89) v2(114.94,112.26) v2(114.94,111.62) v2(114.97,99.38) v2(115,98.75) v2(114.94,98.11) v2(114.99,97.42) v2(114.97,96.79) v2(114.98,96.13) v2(114.96,95.49) v2(115.05,82.53) v2(115.33,111.01) v2(115.58,113.53) v2(115.58,112.89) v2(115.58,112.26) v2(115.58,111.62) v2(115.82,101.83) v2(115.76,100.68) v2(115.76,100.04) v2(115.76,99.38) v2(115.76,98.75) v2(115.76,98.08) v2(115.96,111.01) v2(116.06,101.26) v2(116.21,113.53) v2(116.21,112.89) v2(116.21,112.26) v2(116.21,111.62) v2(116.46,101.83) v2(116.47,93.11) v2(116.5,92.43) v2(116.6,111.01) v2(116.55,100.68) v2(116.55,100.03) v2(116.55,99.38) v2(116.55,98.73) v2(116.55,98.11) v2(116.55,97.43) v2(116.6,96.79) v2(116.55,96.13) v2(116.72,101.26) v2(116.85,112) v2(116.89,82.53) v2(117.03,87.9) v2(117.23,111.5) v2(117.23,110.86) v2(117.23,110.23) v2(117.23,109.59) v2(117.23,108.96) v2(117.34,99.38) v2(117.33,98.72) v2(117.34,98.08) v2(117.33,97.42) v2(117.34,96.78) v2(117.31,96.13) v2(117.34,95.49) v2(117.31,85.99) v2(117.73,101.83) v2(117.8,111.18) v2(117.8,110.42) v2(117.8,109.78) v2(117.89,109.11) v2(118.09,101.31) v2(118.13,100.68) v2(118.13,100.03) v2(118.12,99.38) v2(118.13,98.73) v2(118.15,98.11) v2(118.3,93.03) v2(118.28,92.43) v2(118.4,101.82) v2(118.73,101.34) v2(118.69,85.81) v2(118.88,100.73) v2(118.88,100.04) v2(118.91,99.38) v2(118.89,98.75) v2(118.91,98.08) v2(118.88,97.43) v2(118.91,96.78) v2(118.91,96.15) v2(119.49,87.9) v2(119.62,81.85) v2(119.65,100.7) v2(119.68,99.37) v2(119.67,98.74) v2(119.69,96.81) v2(121.29,112) v2(121.29,111.37) v2(121.44,82.6) v2(121.93,112) v2(121.93,111.37) v2(122.03,110.61) v2(122.03,109.97) v2(122.07,109.39) v2(122.34,108.87) v2(122.56,113.4) v2(122.56,112.77) v2(122.56,112.13) v2(122.56,111.5) v2(122.56,110.86) v2(122.56,110.23) v2(122.64,109.59) v2(122.93,108.93) v2(123.2,113.4) v2(123.2,112.77) v2(123.2,112.13) v2(123.2,111.5) v2(123.2,110.86) v2(123.2,110.23) v2(123.24,109.6) v2(123.56,108.93) v2(123.83,113.4) v2(123.83,112.77) v2(123.83,112.13) v2(123.83,111.5) v2(123.83,110.86) v2(123.83,110.23) v2(123.83,109.59) v2(124.14,109.05) v2(124.47,113.4) v2(124.47,112.77) v2(124.47,112.13) v2(124.47,111.5) v2(124.47,110.86) v2(124.47,110.23) v2(124.47,109.59) v2(125.1,113.4) v2(125.1,112.77) v2(125.1,112.13) v2(125.1,111.5) v2(125.1,110.86) v2(125.1,110.23) v2(125.74,113.41) v2(125.71,112.69) v2(125.74,112) v2(125.74,111.37) v2(126.37,112) v2(126.37,111.37) v4(105.8,114.23) v4(105.88,101.91) v4(125.26,114.24)
+VCCGT: length 24.6
  TOP w0.508: PC1354.1 103.2,90.26
  BOTTOM w0.152: 103.29,82.51 UH1.AP14 ; UH1.AP14 UH1.AP13 103.79,81.55 103.9,81.66 ; UH1.AP14 103.92,82.51 ; UH1.AP14 103.92,81.89 ; UH1.BD14 95.51,82.2 v2(95.83,81.87) 95.51,81.55 UH1.BD13 95.16,81.55 95.02,81.69 ; UH1.BD14 95.06,81.89 ; UH1.BD14 95.06,82.51 ; UH1.BA14 UH1.BA13 98.02,81.55 v2(97.65,81.91) ; UH1.BA14 97.93,82.2 v2(97.65,81.91) ; UH1.BA14 98.12,82.63 98.12,82.64 ; 94.15,81.86 UH1.BF13 94.77,81.86 ; 101.46,81.89 UH1.AT14 ; UH1.AT14 102.09,82.51 ; UH1.AT14 101.46,82.51 ; 96.89,82.51 UH1.BB14 ; UH1.BB14 96.89,81.89 ; UH1.BB14 97.37,82.2 v2(97.65,81.91) ; 94.77,82.51 UH1.BF14 ; UH1.BF14 94.15,82.51 ; UH1.BF14 94.77,81.89 ; UH1.BF14 94.15,81.89 ; v2(104.98,81.87) 105.3,81.55 UH1.AM13 ; v2(104.98,81.87) 104.65,82.2 UH1.AN14 ; v2(104.98,81.87) 105.3,82.2 UH1.AM14 ; v2(104.98,81.87) 104.65,81.55 UH1.AN13 104.35,81.55 104.22,81.67 ; UH1.AL13 106.43,81.55 106.7,81.81 ; UH1.AL13 UH1.AM13 ; UH1.AL13 105.88,82.02 105.61,82.02 UH1.AM14 ; UH1.AM14 105.43,82.64 105.43,82.65 ; UH1.AM14 UH1.AM13 ; v2(97.65,81.91) 97.28,81.55 UH1.BB13 96.93,81.55 96.85,81.62 ; UH1.AU14 100.55,82.51 ; UH1.AU14 101.17,82.51 ; UH1.AU14 101.17,81.89 ; 100.26,82.51 UH1.AW14 ; UH1.AW14 99.63,82.51 ; UH1.AW14 99.63,81.89 ; 104.21,81.89 UH1.AN14 ; UH1.AN14 104.21,82.51
  BOTTOM w0.254: RH203.1 107.62,101.65
  vias: v2(84.36,110.73) v2(84.46,114.54) v2(84.46,113.91) v2(84.46,113.27) v2(84.46,112.64) v2(84.52,112) v2(84.49,111.32) v2(84.95,110.73) v2(85.1,114.54) v2(85.1,113.91) v2(85.1,113.27) v2(85.1,112.64) v2(85.15,112) v2(85.23,111.32) v2(85.56,110.68) v2(85.73,114.54) v2(85.73,113.91) v2(85.73,113.27) v2(85.73,112.64) v2(85.81,112.03) v2(85.84,111.34) v2(86.22,110.73) v2(86.37,114.54) v2(86.37,113.91) v2(86.37,113.27) v2(86.37,112.64) v2(86.5,111.98) v2(86.52,111.32) v2(87,114.54) v2(87,113.91) v2(87,113.27) v2(87,112.64) v2(87.18,111.98) v2(87.64,114.54) v2(87.64,113.91) v2(87.64,113.27) v2(87.67,112.64) v2(87.82,111.95) v2(88.27,114.54) v2(88.27,113.91) v2(88.3,113.27) v2(88.35,112.64) v2(88.43,111.98) v2(89.05,98.89) v2(89.93,112.77) v2(89.93,112.13) v2(89.93,111.5) v2(89.93,110.86) v2(90,101.46) v2(90.21,113.4) v2(90.54,101.78) v2(90.56,112.77) v2(90.56,112.13) v2(90.56,111.5) v2(90.56,110.86) v2(90.84,113.4) v2(91.2,112.77) v2(91.2,112.13) v2(91.2,111.5) v2(91.2,110.86) v2(91.17,101.78) v2(91.48,113.4) v2(91.83,112.77) v2(91.83,112.13) v2(91.83,111.5) v2(91.83,110.86) v2(91.81,101.78) v2(92.11,113.4) v2(92.14,100.71) v2(92.47,112.77) v2(92.47,112.13) v2(92.47,111.5) v2(92.47,110.86) v2(92.44,101.78) v2(92.75,113.4) v2(92.93,100.03) v2(92.93,98.73) v2(92.93,98.08) v2(92.93,96.13) v2(93.1,112.77) v2(93.1,112.13) v2(93.1,111.5) v2(93.13,110.89) v2(93.08,101.78) v2(93.38,113.4) v2(93.74,112.77) v2(93.74,112.13) v2(93.74,111.5) v2(93.71,101.78) v2(93.72,98.08) v2(93.72,96.78) v2(93.72,95.49) v2(93.72,94.07) v2(94.02,113.4) v2(94.35,101.78) v2(94.5,100.03) v2(94.5,98.73) v2(94.5,96.13) v2(94.92,82.52) v2(94.98,101.78) v2(95.29,100.68) v2(95.29,99.38) v2(95.29,98.08) v2(95.29,96.78) v2(95.27,84.16) v2(95.36,91.4) v2(95.51,88.12) v2(95.45,85.74) v2(95.62,101.78) v2(95.58,89.8) v2(96.08,98.73) v2(96.08,97.43) v2(96.08,96.13) v2(96.08,95.49) v2(96.25,101.76) v2(96.5,113.35) v2(96.53,112.77) v2(96.53,112.13) v2(96.53,111.5) v2(96.5,110.86) v2(96.75,82.51) v2(96.91,101.75) v2(96.87,100.68) v2(96.87,99.38) v2(97.16,112.77) v2(97.16,112.13) v2(97.16,111.5) v2(97.16,110.86) v2(97.37,113.4) v2(97.56,101.75) v2(97.57,100.75) v2(97.65,100.03) v2(97.65,98.73) v2(97.65,97.43) v2(97.65,96.13) v2(97.69,84.16) v2(97.8,112.77) v2(97.8,112.13) v2(97.8,111.55) v2(97.88,110.94) v2(98.2,101.75) v2(98.43,112.77) v2(98.43,112.13) v2(98.43,111.55) v2(98.46,110.94) v2(98.44,98.08) v2(98.44,96.78) v2(98.44,95.49) v2(99.07,112.77) v2(99.07,112.13) v2(99.07,111.52) v2(99.1,110.94) v2(99.2,100.78) v2(99.23,100.03) v2(99.23,98.73) v2(99.23,96.13) v2(99.7,112.77) v2(99.7,112.13) v2(99.7,111.52) v2(99.73,110.94) v2(100.02,100.68) v2(100.02,99.38) v2(100.02,98.08) v2(100.02,96.78) v2(100.1,84.16) v2(100.34,112.77) v2(100.34,112.13) v2(100.34,111.5) v2(100.29,91.25) v2(100.37,110.91) v2(100.4,82.52) v2(100.8,98.73) v2(100.8,97.43) v2(100.8,96.13) v2(100.81,95.5) v2(100.97,112.77) v2(100.97,112.13) v2(100.97,111.5) v2(100.97,110.89) v2(101.32,89.97) v2(101.29,88) v2(101.34,88.6) v2(101.48,85.74) v2(101.59,100.68) v2(101.59,99.38) v2(102.38,100.03) v2(102.38,98.73) v2(102.38,97.43) v2(102.38,96.13) v2(102.51,84.16) v2(103.17,98.08) v2(103.17,96.78) v2(103.17,95.49) v2(103.95,100.03) v2(103.95,98.73) v2(103.95,96.13) v2(104.06,81.87) v2(104.72,96.15) v2(104.74,100.68) v2(104.74,99.38) v2(104.74,98.08) v2(104.74,96.78) v2(104.93,84.1) v2(105.38,91.24) v2(105.52,100.69) v2(105.53,98.73) v2(105.53,96.13) v2(106.32,100.03) v2(106.32,99.38) v2(106.32,98.08) v2(106.32,96.78) v2(106.44,89.52) v2(106.48,86.87) v2(107.1,98.73) v2(107.1,97.43) v2(107.1,96.13) v2(107.89,98.08) v2(107.89,96.78) v2(107.89,95.49) v4(90.81,116.27)
+VCCIO: length 38.7
  TOP w0.381: v2(127.14,101.72) RH30.2
  IN3 w0.381: 121.85,93.87 120.73,95 120.73,100.98 121.11,101.36 121.85,101.36 123.05,102.56 126.29,102.56 v2(127.14,101.72)
  BOTTOM w0.254: 121.9,83.4 120.74,83.4 120.18,82.84 119.72,82.84 119.47,83.1 119.47,83.2 119.11,83.56 110.35,83.56 109.56,82.77 109.56,81.37 UH1.AG12
  BOTTOM w0.305: v2(119.75,67.1) 120.13,67.48 125.69,67.48 126.68,68.47 RH24.1
  vias: v2(68.38,59.58) v2(68.42,58.9) v2(68.42,58.27) v2(68.89,59.86) v2(68.89,59.27) v2(68.93,58.61) v2(68.93,57.98) v2(69.43,60.16) v2(69.43,59.58) v2(69.43,58.92) v2(69.49,58.34) v2(122.39,91.96) v2(122.44,85.31) v2(122.47,92.6) v2(122.49,89.63) v2(122.54,87.09) v2(122.51,83.94) v2(124.01,87.87) v2(124,87.12) v2(124.01,86.3) v2(124.02,84.72) v2(124.62,84.75) v2(124.65,87.87) v2(129.37,82.79) v2(129.96,82.79) v2(130.59,82.79) v2(131.23,82.79) v2(131.45,78.37) v2(132.05,78.37) v4(74.43,57.46)
+VCCIO_PG: length 2
  TOP w0.102: RH103.1 192.08,23.52 192.08,23.51
  TOP w0.127: v3(192.08,21.76) PR712.2 192.08,23.51
+VCCSA:
  vias: v2(120.95,93.83) v2(120.95,92.56) v2(121,90.87) v2(121.17,101.97) v2(121.17,89.43) v2(121.17,88.1) v2(121.29,100.68) v2(121.29,100.04) v2(121.29,99.41) v2(121.29,98.75) v2(121.3,98.08) v2(121.29,97.42) v2(121.29,96.79) v2(121.28,96.13) v2(121.98,100.75) v2(122.03,100.04) v2(122.06,99.38) v2(122.08,98.75) v2(122.09,98.09) v2(122.06,96.78) v2(122.06,96.18) v2(122.84,98.75) v2(122.85,96.78) v2(131.45,111.12) v2(131.45,110.48) v2(131.45,109.85) v2(131.45,109.21) v2(132.09,111.12) v2(132.09,110.48) v2(132.09,109.85) v2(132.09,109.21) v2(132.72,111.12) v2(132.72,110.48) v2(132.72,109.85) v2(132.72,109.21) v2(133.36,111.12) v2(133.36,110.48) v2(133.36,109.85) v2(133.36,109.21) v2(133.36,108.58) v2(133.99,111.12) v2(133.99,110.48) v2(133.99,109.85) v2(133.99,109.21) v2(133.99,108.58) v4(134.71,111.47)
+VCCST: length 196.3
  TOP w0.254: RH164.1 132.06,77.71 133.7,77.71 v2(134.02,77.4)
  TOP w0.508: RH98.1 183.68,31.59 183.68,34.23 ; v2(81.19,93.11) 83.07,94.99 RH144.1 ; 183.68,34.23 183.96,34.51 183.96,36.49 184.57,37.1 187.7,37.1 v2(187.97,37.37) ; 183.68,34.23 RH97.1 RH100.1 ; v2(86.19,89.35) 85.91,89.63 RH151.1 85.84,90.21 RH152.1
  IN2 w0.762: 177.15,20.69 178.52,20.69 179.28,21.45 181.24,21.45 184.87,25.09 185.18,25.09 187.98,27.89 187.98,36.65 ; 130.57,87.49 129.93,86.86 128.41,86.86 128.03,86.48 128.03,82.51 128.58,81.96 129.47,81.96 130.44,80.99 130.44,78.27 130.82,77.89 130.82,77 129.93,76.11 129.93,68.44 134.63,63.74 134.63,49.14 137.12,46.65 137.12,40.69 136.79,40.36 136.79,36.13 137.37,35.55 138.45,35.55 140.78,33.23 141.4,33.23 142.58,32.04 142.58,30.15 144.31,28.43 145.07,28.43 147.94,25.56 153.24,25.56
  IN3 w0.508: v2(81.19,93.11) 81.19,91.25 81.77,90.67 85.4,90.67 86.19,89.88 v2(86.19,89.35) 85.56,88.71 85.56,86.83 81.39,82.67 77.35,82.67 76.08,81.4 75.57,81.4 v2(75.45,81.27)
  IN4 w0.762: 121.78,87.06 121.76,87.04 116.32,87.04 116.04,86.76 113.14,86.76 112.16,87.74 105.49,87.74 105.01,87.26 88.86,87.26 86.78,89.35 v2(86.19,89.35)
  BOTTOM w0.203: UH1.H28 UH1.J28 122.89,93.8 v2(122.51,93.42) ; v2(124.01,94.98) 124.01,94.99 124.01,94.99 UH1.H30
  BOTTOM w0.508: RH156.1 81.75,93.11 v2(81.19,93.11) ; PR1103.1 PR1104.1 PC1101.1 71.76,79.46 72.28,78.95 73.26,78.95 75.45,81.13 v2(75.45,81.27)
  vias: v2(130.59,92.9) v2(130.54,88.51) v2(131.11,92.62) v2(131.2,88.53) v2(131.63,92.89) v4(125.91,95.28)
+VCCSTG: length 104.8
  TOP w0.254: v2(82.36,91.48) 82.36,92.95 83.25,93.84 84.19,93.84 84.82,93.21 RH497.1
  TOP w0.508: v2(136.75,107.91) 136.75,107.69 135.9,106.84 135.9,102.99 138.06,100.83 138.69,100.83 139.2,100.32 139.2,99.01 138.3,98.11 135.34,98.11 134.1,96.87 ; RH56.1 82.69,95.88 81.67,94.86 v2(81.29,94.86) 81.06,94.86 80.74,95.18 79.95,95.18 79.89,95.24 ; v2(77.61,99.71) 79.89,97.42 79.89,95.24 ; 79.89,95.24 79.89,92.66 81.07,91.48 v2(82.36,91.48) ; v2(124.36,96) 124.81,96.44 CH106.1
  IN3 w0.508: v2(136.75,107.91) 136.53,107.7 133.3,107.7 132.83,108.17 89.11,108.17 80.65,99.71 v2(77.61,99.71)
  BOTTOM w0.203: UH1.G30 124.31,95.94 v2(124.36,96)
  BOTTOM w0.254: v2(124.02,94.2) 124.01,94.2 123.66,94.55 UH1.H29
  BOTTOM w0.508: v2(81.29,94.86) 81.32,94.83 81.87,94.83 RH165.1 ; RH496.1 v2(82.36,91.48)
  vias: v2(132.7,96.65) v2(133.28,96.65) v4(132.05,96.8)
GND: length 3838.1
  TOP w0.203: UE1.84 234.73,25.34 234.66,25.26 v2(234.65,25.26) ; v2(284.36,35.17) US1.14 ; UE1.17 221.65,23.74 v2(221.84,23.55) ; v2(234.3,17.64) 234.3,17.47 234.25,17.42 UE1.64 ; PC1000.2 211.03,117.41 v2(211.59,117.57) ; v2(229,14.87) 229,16.06 UE1.51 ; UE1.100 233.05,32.68 232.7,33.04 v2(232.47,33.04) ; v2(212.65,12.9) 212.7,12.94 UZ1.11 ; v2(223.91,30.47) 223.76,30.47 223.45,30.78 UE1.124
  TOP w0.254: v2(117.61,113.91) 118.06,113.91 PC1201.2 117.93,114.54 v2(117.61,114.54) ; UZ16.5 71.18,48.78 70.58,49.38 CZ57.2 ; v2(123.88,75.35) 124.58,76.05 CH128.2 ; v2(119.57,34.25) 118.34,33.02 CD71.2 ; v2(175.89,60.02) 175.56,60.35 175.56,61.8 RV582.2 ; RH516.2 124.39,82.92 v2(124.62,83.15) ; CD85.2 96.75,26.85 v2(96.09,26.2) ; v2(121.04,112.64) 120.6,112.64 PC1274.2 120.72,113.27 v2(121.04,113.27) ; v2(220.03,36.31) 220.13,36.41 220.13,38.12 220.3,38.29 v2(222.16,38.29) 224.06,38.29 224.39,37.96 224.39,37 v2(224.36,37) ; CD26.2 105.74,26.72 105.48,26.47 v2(105.37,26.47) ; v2(112.28,113.02) 111.83,113.02 PC1265.2 111.96,113.66 v2(112.28,113.66) ; v2(121.04,113.91) 120.6,113.91 PC1200.2 120.72,114.54 v2(121.04,114.54) ; v2(108.59,114.42) 108.91,114.42 PC1263.2 109.04,115.05 v2(108.59,115.05) ; v2(117.61,113.27) 117.93,113.27 PC1202.2 118.06,112.64 v2(117.61,112.64) ; JKB1.1 v2(196.13,56.91) ; CD72.2 100.34,34.16 99.68,34.82 99.68,35.14 99.43,35.4 v2(99.12,35.4) ; v2(120.33,26.48) 120.3,26.48 119.99,26.8 CD23.2 ; CD78.2 106.34,34.38 105.79,34.93 105.51,34.93 v2(105.47,34.89) ; v2(108.59,113.78) 109.04,113.78 PC1264.2 108.91,113.15 v2(108.59,113.15) ; v2(112.28,114.93) 111.96,114.93 PC1205.2 111.83,114.29 v2(112.28,114.29) ; JPW.4 v2(204.09,33.35)
  TOP w0.305: UZ15.5 130.15,95.81 v2(130.34,95.61) ; v2(172.55,72.79) 171.66,72.79 171.36,72.48 171.36,71.47 RV209.2 ; v2(271.21,23.03) 270.74,22.56 CA34.1 ; JAPS.10 v2(177.68,10.73) ; v2(186.6,126.09) 186.46,125.95 CV869.2 ; 135.93,29.4 135.39,28.87 CD35.2 ; 135.93,29.4 135.95,29.4 136.28,29.07 CD34.2 ; 135.93,29.4 v2(135.93,29.42) ; JAPS.8 176.68,11.18 177.07,10.79 v2(177.07,10.73) ; v2(179.28,10.73) 179.37,10.73 179.68,11.04 JAPS.14 ; JIO1.10 v2(9.03,27.25) ; JAPS.12 v2(178.68,10.73) ; v2(155.1,118.29) v2(155.1,118.89) v2(155.7,118.89) v2(155.7,118.29) v2(155.1,118.29)
  TOP w0.33: v2(177.61,82.31) 177.08,81.78 176.49,81.78 176.11,81.4 CV843.2
  TOP w0.356: v2(186.09,23.38) 186.52,23.81 UZ21.3 ; QZ12.4 152.51,77.97 152.58,77.9 v2(152.58,77.49) ; v2(211.06,88.68) v2(211.06,88.08) v2(210.26,88.08) ; v2(295.54,76.57) DV4.3 v2(295.54,78.98)
  TOP w0.381: CH135.2 119.77,97.52 v2(119.68,97.43) ; CH191.2 157.92,29.15 v2(158.23,29.45) ; v2(246.26,26.17) 246.79,26.17 247.14,26.52 247.14,27.05 QE23.1 ; PC1379.2 95.05,92.04 v2(95.34,92.04) 95.34,92.59 PC1335.2 ; v2(165.27,35.51) 165.26,35.51 165.26,35.54 165.07,35.73 CH183.2 ; CH114.2 120.39,86.52 v2(121.09,85.82) 120.48,85.21 120.37,85.21 CH112.2 ; PC1377.2 100.67,91.92 v2(100.29,91.92) 100.29,92.14 99.75,92.68 PC1322.2 ; PC1223.2 117.59,84.29 PC1243.2 ; PC1233.2 118.71,84.6 v2(118.71,85.19) 118.32,85.19 PC1220.2 ; UZ23.3 65.4,29.18 65.01,28.79 v2(64.93,28.79) ; v2(175,118.29) 175,117.75 CV379.2 ; v2(100.89,21.99) 101.04,21.99 101.51,21.53 101.51,20.54 101.33,20.36 CD83.2 ; PC1329.2 104.01,93.7 v2(104.52,93.19) 104.01,92.68 PC1331.2 ; v2(121.29,95.49) 122.14,94.65 CH204.2 ; UV21.3 198.41,55.27 v2(198.38,55.25) ; UC16.3 136.19,76.97 136.53,76.63 v2(136.53,75.83) ; v2(114.04,82.78) 114.55,83.29 PC1248.2 ; v2(105.37,91.86) 105.55,91.86 105.6,91.81 105.62,91.81 105.89,91.54 PC1375.2 106.07,92.65 PC1330.2 ; CH188.2 174.34,31.61 174.36,31.59 v2(174.41,31.59) ; v2(211.06,108.46) v2(211.06,109.06) ; PC1374.2 97.95,84.8 v2(97.67,84.8) ; CV112.2 177.96,92.57 178.73,92.57 v2(179.29,93.13) ; v2(100.09,84.8) 100.37,84.8 PC1373.2 ; v2(164.4,25.09) 164.42,25.11 164.55,25.11 164.92,25.48 164.92,25.49 165.03,25.59 CH176.2 ; v2(120.47,102.01) 120.2,101.74 CH134.2 ; PC1390.2 120.43,87.85 PC1385.2 120.75,88.81 v2(121.18,88.81) ; v2(119.67,100.03) 120.13,100.03 CH115.2 ; CE78.1 228.1,13.53 229,14.43 v2(229,14.87) ; v2(251.83,25.81) 251.82,25.82 QE20.4 ; UH14.3 v2(188.77,26.32) ; v2(177.57,76.51) 177.14,76.51 176.72,76.93 RV51.2 ; v2(104.94,84.72) 105.27,84.72 PC1363.2 ; UZ21.3 186.52,24.73 RH94.2 ; v2(293.32,68.28) DV5.3 ; PC1269.2 115.9,85.35 PC1222.2 115.88,85.69 v2(116.21,86.02) ; PC1378.2 95.54,84.8 v2(95.26,84.8) ; v2(102.5,84.8) 102.78,84.8 PC1372.2 ; v2(169.25,28.02) 169.25,28.03 168.6,27.38 CH80.2 CH173.2 ; CD80.2 v2(99.3,18.71) ; v2(196.86,76.48) v2(196.86,75.88) v2(197.46,75.88) v2(197.46,76.48) v2(196.86,76.48)
  TOP w0.4: v2(174.4,131.69) v2(175,131.69) v2(175,132.49) ; RV79.1 180.89,96.6 v2(180.89,95.63) ; v2(167.9,128.49) v2(167.3,128.49) ; v2(155.1,128.49) v2(155.7,128.49) ; v2(211.06,96.26) v2(211.06,96.86) ; v2(207.06,96.26) v2(207.06,96.86) ; v2(210.26,76.48) v2(211.06,76.48) ; v2(155.1,131.69) v2(155.7,131.69) v2(155.7,132.49) v2(155.1,132.49) ; v2(175,118.89) v2(175,118.29) ; v2(187.2,128.49) v2(186.6,128.49) ; v2(175,126.19) v2(174.4,126.19) ; v2(155.1,120.49) v2(155.7,120.49) ; v2(205.46,109.06) v2(204.66,109.06) ; v2(207.06,109.06) v2(207.06,108.46) ; v2(187.2,132.49) v2(186.6,132.49) v2(186.6,131.69) v2(187.2,131.69) ; v2(176.8,122.49) v2(176.8,121.69) ; v2(207.06,88.68) v2(207.06,88.08) ; v2(174.4,128.49) v2(175,128.49)
  TOP w0.406: v2(257.18,28.18) 257.18,27.55 256.8,27.17 QE21.1 ; QZ6.1 204.35,70.86 204.86,71.36 v2(205.11,71.36) ; UV22.3 174.37,66.73 v2(174.25,66.84) ; QE21.4 255.38,28.47 v2(255.53,28.31) ; v2(193.79,31.49) 193.79,32.08 JKB1.32
  TOP w0.457: v2(174.4,118.29) v2(174.4,118.89) 173.8,118.89 CV160.2 ; v2(211.06,96.26) 211.3,96.02 CV187.2 ; QZ10.4 157.09,82.17 157.96,82.17 157.99,82.2 CV910.2 ; CV169.2 168.29,132.49 v2(167.9,132.49) v2(167.3,132.49) ; v2(211.06,88.68) 211.06,89.08 CV182.2 ; 158.28,96.89 158.28,96.56 159.14,95.7 v2(159.19,95.7) ; v2(149.39,107.17) 149.95,107.17 QZ8.1 ; CV85.2 181.3,104.4 v2(181.32,104.38) ; QZ12.1 154.44,80.06 154.99,80.61 v2(154.99,80.7) ; QV92.1 207.09,60.1 v2(206.35,60.84) 205.79,61.4 QV92.4 ; v2(174.25,66.84) 173.84,66.84 173.38,67.3 QV89.3 ; v2(211.06,76.48) v2(211.06,75.88) 211.06,75.48 CV179.2 210.26,75.28 v2(210.26,75.88) v2(210.26,76.48) ; CV922.2 157.86,80.98 v2(158.37,81.5) ; UV18.3 154.4,72.47 v2(154.44,72.51) ; CV171.2 155,118.19 v2(155.1,118.29) ; QZ8.4 151.99,105.68 151.31,105 v2(151.31,104.96) ; v2(211.06,109.06) 211.06,109.46 CV397.2 ; CV54.2 148.43,82.22 v2(148.65,82.44) ; CV180.2 197.46,75.28 v2(197.46,75.88)
  TOP w0.508: PC1634.2 166.76,80.33 v2(166.86,80.43) ; v2(196.07,30.58) RN4.2 ; PC1637.2 152.36,74.62 v2(152.16,74.42) ; CZ102.2 151.46,17 v2(151.46,17.87) ; PR1621.2 176.57,50.15 v2(176.55,50.14) ; v2(124.66,92.61) 123.26,92.61 CH110.2 ; v2(13.9,23.76) 13.88,23.76 13.54,24.11 PQ101.3 ; PC1514.2 v2(66.71,114.8) ; UA1.2 288.81,36.82 289.17,36.46 290.12,36.46 290.61,36.95 v2(290.61,37.89) ; RM517.2 v2(262.65,42.79) ; v2(122.41,85.89) 122.93,86.41 CH102.2 ; CM842.2 263.92,28.57 v2(263.66,28.31) ; v2(248.89,30.59) 248.45,30.15 QE23.4 ; v2(70.49,64.89) PC710.2 ; RV161.1 188.73,75.43 188.99,75.17 v2(188.99,75.05) ; v2(161.81,84.99) 161.85,84.95 CV913.2 ; v2(142.54,24.68) 142.01,24.68 CD27.2 ; CH185.2 CH184.2 167.35,38.04 167.93,38.62 v2(167.93,39.33) ; v2(271.21,23.03) 271.22,23.04 DA1.1 ; v2(141.61,64.81) 141.92,64.51 CV912.2 ; CC298.2 130.74,75.1 131.51,74.34 v2(132.93,74.34) ; v2(98.44,86.37) 98.84,86.37 PC1303.2 PC1300.2 ; v2(179.19,104.71) 179.19,105.12 178.88,105.43 CV834.2 ; v2(13.27,32.4) 13.27,32.67 PD100.2 ; v2(177.25,56.91) 177.63,57.29 PC1625.2 ; CV190.2 196.92,95.81 196.86,95.88 v2(196.86,96.26) ; v2(140.19,29.78) 140.01,29.96 CD15.2 ; v2(125.18,42.56) 125.07,42.56 124.56,43.07 CD70.2 125.16,43.88 v2(125.21,43.88) ; CM841.2 CM840.2 273.47,40.53 v2(273.69,40.76) ; CH125.2 111.46,80.61 v2(112.29,80.61) ; RV160.1 RV155.1 186.69,77.11 v2(186.44,77.36) ; v2(199.68,53.37) RV607.2 CV918.2 ; RV136.2 202.78,75.25 202.96,75.43 v2(202.96,75.89) ; RH13.1 178.65,26.03 v2(179.31,26.03) ; CV876.2 182.34,131.35 v2(182.4,131.29) ; CD8.2 88.37,44.07 89.79,45.5 v2(90.13,45.5) ; CV167.2 187.79,121.71 187.41,122.09 v2(187.2,122.09) ; RV536.2 v2(64.4,29.96) ; v2(142.05,65.32) 142.07,65.34 143.11,65.34 CV911.2 ; v2(205.86,104.26) 205.83,104.23 205.83,104.17 205.8,104.15 CV399.2 ; CV51.2 164.63,77.32 PC1657.2 166.66,77.32 PC1635.2 166.72,77.41 v2(166.72,78.08) ; v2(282.08,39.11) 282.15,39.18 CI23.2 ; PC1369.2 PC1367.2 99.68,115.81 v2(99.96,116.09) ; v2(196.86,88.68) 196.43,88.25 CV186.2 ; RH109.2 179.74,30.11 v2(179.74,30.52) ; QZ7.4 154.96,78.85 v2(154.93,78.81) ; CV920.2 153.01,105.77 152.03,105.77 QZ8.4 ; PR709.2 v2(65.47,64.89) ; v2(31.63,35.42) 32.14,35.93 PC318.1 ; CH70.2 165.4,21.8 v2(165.4,21.22) ; v2(155.1,124.55) 154.74,124.91 RV121.2 ; v2(156.07,73.29) 156.44,73.66 RV573.2 ; CD84.2 114.53,29.82 v2(113.6,30.75) ; CD22.2 v2(108.55,18.68) 108.59,18.64 108.59,18.53 109.1,18.02 RH212.2 ; v2(65.83,40.38) 66.56,39.65 UZ8.2 ; PR207.2 v2(47.97,44.01) ; CL44.2 v2(283.35,49.52) ; v2(103.91,90.59) 104.29,90.59 PC1354.2 104.67,90.21 PC1349.2 ; v2(170.44,54.98) 170.8,54.63 PC1644.2 ; CV573.2 147.61,107.94 146.46,107.94 v2(146.31,107.79) ; PC1359.2 100.21,88.94 PC1310.2 ; v2(204.66,109.06) 204.66,109.52 204.99,109.85 CV884.2 ; v2(168.74,16.11) 168.74,16.11 169.11,16.47 CC4.1 ; CT80.2 HT1.2 v2(109.31,86.48) ; v2(95.45,86.37) 95.06,86.37 PC1304.2 ; v2(131.1,43.05) 130.5,43.65 CD7.2 ; PC1382.2 120.6,90.23 v2(121,90.23) ; CD89.2 139.48,20.04 v2(140.24,20.04) ; v2(128.86,18.69) 128.86,18.92 CD81.2 ; CD87.2 71.96,19.08 v2(71.53,18.66) ; CN7.2 v2(201.43,30.57) ; CV899.2 209.92,83.82 v2(209.86,83.88) ; JFAN1.4 52.76,33.12 v2(52.97,32.91) CE99.2 ; v2(245.37,38.32) 245.51,38.18 JFAN2.4 ; v2(240.04,26.96) 240.04,28.01 239.61,28.44 RE114.1 ; v2(240.78,18.79) 240.48,18.79 CE89.2 ; RM587.1 v2(270.01,42.79) ; v2(192.21,33.16) 193.14,32.23 JKB1.32 ; v2(242.22,23.38) 242.22,22.54 JLED.5 ; CV374.2 187.84,126.09 v2(187.2,126.09) ; v2(197.06,105.86) 196.42,105.86 CV404.2 ; CD13.2 135.38,30.14 v2(135.89,30.14) ; PR301.2 22.16,32.63 v2(22.65,33.12) ; v2(93.74,34) 93.79,33.95 CD75.2 ; CZ12.2 220.02,14.84 219.62,15.24 v2(219.62,15.61) ; CE102.2 224.04,35.42 224.29,35.68 v2(224.29,36.31) ; RI51.1 277.35,36.69 v2(277.28,36.77) ; v2(292.86,22.95) 293.08,22.74 RA13.2 ; v2(154.99,80.7) 155.49,80.2 QZ10.1 ; CE101.2 219.94,35.42 219.39,35.97 v2(219.39,36.19) ; v2(135.96,14.66) 135.73,14.89 CE2.2 ; v2(158.15,31.71) 158.15,31.73 158.08,31.8 CH190.2 ; PC1342.2 99.35,82.26 CH124.2 99.74,81.87 v2(100.4,81.87) ; CV848.2 163.23,79.52 CV53.2 162.57,79.75 v2(162.32,80) ; v2(184,118.49) 183.99,118.48 183.99,118.11 183.98,118.11 CV378.2 ; DA2.1 275.5,11.85 274.61,12.74 v2(274.61,13.22) ; v2(187.2,124.49) 187.29,124.4 RV120.2 ; v2(213.28,23.52) 213.28,24.09 CE103.2 ; v2(170.7,35.51) 171.02,35.83 CH82.2 ; JFAN1.6 49.53,39.14 v2(48.88,39.14) ; v2(237.26,35.93) 236.7,35.37 CE76.2 ; v2(251.57,30.47) 251.81,30.72 JFAN2.5 ; CV184.2 205.8,83.82 v2(205.86,83.88) ; CV921.2 156.04,75.61 156.67,76.23 156.67,77.24 v2(156.73,77.29) 156.98,77.54 157.19,77.54 157.2,77.55 QZ7.1 ; v2(239.94,30.6) 239.9,30.63 DE8.2 ; CV377.2 179.26,131.35 v2(179.2,131.29) ; JAPS.20 v2(183.78,6.98) ; CA39.2 271.46,15.18 v2(271.92,14.72) 272.32,15.13 CA38.2 ; CA7.2 v2(287.47,33.07) ; v2(156.68,28.34) 156.8,28.46 RH495.2 ; v2(131.07,29.58) 131.29,29.36 CD24.2 ; CZ28.2 130.34,95.6 v2(130.34,95.61) ; PC1276.2 v2(118.06,87.82) ; CL41.2 v2(294.52,82.29) ; v2(203.06,109.06) 203.4,109.4 CV191.2 ; v2(95.83,82.52) 95.54,82.81 PC1339.2 ; RM584.1 v2(264.93,28.44) ; PC1377.2 PC1376.2 ; CV175.2 CV385.2 168.37,121.73 167.95,122.15 v2(167.9,122.09) v2(167.3,122.09) ; v2(187.2,131.69) 187.3,131.79 187.46,131.79 187.65,131.99 CV161.2 ; v2(80.65,43.91) 80.76,43.81 CD2.2 ; v2(209.97,53.86) PR1719.2 209.33,53 PC1731.2 ; RI49.2 286.45,35.55 v2(286.45,35.09) ; PC1373.2 100.8,84 101.26,83.54 PC1333.2 ; PC1310.2 99.95,87.55 PC1361.2 ; PC1310.2 98.97,88.53 v2(98.56,88.53) ; v2(158.37,81.5) 158.44,81.57 CV910.2 CV909.2 ; CH51.1 175.29,25.24 v2(175.7,24.83) ; QZ6.4 205.65,71.69 v2(205.8,71.54) ; v2(210.75,46.45) 210.19,47.01 PC1713.2 PR1716.1 ; v2(172.53,80.51) 172.65,80.64 CV117.2 ; RI45.2 286.53,36.92 v2(286.59,36.87) ; v2(238.97,24.9) 239.33,25.26 239.33,25.49 RE21.2 ; v2(159.9,127.29) 159.95,127.23 CV383.2 ; RA33.2 280.5,15.36 280.04,14.9 v2(279.87,14.9) ; v2(207.06,88.68) 207,88.74 CV394.2 ; v2(204.66,76.48) 204.52,76.62 CV395.2 ; RV132.2 206.08,91.86 v2(206,91.94) ; v2(166.39,86.81) 166.87,87.29 PC1658.2 ; v2(64.04,85.79) 64.25,85.99 65.69,85.99 PC1105.1 65.72,85.04 PR1110.1 ; 64.79,86.86 64.37,86.86 v2(64.04,87.19) ; 64.79,86.86 PC1107.1 ; 64.79,86.86 PC1106.1 ; CV916.2 143.04,60.7 v2(143.62,61.28) ; CH103.2 123.37,89.08 123.76,88.68 v2(124.63,88.68) ; v2(151.8,73.83) 150.66,73.83 150.51,73.68 UV19.3 ; CZ96.2 135.29,102.89 v2(135.01,103.16) ; v2(136,96.7) 135.25,96.7 CZ47.2 ; v2(167.3,118.29) 167.3,118.28 CV851.2 ; v2(155.1,128.49) 155.04,128.43 CV384.2 ; CD28.2 v2(140.34,24.35) ; CZ104.2 13.34,21.83 v2(13.73,22.22) ; RZ40.2 v2(65.08,36.39) ; CZ105.2 16.29,35.47 16.8,35.98 v2(17.23,35.98) ; CV381.2 154.4,131.99 154.7,131.69 v2(155.1,131.69) ; CA10.1 285.19,39.04 v2(285.25,39.11) ; CZ49.2 68.18,47.59 v2(68.08,47.49) ; RV152.1 179.94,75.59 v2(180.06,75.71) ; CM24.2 v2(263.79,42.66) ; CV170.2 168.79,118.35 168.26,118.89 v2(167.9,118.89) ; PC1137.2 69.1,97.35 v2(69.1,98.29) ; RH112.2 175.07,33.52 v2(175.07,33.99) ; QV2.3 v2(66.16,26.65) ; CV173.2 155.09,120.48 v2(155.1,120.49) ; CH189.2 v2(174.81,27.22) ; v2(103.98,88.17) 103.98,88.17 PC1353.2 104.62,87.53 PC1351.2 ; v2(119.08,16.83) 119.36,16.55 RE4.1 ; v2(249.95,21.58) 250.24,21.87 JLED.6 ; v2(209.86,104.26) 209.92,104.21 CV192.2 ; v2(181.58,40) 181.58,39.4 CH179.2 ; v2(159.22,79.8) 159.47,79.54 CV846.2 ; RV154.1 190,76.65 v2(190.31,76.95) 190.33,76.97 190.69,76.97 191.02,76.64 RV153.1 ; RA15.2 293.18,12.69 v2(293.18,12.7) ; PC1424.2 v2(107.58,132.58) ; PC1639.2 163.14,72.96 v2(162.56,73.55) 161.95,73.55 161.41,74.08 CV50.2 ; CH52.2 174.66,21.99 174.66,21.64 v2(174.95,21.35) ; CV917.2 201.03,59.3 v2(202.85,59.3) ; CV576.2 v2(64.4,34.15) ; v2(174.17,29.04) 174.2,29.07 CH202.2 ; PC1326.2 v2(105.02,82.52) ; CV382.2 154.97,122.21 v2(155.1,122.09) ; RM588.1 v2(267.22,42.79) ; CL32.2 284.82,44.62 v2(284.9,44.69) ; v2(207.06,109.06) 207,109.12 CV403.2 207,110.52 206.79,110.73 RV135.2 ; CH181.2 156.41,44.38 v2(156.73,44.06) ; JPW.5 198.51,37.07 v2(198.38,37.2) ; PC1204.2 v2(108.47,86.48) ; v2(231.38,36.1) 231.38,35.78 CE63.1 ; RV156.1 RV162.1 185.42,76.88 185.33,76.98 v2(185.33,77.41) ; CD12.2 139.02,31.94 v2(138.95,32.02) ; v2(124.72,14.82) 124.72,14.95 125.4,15.64 CE5.2 ; RV78.1 175.74,102.16 v2(175.89,102.31) ; PC1633.2 169.44,78.26 169.45,78.27 169.45,78.31 169.77,78.63 169.81,78.63 v2(170.06,78.88) 169.39,79.56 PC1632.2 169.39,80.4 v2(169.23,80.56) 169.39,80.72 PC1631.2 169.39,82.32 PC1666.2 ; v2(200.6,30.6) 200.4,30.41 CN6.2 199.53,30.66 v2(199.53,31.23) ; v2(197.06,79.08) 196.42,79.08 CV902.2 ; CV901.2 200.41,89.48 CV900.2 200.37,89.31 200.66,89.02 v2(200.66,88.68) v2(200.66,88.08) ; CV392.2 207.2,75.74 v2(207.06,75.88) ; PR1617.1 v2(180.73,52.44) ; CV883.2 200.87,109.28 v2(200.66,109.06) ; RH127.2 162.34,27.47 v2(162.51,27.29) ; v2(105.29,18.68) 105.29,19.09 105.53,19.32 CD82.2 ; v2(155.1,126.89) 154.87,126.66 CV386.2 ; CH123.2 112.47,76.67 112.25,76.89 v2(112.25,77.38) ; v2(134.58,44.81) 134.91,44.47 CD17.2 CD16.2 ; v2(30.94,36.27) 31.49,36.82 PC320.2 ; CD76.2 126.71,31.56 v2(126.9,31.36) ; CD10.2 137.23,39.11 CD9.2 137.25,38.6 v2(137.65,38.19) ; CL21.2 284.85,43.63 v2(284.9,43.58) ; v2(173.75,18.98) 173.89,18.84 CH53.2 ; CZ11.2 219.64,11.18 219.64,10.89 v2(219.67,10.86) ; v2(205.86,80.68) 205.8,80.74 CV185.2 ; v2(102.07,75.97) 102.8,75.24 CH120.2 ; v2(151.91,78.9) 151.27,78.25 QZ11.3 ; RV66.1 177.75,73.84 RV49.2 177.75,75.29 v2(177.86,75.4) ; CI18.2 v2(292.11,26.91) ; v2(140.22,39.76) 140.04,39.76 CD4.2 CD3.2 ; CH180.2 v2(154.75,42.08) ; v2(122.56,16.86) 121.85,16.86 CE4.2 ; v2(215.55,21.45) 215.81,21.71 CE74.2 CE65.2 ; CD6.2 103.45,45.14 v2(103.64,45.33) ; JLED.1 245.49,24.16 v2(245.88,23.76) ; CV833.2 175.32,95.63 v2(176.79,95.63) ; v2(291.13,29.52) CI17.2 291.73,28.44 v2(291.92,28.25) ; QE5.3 117.42,15.06 v2(117.74,15.38) ; v2(209.86,101.06) 209.92,101.12 CV400.2 ; CE100.2 240.03,38.09 v2(239.75,38.37) ; RV37.2 170.55,75 v2(170.9,75.35) ; v2(204.68,37.38) 204.99,37.07 JPW.6 ; v2(108.68,95.46) 108.68,95.41 108,94.73 PC1320.2 PC1328.2 v2(108,92.55) 108,92.22 PC1203.2 108.99,92.27 v2(108.99,92.64) 109,92.65 PC1239.2 ; CV896.2 209.92,80.74 v2(209.86,80.68) ; QZ13.1 30.47,38.87 v2(30.94,38.41) 31.1,38.24 R5.2 ; v2(273.67,30.14) 273.59,30.22 CM823.2 CM837.2 ; PC1415.2 v2(108.47,132.58) ; CH186.2 170.54,25.24 v2(170.22,24.91) ; CL20.2 v2(284.05,46.79) ; CA37.2 276.29,15.05 v2(276.62,14.72) 276.67,14.72 277.15,15.2 CA36.2 ; v2(156.6,22.28) 156.4,22.08 CH192.2 ; v2(72.7,49.67) 70.73,49.67 CZ57.2 ; v2(69.35,62.47) 69.61,62.73 PC713.2 ; PC1340.2 97.51,82.64 v2(97.62,82.52) ; PC1314.2 98.13,91.92 v2(97.75,91.92) 97.75,92.46 PC1334.2 PC1327.2 ; v2(242.54,28.37) 241.87,27.7 CE8.2 ; v2(101.61,113.78) 101.93,113.78 PC1366.2 102.05,114.42 v2(101.61,114.42) ; v2(170.95,5.78) 171.08,5.91 JAPS.19 ; v2(113.59,21.38) 113.32,21.11 CD29.2 RH210.2 ; v2(106.86,83.97) PC1323.2 ; v2(120.95,91.93) 120.57,91.93 CH136.2 ; 204.56,75.18 CV897.2 ; 204.56,75.18 CV898.2 ; 204.56,75.18 204.56,75.46 v2(204.99,75.89) ; v2(60.46,39.49) 60.42,39.52 JFAN1.5 ; v2(289.44,41.14) 290.2,40.38 CA4.2 ; v2(187.2,128.49) 187.4,128.69 CV380.2 ; v2(125.71,101.62) 125.55,101.45 CH117.2 125.04,99.58 CH116.2 ; CH119.2 106.02,82.38 v2(105.9,82.51) ; RV567.2 64.32,25.95 v2(64.4,26.03) ; CV874.2 182.34,127.23 v2(182.4,127.29) ; v2(180.09,93.98) 180.09,94.36 179.64,94.81 CV83.2 ; CV875.2 179.26,127.23 v2(179.2,127.29) ; PC800.2 228.74,43.53 229.17,43.96 229.17,44.54 229.24,44.62 v2(229.24,44.69) ; RV116.2 v2(170.72,132.48) ; v2(120.52,80.58) 120.34,80.76 CH127.2 ; CH126.2 117.48,74.72 v2(117.15,74.72) ; v2(102.4,93.2) 101.97,93.64 PC1325.2 PC1324.2 ; v2(158.3,118.49) 158.24,118.43 CV858.2 ; PC1407.2 v2(127.64,132.83) ; v2(103.15,81.87) 103.16,81.89 PC1332.2 ; CV877.2 RV110.2 202.91,96.21 v2(202.96,96.26) v2(202.96,96.86) ; v2(125.21,61.96) 126.06,61.12 CH129.2 CH130.2 CH131.2 CH132.2 ; PQ901.3 145.06,111.97 v2(144.83,111.74) ; v2(98.63,90.44) 99.03,90.44 PC1306.2 100.37,90.02 PC1348.2 ; v2(137.67,14.53) 137.67,15.06 137.25,15.48 UE4.2 ; v2(174.4,128.49) 174.34,128.43 CV166.2 ; v2(286.01,45.81) 286.51,46.31 CL22.2 ; v2(202.96,88.68) 203,88.72 RV111.2 ; PC1244.2 PC1242.2 v2(111.75,92.5) ; PR105.2 11.8,24.78 v2(12.41,24.78) ; PC1362.2 PC1350.2 104.46,86.52 v2(104.1,86.52) ; CA30.2 273.38,25.45 v2(273.82,25.01) 273.95,24.88 CA27.2 ; RH184.2 RH183.2 89.79,89.96 v2(89.86,90.03) ; v2(85.37,18.72) 84.8,19.3 CD20.2 ; v2(160,85.66) 160.11,85.56 CV114.2 ; CV579.2 v2(64.4,25.01) ; RM586.1 v2(268.23,42.79) ; PC1311.2 95.13,90.44 v2(95.58,90.44) ; CN9.2 202.32,30.41 v2(202.16,30.57) ; CI19.2 v2(291.22,25.77) ; v2(103.97,89.19) 104.35,89.19 PC1360.2 PC1352.2 ; PC1221.2 118.4,83.53 118.4,82.72 v2(118.42,82.69) 118.55,82.57 119.03,82.57 PC1247.2 ; QE20.1 v2(253.12,28.23) ; v2(11.57,40.25) 11.57,39.97 PC101.2 ; CZ97.2 v2(129.81,100.92) ; v2(120.95,93.2) 120.57,93.2 PC1386.2 ; CV852.2 159.95,131.35 v2(159.9,131.29) ; v2(116.2,35.63) 115.61,35.63 114.77,34.79 114.77,33.9 CD96.2 ; PC1322.2 PC1321.2 ; CV154.2 172.92,99.88 v2(172.57,99.88) ; v2(187.2,126.89) 187.28,126.96 CV165.2 ; CH121.2 101.13,78.51 101.25,78.63 v2(101.38,78.63) ; CV174.2 163.04,127.23 v2(163.1,127.29) ; CV857.2 168.41,128.84 168.06,128.49 v2(167.9,128.49) ; v2(207.06,96.26) 207.06,95.99 207.3,95.75 CV878.2 ; CA3.2 286.75,28.57 v2(287.21,28.11) 286.78,27.68 CA15.1 ; CD31.2 CD30.2 138.82,28.64 v2(138.82,29.42) ; v2(108.62,81.19) 108.43,81.38 CH122.2 ; CD32.2 v2(135.4,22.82) ; v2(34.33,40.58) 33.74,41.16 QZ13.4 31.77,41.87 R4.2 ; PC202.2 v2(46.24,46.6) ; RV108.2 174.16,124.63 v2(174.4,124.39) ; v2(86.75,31.36) 86.43,31.04 CD86.2 86.43,29.9 v2(86.75,29.58) ; v2(17.22,36.69) 14.95,36.69 CZ106.2 ; CD14.2 135.58,30.85 v2(135.89,30.85) ; CV577.2 v2(64.08,36.19) ; PC1712.2 v2(205.52,57.88) ; v2(241.56,18.66) 240.93,18.02 CE64.1 ; CC5.1 184.28,23.85 v2(184.52,23.61) 184.3,23.4 RZ71.2 ; v2(175,122.09) v2(174.4,122.09) 174.3,121.99 CV376.2 173.6,122.01 CV375.2 ; v2(11.41,41.85) 11.49,41.93 PC100.2 ; v2(123.45,101.08) 123.33,100.95 CH133.2 ; v2(199.74,52.68) 199.96,52.47 PR1702.2 ; PC1271.2 v2(114.56,87.75) ; v2(208.66,96.26) 208.8,96.13 208.8,95.7 208.82,95.7 CV879.2 ; CZ41.2 61.99,41.14 v2(61.71,41.42) ; v2(95.5,88.81) 95.12,88.81 94.64,88.33 PC1305.2 ; RV551.2 RV537.2 64.27,30.98 v2(64.53,31.23) ; v2(200.66,96.26) 200.66,96.17 200.47,95.98 200.47,95.96 200.37,95.85 CV402.2 ; CV152.2 171.71,98.21 v2(171.71,98.21) ; v2(205.86,101.06) 205.8,101.12 CV401.2 ; CV214.2 172.77,77.05 v2(172.55,77.27) ; PC1261.2 v2(115.64,87.68) ; DA3.1 270.57,11.85 v2(269.15,13.27) ; CD74.2 83.15,34.11 v2(83.32,34.28) ; v2(109.47,95.49) 109.9,95.06 PC1246.2 ; CV915.2 v2(142.71,59.65) ; CD1.2 95.69,43.58 CD73.2 95.35,44.62 v2(95.11,44.86) ; PR711.2 v2(68.67,60.75) ; PC1223.2 117.59,82.74 v2(117.78,82.55) ; RH211.2 v2(69.22,45.64) ; CV183.2 197.46,89.18 v2(197.46,88.68) ; v2(167.9,124.39) 167.94,124.43 RV107.2 ; CV499.2 154.1,76.44 v2(154.11,76.43) ; v2(95.67,18.74) 95.67,19.17 95.34,19.5 CD19.2 ; CH201.2 v2(177.81,29.4) ; v2(67.45,43.04) 67.88,43.04 RH209.2 ; CV164.2 173.67,131.99 173.97,131.69 v2(174.4,131.69) ; JFAN2.6 v2(251.81,42.36) ; PC1636.2 v2(169.55,74.96) ; v2(103.9,18.66) 103.9,19.3 103.67,19.52 CD21.2 ; CD77.2 v2(103.64,43.3) ; v2(163.1,131.29) 163.04,131.35 CV853.2 ; v2(135.41,21.39) 135.42,21.38 CD90.2 ; v2(205.01,49.62) 205.24,49.39 PC1707.2 PC1709.2 ; v2(179.66,18.07) 179.41,18.33 RH88.1 ; PR1712.2 200.9,48.86 v2(200.85,48.91) ; CH113.2 125.96,96.74 CH106.2 126.46,96.44 v2(126.57,96.56) ; v2(63.98,61.55) CZ108.2 63.09,60.66 PR704.2 ; CZ88.2 137.77,99.2 v2(138.33,99.76) ; CV391.2 200.72,75.82 v2(200.66,75.88) ; CD5.2 114.02,43.78 CD79.2 113.53,42.73 v2(113.75,42.51) ; CE6.2 v2(124.72,15.97) ; CH104.2 123.19,90.34 123.75,90.89 123.78,90.89 123.97,91.07 v2(123.99,91.07) ; v2(159.19,99.01) 159.32,98.88 159.32,98.03 CV838.2 ; CV193.2 204.52,108.32 v2(204.66,108.46) ; PC1335.2 PC1341.2 ; CV102.2 176.98,89.68 176.98,90.45 v2(176.79,90.63) ; v2(193.66,56.73) 193.63,56.76 193.63,58.39 JKB1.31 ; v2(112.28,82.51) 112.48,82.71 PC1245.2 PC1232.2 ; CM229.2 v2(269.12,42.79) ; CV387.2 155.84,125.96 v2(155.71,126.09) ; PC1330.2 PC1338.2 ; v2(199.06,109.06) 199.1,109.1 CV882.2 ; PC1700.2 206.46,48.15 v2(205.9,48.15) ; CD88.2 v2(140.24,21.55) ; v2(118.37,18.69) 118.37,18.69 118.37,18.69 118.37,18.69 118.38,18.69 118.38,18.71 118.35,18.74 118.35,18.77 118.21,18.9 CD25.2 ; CE1.2 v2(212.58,35.25) ; v2(118.9,95.51) 118.9,95.33 119.18,95.06 PC1240.2 PC1231.2 v2(119.18,92.38) ; PC1645.2 v2(180.58,54.22) ; RM589.1 v2(265.82,28.31) ; PC1416.2 v2(109.36,132.6)
  GND1 w0.203: H12.1 287.72,107.9 ; H12.1 285.89,106.07 ; H12.1 285.89,109.73 ; H12.1 287.23,109.24 ; H12.1 284.06,107.9 ; H12.1 284.55,106.56 ; H12.1 287.23,106.56 ; H12.1 284.55,109.24 ; 298,42.69 JUSB2.13 ; JUSB2.13 296.53,43.57 ; JUSB2.13 296.53,44.45 ; JUSB2.13 298,44.45 ; JUSB2.13 299.47,42.69 ; JUSB2.13 296.53,42.69 ; JUSB2.13 299.47,43.57 ; H10.1 86.53,130.24 ; H10.1 86.53,127.56 ; H10.1 87.02,128.9 ; H10.1 83.85,127.56 ; H10.1 83.36,128.9 ; H10.1 85.19,130.73 ; H10.1 83.85,130.24 ; H10.1 85.19,127.07 ; H13.1 306.03,117.96 ; H13.1 306.47,119.2 ; H13.1 303.55,120.44 ; H13.1 303.55,117.96 ; H13.1 304.79,117.52 ; H13.1 304.79,120.88 ; H13.1 306.03,120.44 ; H13.1 303.11,119.2 ; H17.1 66.63,78.24 ; H17.1 65.29,78.73 ; H17.1 63.95,75.56 ; H17.1 65.29,75.07 ; H17.1 63.46,76.9 ; H17.1 67.12,76.9 ; H17.1 63.95,78.24 ; H17.1 66.63,75.56 ; JUSB1.4 297.04,33.59 ; JUSB1.4 296.41,35.05 ; JUSB1.4 295.58,34.22 ; JUSB1.4 295.77,33.59 ; JUSB1.4 296.41,33.39 ; JUSB1.4 295.77,34.86 ; 304.13,22.87 JUSB1.12 ; JUSB1.12 306.87,22.87 ; JUSB1.12 305.5,21.99 ; JUSB1.12 306.87,21.99 ; JUSB1.12 304.13,21.99 ; H4.1 141.46,69.33 ; H4.1 142.08,71 ; H4.1 139.79,73.29 ; H4.1 141.46,72.67 ; H4.1 138.12,72.67 ; H4.1 138.12,69.33 ; H4.1 137.5,71 ; H4.1 139.79,68.71 ; 296.53,38.57 JUSB1.10 ; JUSB1.10 296.53,39.45 ; JUSB1.10 296.53,37.69 ; JUSB1.10 298,37.69 ; JUSB1.10 298,39.45 ; JUSB1.10 299.47,38.57 ; JUSB1.10 299.47,39.45 ; 194.8,115.64 H5.1 ; H5.1 196.29,112.12 ; H5.1 198.32,114.15 ; H5.1 197.78,115.64 ; H5.1 194.8,112.66 ; H5.1 196.29,116.18 ; H5.1 194.26,114.15 ; H5.1 197.78,112.66 ; 78.2,108.8 H1.1 ; H1.1 82.16,110.47 ; H1.1 82.16,107.13 ; H1.1 80.49,106.51 ; H1.1 78.82,110.47 ; H1.1 80.49,111.09 ; H1.1 78.82,107.13 ; H1.1 82.78,108.8 ; JUSB2.11 305.5,60.15 ; JUSB2.11 304.13,60.15 ; JUSB2.11 306.87,59.27 ; JUSB2.11 306.87,60.15 ; JUSB2.11 304.13,59.27 ; 78.2,70.4 H3.1 ; H3.1 82.16,68.73 ; H3.1 80.49,68.11 ; H3.1 80.49,72.69 ; H3.1 78.82,72.07 ; H3.1 82.78,70.4 ; H3.1 78.82,68.73 ; H3.1 82.16,72.07 ; 304.13,43.57 JUSB2.12 ; JUSB2.12 306.87,43.57 ; JUSB2.12 306.87,42.69 ; JUSB2.12 305.5,42.69 ; JUSB2.12 304.13,42.69 ; JHDMI1.2 301.11,77.22 ; JHDMI1.2 300.66,78.23 ; JHDMI1.2 300.21,78.12 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 301.22,77.67 ; JHDMI1.2 300.1,77.67 ; 295.58,54.92 JUSB2.4 ; JUSB2.4 295.77,55.56 ; JUSB2.4 295.77,54.29 ; JUSB2.4 296.41,55.75 ; JUSB2.4 296.41,54.09 ; JUSB2.4 297.04,54.29 ; 301.41,76.62 JHDMI1.5 ; JHDMI1.5 302.31,75.72 ; JHDMI1.5 302.31,76.62 ; JHDMI1.5 301.41,75.72 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 301.3,76.17 ; H23.1 57.49,59.08 ; H23.1 55.81,57.4 ; H23.1 56.25,58.64 ; H23.1 56.25,56.16 ; H23.1 57.49,55.72 ; H23.1 59.17,57.4 ; H23.1 58.73,58.64 ; H23.1 58.73,56.16 ; H6.1 212.72,68.55 ; H6.1 212.18,70.04 ; H6.1 209.2,67.06 ; H6.1 212.18,67.06 ; H6.1 209.2,70.04 ; H6.1 208.66,68.55 ; H6.1 210.69,70.58 ; H6.1 210.69,66.52 ; H19.1 215.48,51.76 ; H19.1 215.48,54.44 ; H19.1 212.8,54.44 ; H19.1 212.31,53.1 ; H19.1 214.14,54.93 ; H19.1 214.14,51.27 ; H19.1 215.97,53.1 ; H19.1 212.8,51.76 ; 39.27,43.27 H20.1 ; H20.1 42.31,40.23 ; H20.1 42.87,41.75 ; H20.1 39.27,40.23 ; H20.1 40.79,43.83 ; H20.1 40.79,39.67 ; H20.1 38.71,41.75 ; H20.1 42.31,43.27 ; 300.1,74.67 JHDMI1.8 ; JHDMI1.8 300.21,74.22 ; JHDMI1.8 301.22,74.67 ; JHDMI1.8 300.21,75.12 ; JHDMI1.8 301.11,74.22 ; JHDMI1.8 301.11,75.12 ; 299.44,67.3 JHDMI1.21 ; JHDMI1.21 302.74,67.3 ; JHDMI1.21 301.09,65.54 ; JHDMI1.21 299.44,65.54 ; JHDMI1.21 302.74,65.54 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 299.44,66.42 ; H11.1 194.09,130.73 ; H11.1 192.26,128.9 ; H11.1 195.92,128.9 ; H11.1 192.75,127.56 ; H11.1 195.43,130.24 ; H11.1 192.75,130.24 ; H11.1 194.09,127.07 ; H11.1 195.43,127.56 ; H57.1 90.06,9.99 ; H57.1 86.71,8.57 ; H57.1 87.22,9.99 ; H57.1 88.64,10.5 ; H57.1 90.57,8.57 ; 301.41,69.72 JHDMI1.17 ; JHDMI1.17 301.3,70.17 ; JHDMI1.17 301.41,70.62 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 302.31,70.62 ; JHDMI1.17 302.31,69.72 ; H2.1 141.46,106.22 ; H2.1 139.79,102.26 ; H2.1 137.5,104.55 ; H2.1 139.79,106.84 ; H2.1 141.46,102.88 ; H2.1 142.08,104.55 ; H2.1 138.12,106.22 ; H2.1 138.12,102.88 ; JUSB2.10 299.47,60.15 ; JUSB2.10 299.47,59.27 ; JUSB2.10 298,60.15 ; JUSB2.10 296.53,59.27 ; JUSB2.10 298,58.39 ; JUSB2.10 296.53,60.15 ; JUSB2.10 296.53,58.39 ; H56.1 90.32,6.97 ; H56.1 86.96,6.97 ; H56.1 89.88,5.73 ; H56.1 87.4,5.73 ; H56.1 88.64,5.29 ; 297.08,30.72 JUSB1.7 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.91,29.89 ; JUSB1.7 297.91,31.55 ; JUSB1.7 297.27,31.36 ; JUSB1.11 305.5,39.45 ; JUSB1.11 304.13,39.45 ; JUSB1.11 304.13,38.57 ; JUSB1.11 306.87,38.57 ; JLAN.10 309.22,94.44 ; JLAN.10 307.47,93.39 ; JLAN.10 309.22,94.97 ; 297.27,50.79 JUSB2.7 ; JUSB2.7 297.91,52.25 ; JUSB2.7 297.08,51.42 ; JUSB2.7 297.27,52.06 ; JUSB2.7 297.91,50.59 ; 301.09,80.04 JHDMI1.20 ; JHDMI1.20 302.74,80.04 ; JHDMI1.20 302.74,81.8 ; JHDMI1.20 299.44,80.04 ; JHDMI1.20 299.44,81.8 ; JHDMI1.20 299.44,80.92 ; JHDMI1.20 301.09,81.8 ; 301.41,73.62 JHDMI1.11 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 301.3,73.17 ; JHDMI1.11 301.41,72.72 ; JHDMI1.11 302.31,72.72 ; 296.53,22.87 JUSB1.13 ; JUSB1.13 296.53,21.99 ; JUSB1.13 299.47,21.99 ; JUSB1.13 298,23.75 ; JUSB1.13 299.47,22.87 ; JUSB1.13 296.53,23.75 ; JUSB1.13 298,21.99
  IN1 w0.508: v2(292.86,22.95) 294.97,20.84 v2(294.97,17.9)
  VCC w0.203: 78.82,68.73 H3.1 ; H3.1 82.16,68.73 ; H3.1 80.49,68.11 ; H3.1 78.82,72.07 ; H3.1 80.49,72.69 ; H3.1 82.78,70.4 ; H3.1 82.16,72.07 ; H3.1 78.2,70.4 ; 295.77,34.86 JUSB1.4 ; JUSB1.4 296.41,35.05 ; JUSB1.4 297.04,33.59 ; JUSB1.4 296.41,33.39 ; JUSB1.4 295.58,34.22 ; JUSB1.4 295.77,33.59 ; 304.13,22.87 JUSB1.12 ; JUSB1.12 306.87,22.87 ; JUSB1.12 306.87,21.99 ; JUSB1.12 304.13,21.99 ; JUSB1.12 305.5,21.99 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 301.41,73.62 ; JHDMI1.11 302.31,72.72 ; JHDMI1.11 301.41,72.72 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 301.3,73.17 ; H5.1 197.78,115.64 ; H5.1 196.29,116.18 ; H5.1 194.8,112.66 ; H5.1 194.26,114.15 ; H5.1 198.32,114.15 ; H5.1 197.78,112.66 ; H5.1 196.29,112.12 ; H5.1 194.8,115.64 ; JUSB2.11 306.87,60.15 ; JUSB2.11 304.13,59.27 ; JUSB2.11 305.5,60.15 ; JUSB2.11 306.87,59.27 ; JUSB2.11 304.13,60.15 ; 138.12,102.88 H2.1 ; H2.1 139.79,102.26 ; H2.1 137.5,104.55 ; H2.1 141.46,106.22 ; H2.1 138.12,106.22 ; H2.1 141.46,102.88 ; H2.1 139.79,106.84 ; H2.1 142.08,104.55 ; 192.75,127.56 H11.1 ; H11.1 194.09,130.73 ; H11.1 192.26,128.9 ; H11.1 195.43,130.24 ; H11.1 192.75,130.24 ; H11.1 195.43,127.56 ; H11.1 194.09,127.07 ; H11.1 195.92,128.9 ; 296.53,22.87 JUSB1.13 ; JUSB1.13 299.47,21.99 ; JUSB1.13 296.53,23.75 ; JUSB1.13 296.53,21.99 ; JUSB1.13 298,23.75 ; JUSB1.13 299.47,22.87 ; JUSB1.13 298,21.99 ; 212.8,54.44 H19.1 ; H19.1 212.31,53.1 ; H19.1 215.97,53.1 ; H19.1 212.8,51.76 ; H19.1 214.14,54.93 ; H19.1 214.14,51.27 ; H19.1 215.48,54.44 ; H19.1 215.48,51.76 ; JUSB2.12 306.87,43.57 ; JUSB2.12 304.13,43.57 ; JUSB2.12 304.13,42.69 ; JUSB2.12 305.5,42.69 ; JUSB2.12 306.87,42.69 ; JHDMI1.5 302.31,76.62 ; JHDMI1.5 301.41,75.72 ; JHDMI1.5 301.41,76.62 ; JHDMI1.5 302.31,75.72 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 301.3,76.17 ; JUSB1.10 299.47,38.57 ; JUSB1.10 296.53,37.69 ; JUSB1.10 299.47,39.45 ; JUSB1.10 296.53,39.45 ; JUSB1.10 298,37.69 ; JUSB1.10 298,39.45 ; JUSB1.10 296.53,38.57 ; 297.27,31.36 JUSB1.7 ; JUSB1.7 297.91,31.55 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.91,29.89 ; JUSB1.7 297.08,30.72 ; 296.53,59.27 JUSB2.10 ; JUSB2.10 299.47,60.15 ; JUSB2.10 296.53,60.15 ; JUSB2.10 296.53,58.39 ; JUSB2.10 298,60.15 ; JUSB2.10 298,58.39 ; JUSB2.10 299.47,59.27 ; JHDMI1.21 302.74,65.54 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 299.44,67.3 ; JHDMI1.21 299.44,65.54 ; JHDMI1.21 299.44,66.42 ; JHDMI1.21 302.74,67.3 ; JHDMI1.21 301.09,65.54 ; 298,42.69 JUSB2.13 ; JUSB2.13 296.53,44.45 ; JUSB2.13 299.47,42.69 ; JUSB2.13 298,44.45 ; JUSB2.13 296.53,43.57 ; JUSB2.13 299.47,43.57 ; JUSB2.13 296.53,42.69 ; 209.2,67.06 H6.1 ; H6.1 212.18,70.04 ; H6.1 210.69,66.52 ; H6.1 209.2,70.04 ; H6.1 208.66,68.55 ; H6.1 210.69,70.58 ; H6.1 212.72,68.55 ; H6.1 212.18,67.06 ; 299.44,80.04 JHDMI1.20 ; JHDMI1.20 301.09,80.04 ; JHDMI1.20 299.44,80.92 ; JHDMI1.20 302.74,80.04 ; 295.77,54.29 JUSB2.4 ; JUSB2.4 295.58,54.92 ; JUSB2.4 295.77,55.56 ; JUSB2.4 296.41,55.75 ; JUSB2.4 297.04,54.29 ; JUSB2.4 296.41,54.09 ; JUSB2.7 297.91,52.25 ; JUSB2.7 297.91,50.59 ; JUSB2.7 297.27,50.79 ; JUSB2.7 297.08,51.42 ; JUSB2.7 297.27,52.06 ; JHDMI1.17 302.31,69.72 ; JHDMI1.17 301.3,70.17 ; JHDMI1.17 302.31,70.62 ; JHDMI1.17 301.41,70.62 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 301.41,69.72 ; 300.21,75.12 JHDMI1.8 ; JHDMI1.8 300.1,74.67 ; JHDMI1.8 300.21,74.22 ; JHDMI1.8 301.22,74.67 ; JHDMI1.8 301.11,74.22 ; JHDMI1.8 301.11,75.12 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 301.11,77.22 ; JHDMI1.2 300.21,78.12 ; JHDMI1.2 300.1,77.67 ; JHDMI1.2 301.22,77.67 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 300.66,78.23 ; 304.13,39.45 JUSB1.11 ; JUSB1.11 304.13,38.57 ; JUSB1.11 305.5,39.45 ; JUSB1.11 306.87,38.57
  GND2 w0.203: 55.81,57.4 H23.1 ; H23.1 57.49,59.08 ; H23.1 59.17,57.4 ; H23.1 56.25,56.16 ; H23.1 58.73,58.64 ; H23.1 56.25,58.64 ; H23.1 58.73,56.16 ; H23.1 57.49,55.72 ; 196.29,112.12 H5.1 ; H5.1 194.26,114.15 ; H5.1 194.8,115.64 ; H5.1 196.29,116.18 ; H5.1 197.78,112.66 ; H5.1 194.8,112.66 ; H5.1 197.78,115.64 ; H5.1 198.32,114.15 ; 299.44,80.04 JHDMI1.20 ; JHDMI1.20 299.44,81.8 ; JHDMI1.20 302.74,81.8 ; JHDMI1.20 301.09,81.8 ; JHDMI1.20 301.09,80.04 ; JHDMI1.20 302.74,80.04 ; JHDMI1.20 299.44,80.92 ; JHDMI1.2 301.22,77.67 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 300.1,77.67 ; JHDMI1.2 300.21,78.12 ; JHDMI1.2 300.66,78.23 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 301.11,77.22 ; 297.08,51.42 JUSB2.7 ; JUSB2.7 297.27,50.79 ; JUSB2.7 297.91,50.59 ; JUSB2.7 297.27,52.06 ; JUSB2.7 297.91,52.25 ; JHDMI1.5 302.31,75.72 ; JHDMI1.5 301.41,76.62 ; JHDMI1.5 302.31,76.62 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 301.3,76.17 ; JHDMI1.5 301.41,75.72 ; 138.12,102.88 H2.1 ; H2.1 139.79,102.26 ; H2.1 142.08,104.55 ; H2.1 137.5,104.55 ; H2.1 141.46,102.88 ; H2.1 141.46,106.22 ; H2.1 138.12,106.22 ; H2.1 139.79,106.84 ; JUSB2.13 298,44.45 ; JUSB2.13 296.53,42.69 ; JUSB2.13 299.47,43.57 ; JUSB2.13 299.47,42.69 ; JUSB2.13 298,42.69 ; JUSB2.13 296.53,43.57 ; JUSB2.13 296.53,44.45 ; 86.71,8.57 H57.1 ; H57.1 87.22,9.99 ; H57.1 90.06,9.99 ; H57.1 88.64,10.5 ; H57.1 90.57,8.57 ; 65.29,75.07 H17.1 ; H17.1 65.29,78.73 ; H17.1 67.12,76.9 ; H17.1 66.63,75.56 ; H17.1 66.63,78.24 ; H17.1 63.95,75.56 ; H17.1 63.95,78.24 ; H17.1 63.46,76.9 ; 85.19,127.07 H10.1 ; H10.1 83.85,130.24 ; H10.1 83.36,128.9 ; H10.1 85.19,130.73 ; H10.1 87.02,128.9 ; H10.1 86.53,127.56 ; H10.1 83.85,127.56 ; H10.1 86.53,130.24 ; 304.13,22.87 JUSB1.12 ; JUSB1.12 304.13,21.99 ; JUSB1.12 305.5,21.99 ; JUSB1.12 306.87,22.87 ; JUSB1.12 306.87,21.99 ; 303.11,119.2 H13.1 ; H13.1 306.47,119.2 ; H13.1 306.03,117.96 ; H13.1 304.79,117.52 ; H13.1 303.55,117.96 ; H13.1 303.55,120.44 ; H13.1 304.79,120.88 ; H13.1 306.03,120.44 ; 194.09,127.07 H11.1 ; H11.1 195.92,128.9 ; H11.1 192.75,127.56 ; H11.1 195.43,127.56 ; H11.1 192.26,128.9 ; H11.1 194.09,130.73 ; H11.1 195.43,130.24 ; H11.1 192.75,130.24 ; JLAN.10 309.22,93.91 ; JLAN.10 307.47,93.39 ; JLAN.10 309.22,94.97 ; JLAN.10 309.3,94.44 ; H1.1 82.16,107.13 ; H1.1 78.2,108.8 ; H1.1 78.82,110.47 ; H1.1 78.82,107.13 ; H1.1 80.49,111.09 ; H1.1 82.16,110.47 ; H1.1 80.49,106.51 ; H1.1 82.78,108.8 ; JHDMI1.21 302.74,65.54 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 299.44,65.54 ; JHDMI1.21 299.44,66.42 ; JHDMI1.21 299.44,67.3 ; JHDMI1.21 301.09,65.54 ; JHDMI1.21 302.74,67.3 ; 300.21,75.12 JHDMI1.8 ; JHDMI1.8 300.21,74.22 ; JHDMI1.8 301.11,75.12 ; JHDMI1.8 301.11,74.22 ; JHDMI1.8 300.1,74.67 ; JHDMI1.8 301.22,74.67 ; JHDMI1.17 302.31,69.72 ; JHDMI1.17 301.41,70.62 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 301.3,70.17 ; JHDMI1.17 302.31,70.62 ; JHDMI1.17 301.41,69.72 ; 295.58,34.22 JUSB1.4 ; JUSB1.4 295.77,33.59 ; JUSB1.4 296.41,33.39 ; JUSB1.4 297.04,33.59 ; JUSB1.4 295.77,34.86 ; JUSB1.4 296.41,35.05 ; H4.1 142.08,71 ; H4.1 139.79,73.29 ; H4.1 137.5,71 ; H4.1 141.46,72.67 ; H4.1 138.12,69.33 ; H4.1 141.46,69.33 ; H4.1 139.79,68.71 ; H4.1 138.12,72.67 ; H12.1 287.23,109.24 ; H12.1 284.55,106.56 ; H12.1 287.23,106.56 ; H12.1 284.55,109.24 ; H12.1 285.89,109.73 ; H12.1 285.89,106.07 ; H12.1 284.06,107.9 ; H12.1 287.72,107.9 ; 295.77,55.56 JUSB2.4 ; JUSB2.4 295.77,54.29 ; JUSB2.4 296.41,54.09 ; JUSB2.4 297.04,54.29 ; JUSB2.4 295.58,54.92 ; JUSB2.4 296.41,55.75 ; 304.13,60.15 JUSB2.11 ; JUSB2.11 306.87,59.27 ; JUSB2.11 306.87,60.15 ; JUSB2.11 304.13,59.27 ; JUSB2.11 305.5,60.15 ; JUSB2.10 299.47,60.15 ; JUSB2.10 299.47,59.27 ; JUSB2.10 298,58.39 ; JUSB2.10 296.53,59.27 ; JUSB2.10 296.53,58.39 ; JUSB2.10 298,60.15 ; JUSB2.10 296.53,60.15 ; 304.13,38.57 JUSB1.11 ; JUSB1.11 306.87,38.57 ; JUSB1.11 305.5,39.45 ; JUSB1.11 304.13,39.45 ; H3.1 82.16,68.73 ; H3.1 78.82,68.73 ; H3.1 78.2,70.4 ; H3.1 80.49,72.69 ; H3.1 82.78,70.4 ; H3.1 78.82,72.07 ; H3.1 80.49,68.11 ; H3.1 82.16,72.07 ; 209.2,67.06 H6.1 ; H6.1 212.72,68.55 ; H6.1 209.2,70.04 ; H6.1 208.66,68.55 ; H6.1 212.18,70.04 ; H6.1 210.69,66.52 ; H6.1 210.69,70.58 ; H6.1 212.18,67.06 ; H19.1 214.14,54.93 ; H19.1 214.14,51.27 ; H19.1 215.48,51.76 ; H19.1 212.8,54.44 ; H19.1 212.8,51.76 ; H19.1 215.48,54.44 ; H19.1 215.97,53.1 ; H19.1 212.31,53.1 ; 39.27,43.27 H20.1 ; H20.1 40.79,39.67 ; H20.1 38.71,41.75 ; H20.1 42.31,40.23 ; H20.1 39.27,40.23 ; H20.1 42.31,43.27 ; H20.1 42.87,41.75 ; H20.1 40.79,43.83 ; JUSB2.12 306.87,42.69 ; JUSB2.12 304.13,42.69 ; JUSB2.12 305.5,42.69 ; JUSB2.12 304.13,43.57 ; JUSB2.12 306.87,43.57 ; JUSB1.13 299.47,22.87 ; JUSB1.13 296.53,21.99 ; JUSB1.13 298,21.99 ; JUSB1.13 296.53,23.75 ; JUSB1.13 299.47,21.99 ; JUSB1.13 298,23.75 ; JUSB1.13 296.53,22.87 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 301.41,73.62 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 302.31,72.72 ; JHDMI1.11 301.3,73.17 ; JHDMI1.11 301.41,72.72 ; H56.1 90.32,6.97 ; H56.1 86.96,6.97 ; H56.1 89.88,5.73 ; H56.1 88.64,5.29 ; H56.1 87.4,5.73 ; 298,37.69 JUSB1.10 ; JUSB1.10 296.53,39.45 ; JUSB1.10 299.47,38.57 ; JUSB1.10 296.53,38.57 ; JUSB1.10 298,39.45 ; JUSB1.10 296.53,37.69 ; JUSB1.10 299.47,39.45 ; 297.27,31.36 JUSB1.7 ; JUSB1.7 297.91,31.55 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.91,29.89 ; JUSB1.7 297.08,30.72
  GND3 w0.203: 139.79,102.26 H2.1 ; H2.1 138.12,106.22 ; H2.1 139.79,106.84 ; H2.1 141.46,102.88 ; H2.1 142.08,104.55 ; H2.1 141.46,106.22 ; H2.1 138.12,102.88 ; H2.1 137.5,104.55 ; H10.1 87.02,128.9 ; H10.1 85.19,130.73 ; H10.1 83.85,130.24 ; H10.1 86.53,127.56 ; H10.1 83.36,128.9 ; H10.1 85.19,127.07 ; H10.1 86.53,130.24 ; H10.1 83.85,127.56 ; 297.08,30.72 JUSB1.7 ; JUSB1.7 297.27,31.36 ; JUSB1.7 297.27,30.09 ; JUSB1.7 297.91,31.55 ; JUSB1.7 297.91,29.89 ; JUSB1.13 299.47,21.99 ; JUSB1.13 296.53,23.75 ; JUSB1.13 299.47,22.87 ; JUSB1.13 298,23.75 ; JUSB1.13 296.53,21.99 ; JUSB1.13 296.53,22.87 ; JUSB1.13 298,21.99 ; H13.1 306.47,119.2 ; H13.1 304.79,117.52 ; H13.1 303.55,117.96 ; H13.1 303.11,119.2 ; H13.1 304.79,120.88 ; H13.1 303.55,120.44 ; H13.1 306.03,120.44 ; H13.1 306.03,117.96 ; 297.08,51.42 JUSB2.7 ; JUSB2.7 297.27,52.06 ; JUSB2.7 297.91,50.59 ; JUSB2.7 297.91,52.25 ; JUSB2.7 297.27,50.79 ; JUSB1.11 306.87,38.57 ; JUSB1.11 304.13,38.57 ; JUSB1.11 305.5,39.45 ; JUSB1.11 304.13,39.45 ; JUSB2.11 306.87,60.15 ; JUSB2.11 305.5,60.15 ; JUSB2.11 306.87,59.27 ; JUSB2.11 304.13,59.27 ; JUSB2.11 304.13,60.15 ; 284.55,109.24 H12.1 ; H12.1 287.72,107.9 ; H12.1 284.06,107.9 ; H12.1 287.23,109.24 ; H12.1 285.89,106.07 ; H12.1 285.89,109.73 ; H12.1 284.55,106.56 ; H12.1 287.23,106.56 ; H20.1 42.31,43.27 ; H20.1 42.87,41.75 ; H20.1 42.31,40.23 ; H20.1 38.71,41.75 ; H20.1 40.79,43.83 ; H20.1 39.27,43.27 ; H20.1 39.27,40.23 ; H20.1 40.79,39.67 ; H11.1 195.92,128.9 ; H11.1 195.43,127.56 ; H11.1 194.09,127.07 ; H11.1 195.43,130.24 ; H11.1 194.09,130.73 ; H11.1 192.75,127.56 ; H11.1 192.26,128.9 ; H11.1 192.75,130.24 ; 299.44,65.54 JHDMI1.21 ; JHDMI1.21 299.44,66.42 ; JHDMI1.21 301.09,65.54 ; JHDMI1.21 302.74,67.3 ; JHDMI1.21 299.44,67.3 ; JHDMI1.21 301.09,67.3 ; JHDMI1.21 302.74,65.54 ; H23.1 58.73,56.16 ; H23.1 57.49,55.72 ; H23.1 56.25,58.64 ; H23.1 55.81,57.4 ; H23.1 59.17,57.4 ; H23.1 56.25,56.16 ; H23.1 57.49,59.08 ; H23.1 58.73,58.64 ; 298,37.69 JUSB1.10 ; JUSB1.10 296.53,37.69 ; JUSB1.10 299.47,38.57 ; JUSB1.10 299.47,39.45 ; JUSB1.10 296.53,39.45 ; JUSB1.10 296.53,38.57 ; JUSB1.10 298,39.45 ; 295.77,55.56 JUSB2.4 ; JUSB2.4 297.04,54.29 ; JUSB2.4 295.58,54.92 ; JUSB2.4 296.41,55.75 ; JUSB2.4 296.41,54.09 ; JUSB2.4 295.77,54.29 ; H5.1 198.32,114.15 ; H5.1 194.26,114.15 ; H5.1 194.8,112.66 ; H5.1 194.8,115.64 ; H5.1 197.78,115.64 ; H5.1 196.29,112.12 ; H5.1 196.29,116.18 ; H5.1 197.78,112.66 ; H57.1 90.57,8.57 ; H57.1 88.64,10.5 ; H57.1 86.71,8.57 ; H57.1 87.22,9.99 ; H57.1 90.06,9.99 ; 78.82,68.73 H3.1 ; H3.1 80.49,72.69 ; H3.1 82.16,68.73 ; H3.1 78.82,72.07 ; H3.1 82.78,70.4 ; H3.1 80.49,68.11 ; H3.1 78.2,70.4 ; H3.1 82.16,72.07 ; JHDMI1.11 302.31,72.72 ; JHDMI1.11 302.42,73.17 ; JHDMI1.11 301.41,73.62 ; JHDMI1.11 302.31,73.62 ; JHDMI1.11 301.41,72.72 ; JHDMI1.11 301.3,73.17 ; H56.1 89.88,5.73 ; H56.1 88.64,5.29 ; H56.1 86.96,6.97 ; H56.1 90.32,6.97 ; H56.1 87.4,5.73 ; H19.1 215.97,53.1 ; H19.1 212.8,51.76 ; H19.1 212.31,53.1 ; H19.1 215.48,54.44 ; H19.1 214.14,51.27 ; H19.1 212.8,54.44 ; H19.1 215.48,51.76 ; H19.1 214.14,54.93 ; 300.1,77.67 JHDMI1.2 ; JHDMI1.2 300.21,77.22 ; JHDMI1.2 300.66,78.23 ; JHDMI1.2 300.21,78.12 ; JHDMI1.2 301.11,78.12 ; JHDMI1.2 301.22,77.67 ; JHDMI1.2 301.11,77.22 ; 296.53,59.27 JUSB2.10 ; JUSB2.10 299.47,59.27 ; JUSB2.10 296.53,58.39 ; JUSB2.10 298,60.15 ; JUSB2.10 299.47,60.15 ; JUSB2.10 296.53,60.15 ; JUSB2.10 298,58.39 ; 209.2,67.06 H6.1 ; H6.1 212.18,70.04 ; H6.1 212.72,68.55 ; H6.1 210.69,70.58 ; H6.1 208.66,68.55 ; H6.1 210.69,66.52 ; H6.1 209.2,70.04 ; H6.1 212.18,67.06 ; H17.1 67.12,76.9 ; H17.1 65.29,75.07 ; H17.1 66.63,78.24 ; H17.1 65.29,78.73 ; H17.1 63.95,78.24 ; H17.1 66.63,75.56 ; H17.1 63.95,75.56 ; H17.1 63.46,76.9 ; JUSB1.4 296.41,35.05 ; JUSB1.4 297.04,33.59 ; JUSB1.4 296.41,33.39 ; JUSB1.4 295.77,33.59 ; JUSB1.4 295.58,34.22 ; JUSB1.4 295.77,34.86 ; 80.49,106.51 H1.1 ; H1.1 82.78,108.8 ; H1.1 82.16,107.13 ; H1.1 82.16,110.47 ; H1.1 80.49,111.09 ; H1.1 78.2,108.8 ; H1.1 78.82,107.13 ; H1.1 78.82,110.47 ; 138.12,69.33 H4.1 ; H4.1 137.5,71 ; H4.1 141.46,72.67 ; H4.1 139.79,68.71 ; H4.1 139.79,73.29 ; H4.1 141.46,69.33 ; H4.1 138.12,72.67 ; H4.1 142.08,71 ; JUSB2.13 299.47,42.69 ; JUSB2.13 299.47,43.57 ; JUSB2.13 298,42.69 ; JUSB2.13 298,44.45 ; JUSB2.13 296.53,42.69 ; JUSB2.13 296.53,44.45 ; JUSB2.13 296.53,43.57 ; JHDMI1.8 301.22,74.67 ; JHDMI1.8 300.1,74.67 ; JHDMI1.8 300.21,74.22 ; JHDMI1.8 301.11,75.12 ; JHDMI1.8 300.21,75.12 ; JHDMI1.8 301.11,74.22 ; JHDMI1.20 302.74,81.8 ; JHDMI1.20 301.09,81.8 ; JHDMI1.20 302.74,80.04 ; JHDMI1.20 299.44,80.04 ; JHDMI1.20 299.44,80.92 ; JHDMI1.20 301.09,80.04 ; JHDMI1.20 299.44,81.8 ; JHDMI1.5 302.42,76.17 ; JHDMI1.5 301.41,75.72 ; JHDMI1.5 301.41,76.62 ; JHDMI1.5 301.3,76.17 ; JHDMI1.5 302.31,75.72 ; JHDMI1.5 302.31,76.62 ; JUSB1.12 306.87,21.99 ; JUSB1.12 305.5,21.99 ; JUSB1.12 304.13,21.99 ; JUSB1.12 306.87,22.87 ; JUSB1.12 304.13,22.87 ; 301.3,70.17 JHDMI1.17 ; JHDMI1.17 302.31,69.72 ; JHDMI1.17 302.31,70.62 ; JHDMI1.17 301.41,70.62 ; JHDMI1.17 302.42,70.17 ; JHDMI1.17 301.41,69.72 ; JUSB2.12 306.87,42.69 ; JUSB2.12 306.87,43.57 ; JUSB2.12 304.13,43.57 ; JUSB2.12 304.13,42.69 ; JUSB2.12 305.5,42.69 ; 307.47,93.39 JLAN.10 ; JLAN.10 309.22,94.44 ; JLAN.10 309.22,94.97
  BOTTOM w0.102: UV1.D2 179.64,76.13 v2(180.06,75.71)
  BOTTOM w0.127: UH2.B6 176.18,43.37 176.18,43.73 176.34,43.89 176.44,43.89 176.83,44.28 ; UV1.B34 181.29,104.36 v2(181.32,104.38) ; v2(179.49,72.29) 179.54,72.24 179.96,72.24 180.12,72.08 180.12,68.89 179.91,68.67 175.88,68.67 175.65,68.9 CV71.1 ; v2(234.3,17.64) v4(233.47,17.64)
  BOTTOM w0.15: v2(179.29,93.13) 179.29,92.51 179.49,92.31 179.89,92.31 180.09,92.11 180.09,91.48 v2(180.09,91.48) ; v2(180.09,84.81) 180.74,84.81 180.89,84.66 v2(180.89,83.98) ; v2(165.87,98.21) 166.74,98.21 UV1.W28 ; UV1.C25 180.09,96.46 v2(180.09,97.31)
  BOTTOM w0.152: UH2.AM45 157.15,28.3 156.71,28.3 v2(156.68,28.34) ; v2(158.18,27.07) 158.27,27.07 158.31,27.03 UH2.AR42 ; UH2.BE14 172.64,21.88 172.64,21.35 v2(172.63,21.34) ; UH2.BE32 163.45,21.72 v2(162.79,21.06) ; v2(170.14,44.08) 170.14,44.03 170.28,43.89 UH2.A18 ; v2(166.81,42.59) 166.77,42.63 UH2.B25 UH2.A25 ; v2(178.04,91.06) UV1.G19 ; UH2.AC1 179.17,32.79 v2(179.31,32.93) ; v2(156.73,26.41) 157.17,25.96 UH2.AU45 ; UH2.A32 163.46,43.77 163.48,43.79 v2(163.48,44.26) ; v2(182.49,83.13) 182.06,83.56 UV1.B10 ; UH1.G28 123.98,93.47 123.98,92.55 UH1.G26 ; UH2.AU1 179.23,25.95 v2(179.31,26.03) ; UH2.A37 161.08,43.54 UH2.B37 161.02,42.97 161.02,42.59 UH2.C37 ; v2(156.7,30.57) 156.74,30.53 UH2.AH45 ; v2(156.5,35.25) 156.52,35.22 156.55,35.22 156.69,35.08 UH2.V45 ; UH2.AC45 157.03,32.97 156.74,32.97 v2(156.74,32.97) ; 162.14,77.15 UV1.AE2 162.14,76.7 161.95,76.51 161.13,76.51 160.88,76.76 160.88,77.07 160.87,77.09 v2(160.87,77.31) 161.99,77.31 162.14,77.15
  BOTTOM w0.178: UV1.G22 v2(178.04,93.56) UV1.E22
  BOTTOM w0.2: v2(182.49,93.98) v2(181.69,93.98)
  BOTTOM w0.203: UH1.AW3 UH1.AW4 UH1.AW5 100.18,76.34 UH1.AU6 100.81,77.05 100.39,77.31 ; UH1.AW3 99.88,75.03 v2(99.55,74.71) ; UH1.AW3 100.03,75 100.03,74.42 UH1.AW2 100.02,74.36 100.02,73.76 UH1.AW1 99.87,73.73 v2(99.55,74.06) ; 126.31,78.89 126.86,78.89 UH1.C9 126.91,78.77 v2(127.24,78.45) ; 126.31,78.89 126.38,78.96 126.38,79.51 UH1.D10 ; 126.31,78.89 UH1.D9 ; UH1.BN19 89.37,86.64 89.37,87.11 UH1.BN20 UH1.BN21 ; UH2.AE42 158.3,31.58 158.16,31.71 v2(158.15,31.71) ; UH1.AR5 v2(102.07,75.97) UH1.AR4 UH1.AR3 UH1.AR2 UH1.AR1 102.51,73.61 101.76,72.86 101.76,72.46 v2(102.14,72.08) ; v2(126.1,75.94) 126.14,75.99 126.42,75.99 UH1.C5 127.33,76.9 127.7,76.9 128.07,77.28 UH1.A6 ; v2(126.1,75.94) 125.84,75.69 UH1.E4 UH1.F4 ; v2(126.1,75.94) 126.17,75.86 126.17,75.4 126.39,75.19 UH1.D3 126.48,75.06 v2(126.95,75.06) ; UH1.BN12 89.48,80.92 88.93,80.92 UH1.BP12 UH1.BR12 UH1.BT12 86.71,80.97 v2(86.67,80.94) ; v2(123.14,79.91) 122.81,80.25 UH1.K11 ; v2(110.05,73.19) UH1.AF1 UH1.AF2 110.03,74.38 109.65,74.64 v2(109.64,74.71) 110.02,74.92 UH1.AF3 UH1.AF4 ; UH1.BA9 UH1.BA10 v2(98.58,79.97) UH1.BA11 v2(98.57,80.61) ; UH1.BA9 v2(98.57,79.34) ; UH1.BA9 UH1.BA8 ; UH1.BL35 90.77,98.41 v2(90.53,98.65) 90.53,98.64 UH1.BM35 ; UH1.BL38 91.03,100.4 v2(90.69,100.74) 90.32,100.37 UH1.BM38 ; UH1.J4 123.5,75.69 123.84,75.35 v2(123.88,75.35) 124.22,75.69 UH1.G4 UH1.F4 ; UH1.J4 123.38,75.69 v2(123.04,75.35) 123,75.35 122.66,75.69 UH1.K4 ; UH1.J4 123.79,76.01 123.87,76.01 124.19,76.34 UH1.G5 ; UH1.F4 124.95,75.37 125.05,75.27 UH1.F3 124.98,75.03 v2(124.66,74.71) 124.73,74.71 UH1.F2 ; UH1.BE3 UH1.BE2 UH1.BE1 94.96,73.22 v2(94.52,72.77) ; UH1.BE3 UH1.BE4 UH1.BE5 95.29,76.66 v2(95.36,76.66) ; UH1.BE3 v2(94.47,74.71) ; v2(126.95,75.06) 127.01,75.12 UH1.B3 127.64,74.99 UH1.A3 UH1.A4 ; v2(126.95,75.06) 126.95,74.54 UH1.C2 ; v2(120.52,79.93) 120.19,79.6 UH1.N10 ; UH1.K4 122.53,75.6 122.53,75.12 UH1.K3 UH1.K2 122.69,74.38 v2(123.04,74.03) 123,74.03 122.7,73.73 UH1.K1 ; UH1.K4 122.66,75.72 122.66,76.3 UH1.K5 ; UH1.AL7 UH1.AL8 106.4,78.3 v2(106.8,78.7) v2(106.8,79.34) 106.41,78.95 UH1.AL9 ; v2(128.85,86) 128.85,85.93 UH1.A18 ; UH1.AD10 112.21,79.97 v2(112.3,79.97) v2(112.29,80.61) 112.2,80.61 UH1.AD11 UH1.AD10 ; UH1.AD10 UH1.AD9 ; UH1.F9 124.96,78.77 v2(125.28,78.45) ; v2(104.06,79.34) 103.86,79.34 UH1.AP10 ; v2(104.06,79.34) v2(104.06,78.7) ; v2(104.06,79.34) 104.06,79.97 v2(104.07,79.97) ; UH1.BN21 89.53,88.13 v2(89.86,88.45) 90.18,88.13 UH1.BM21 ; UH1.BN21 89.47,88 88.94,88 UH1.BP21 ; v2(174.95,21.35) 174.95,21.88 UH2.BE9 ; UH1.A30 128.21,95.33 v2(128.56,94.99) ; UH1.T11 UH1.T12 ; UH1.T11 UH1.T10 ; UH1.T11 117.51,80.25 v2(117.78,79.97) 117.7,79.97 UH1.T10 ; UH1.T12 117.49,80.9 v2(117.78,80.61) 117.95,80.61 UH1.R12 118.49,81.16 118.89,81.16 UH1.P12 119.37,81.11 119.85,81.11 UH1.N12 ; UH1.T12 UH1.T13 117.18,81.55 v2(116.88,81.85) 117.22,82.2 UH1.T14 117.43,82.2 v2(117.78,82.55) ; UH1.T12 117.15,81.06 116.57,81.06 UH1.V12 ; UH1.BL13 91.17,82.1 ; 91.17,82.1 91.48,81.78 UH1.BK13 ; 91.17,82.1 91.48,82.41 UH1.BK14 91.48,82.55 91.12,82.91 v2(91.12,82.95) 91.12,82.97 91.48,83.33 UH1.BK15 ; UH1.Y10 UH1.Y9 UH1.Y8 ; UH1.Y10 114.95,79.97 v2(115.04,79.97) 114.76,80.25 UH1.Y11 UH1.Y10 ; UH1.AJ4 UH1.AJ3 107.42,75.03 v2(107.09,74.71) 107.18,74.71 107.51,74.38 UH1.AJ2 107.58,74.34 107.58,73.78 UH1.AJ1 107.44,73.73 v2(107.1,74.07) ; UH1.AJ4 UH1.AJ5 UH1.AJ6 UH1.AH6 UH1.AG6 ; UH1.AJ4 UH1.AK4 106.51,75.55 106.05,75.55 UH1.AL4 ; UH1.AP33 103.63,97.11 v2(103.95,97.43) 103.62,97.76 UH1.AP34 ; v2(95.83,82.52) 96.16,82.2 UH1.BC14 UH1.BC13 ; UH1.BN2 UH1.BM2 UH1.BM3 90.15,75.47 v2(90.32,75.81) 90.08,76.25 UH1.BM5 ; UH1.T34 117.8,97.76 v2(118.13,97.43) UH1.T33 ; UH1.BL6 90.06,76.99 UH1.BM6 89.98,76.36 UH1.BM5 ; UH1.BL6 UH1.BM7 ; UH1.BL6 UH1.BK6 91.68,76.99 v2(92,76.66) ; v2(159.22,79.8) 159.22,79.82 159.19,79.85 159.19,80.38 159.59,80.78 UV1.AH7 ; v2(159.22,79.8) 159.15,79.73 157.51,79.73 157.19,79.41 UV1.AL5 ; v2(159.22,79.8) 159.22,79.73 UV1.AH5 ; v2(86.72,88.06) UH1.BT21 UH1.BR21 ; UH2.BE18 170.13,21.85 170.13,21.57 170.14,21.56 v2(170.14,21.51) ; v2(111.38,78.62) 111.78,78.29 UH1.AD8 ; UH1.U37 v2(117.34,100.03) UH1.U38 ; UH1.AG11 109.41,80.57 v2(109.51,80.57) ; UH1.N10 UH1.N11 ; UH1.N10 120.04,79.58 120.04,78.97 UH1.N9 120.37,79.25 v2(120.51,79.25) 120.54,79.22 120.54,78.77 UH1.N8 UH1.N7 120.11,77.6 UH1.N6 ; UH2.H29 v2(164.53,39.9) ; v2(92,76.66) 92.12,76.66 UH1.BH6 ; v2(92,76.66) 92.33,76.34 UH1.BH5 UH1.BH4 UH1.BH3 ; UH1.BR38 88.03,100.51 v2(88.03,101.02) ; UH1.G24 124.63,90.33 v2(124.63,90.26) ; v2(125.71,101.62) 125.69,101.62 125.31,101.24 UH1.E38 125.21,100.26 125.21,99.46 124.82,99.07 UH1.F36 ; v2(124.64,86.32) 124.96,86.64 UH1.F19 124.96,86.78 v2(124.63,87.11) 124.63,87.18 UH1.G20 ; UH1.F13 124.96,81.85 UH1.G12 124.31,81.14 v2(123.98,80.81) ; v2(103.17,99.38) 102.84,99.71 UH1.AR37 ; UH1.BN9 89.86,79.72 89.86,79.79 ; UH1.BE6 95.37,77.4 UH1.BD7 UH1.BD8 v2(95.83,78.7) UH1.BD9 v2(95.83,79.34) UH1.BD10 v2(95.84,79.97) UH1.BD11 95.84,80.62 95.84,80.6 ; UH1.BE6 v2(95.36,76.66) ; UH1.BE6 UH1.BF6 UH1.BG6 UH1.BH6 ; v2(109.58,77.35) UH1.AG6 ; UH1.AG6 109.09,77.11 UH1.AG7 UH1.AG8 ; UH1.AB33 v2(113.4,97.43) UH1.AB34 ; UH1.BM25 90.51,91.53 v2(90.51,91.6) 90.51,91.67 UH1.BM26 ; UH1.M14 UH1.M13 UH1.M12 120.84,80.9 v2(120.52,80.58) ; UH1.BK25 UH1.BJ25 v2(92.71,91.21) ; v2(93.09,77.97) UH1.BH7 ; UH1.BH7 UH1.BH6 ; UH1.BH7 UH1.BH8 ; v2(112.3,79.32) 112.21,79.32 UH1.AD9 ; v2(117.79,79.34) 117.66,79.34 ; 117.66,79.34 117.58,79.34 UH1.T10 ; 117.66,79.34 117.32,79 ; UH1.BM29 UH1.BN29 UH1.BP29 UH1.BR29 ; UH1.BM29 UH1.BM28 90.18,93.5 v2(90.51,93.18) 90.18,92.85 UH1.BM27 ; UH1.BM29 UH1.BL29 91.27,94.36 UH1.BK29 91.88,94.97 UH1.BJ30 91.75,95.09 v2(91.35,95.48) 91.68,95.81 UH1.BJ31 ; UH1.BC34 96.54,97.76 v2(96.87,98.08) ; 163.28,41.9 162.98,42.2 UH2.D33 162.7,42.2 ; UH1.N11 120.19,80.25 v2(120.52,80.58) ; UH1.N11 UH1.N12 ; UH1.AR13 103.01,81.87 v2(103.15,81.87) 102.82,82.2 UH1.AR14 102.56,82.2 v2(102.23,81.87) ; v2(125.28,91.05) 125.28,91.11 UH1.F25 ; UH1.T10 117.32,79 ; UH1.AJ38 UH1.AJ37 107.43,99.71 v2(107.1,99.39) ; UH1.F15 124.85,83.43 v2(124.62,83.15) 124.62,83.09 UH1.G14 ; UH1.F15 v2(124.63,83.96) 124.63,84.03 UH1.G16 ; UH1.F15 125.28,83.18 v2(125.28,83.15) ; v2(124.63,90.26) 124.96,89.93 UH1.F23 124.96,89.8 v2(125.28,89.47) ; v2(124.63,90.26) 124.63,90.19 UH1.G23 ; UH1.A14 v2(128.77,82.78) ; v2(114.64,72.8) 115.08,73.25 UH1.W1 UH1.W2 115.11,74.42 115.11,75 UH1.W3 ; UH1.AM37 105.21,99.71 v2(105.53,100.03) 105.2,100.36 UH1.AM38 ; 89.86,79.79 90.18,80.12 UH1.BM11 v2(89.86,80.58) 89.86,80.65 UH1.BM12 ; 89.86,79.79 90.18,79.47 UH1.BM9 89.85,79.06 v2(89.85,79) 89.85,78.95 UH1.BM8 90.11,78.54 90.11,77.9 UH1.BM7 ; v2(86.82,85.66) 86.86,85.7 UH1.BT18 UH1.BR18 UH1.BP18 UH1.BN18 89.53,85.63 v2(89.86,85.3) 90.18,85.63 UH1.BM18 ; UH1.BM7 UH1.BN7 89.53,77.9 v2(89.2,78.23) 89.2,78.14 UH1.BP7 UH1.BR7 ; UH1.BK18 UH1.BJ18 92.57,85.7 v2(92.73,85.54) ; v2(97.06,76.66) 97.15,76.66 UH1.BB6 ; v2(97.06,76.66) UH1.BC6 UH1.BD6 v2(95.36,76.66) ; v2(97.06,76.66) 97.11,76.61 97.11,75.51 97.48,75.14 UH1.BB3 97.5,75.01 97.5,74.41 UH1.BB2 97.49,74.37 97.49,73.75 UH1.BB1 ; UH1.D22 126.91,88.43 UH1.C21 126.91,88.22 v2(127.24,87.9) ; v2(156.63,24.25) 156.72,24.34 UH2.AY45 ; UH1.BB4 97.5,75.71 97.5,76.31 UH1.BB5 97.5,76.36 97.5,76.96 UH1.BB6 ; UH1.BB6 UH1.BA6 ; UH1.BB6 98.12,77.62 UH1.BA7 UH1.BA8 ; v2(127.24,80.02) 126.91,80.35 UH1.C11 126.91,80.55 UH1.D12 ; v2(161.11,21.48) 161.15,21.52 UH2.BE37 ; UH1.AM5 UH1.AM4 105.06,75.65 105.06,75.07 UH1.AM3 UH1.AM2 UH1.AM1 105.02,73.26 v2(105.08,73.2) ; v2(179.16,36.59) 178.87,36.3 UH2.T1 UH2.T2 ; v2(127.24,78.45) 126.91,78.12 UH1.C8 126.91,77.92 UH1.D6 ; v2(127.24,78.45) 127.56,78.77 UH1.B9 UH1.A9 ; UH1.C25 126.91,91.58 UH1.D26 126.26,92.26 126.58,92.58 v2(126.58,92.62) ; v2(128.56,94.22) 128.56,94.15 UH1.A28 ; UH2.BE23 168.03,21.99 168.44,21.58 v2(168.54,21.58) ; v2(109.55,79.97) 109.47,79.97 UH1.AG10 ; UH1.D20 126.91,86.85 UH1.C19 126.91,86.65 v2(126.58,86.32) ; v2(119.67,100.03) 119.7,100.03 ; 119.7,100.03 UH1.P37 ; 119.7,100.03 UH1.P38 ; v2(120.52,80.58) 120.21,80.9 UH1.N12 ; v2(114.64,74.73) UH1.W3 ; UH1.W3 UH1.W4 UH1.W5 115.73,76.99 UH1.V6 UH1.U6 116.76,77.08 UH1.T7 UH1.T8 UH1.T9 117.32,79 ; v2(125.28,87.9) 125.28,87.96 UH1.F21 124.63,88.61 v2(124.63,88.68) 124.63,88.75 UH1.G22 124.28,89.04 123.64,89.04 UH1.H22 UH1.J22 ; v2(128.86,87.67) 128.86,87.57 128.79,87.5 UH1.A20 ; UH1.BT5 86.68,76.55 v2(86.55,76.68) ; UH1.AU9 UH1.AU8 UH1.AU7 ; UH1.AU9 v2(101.38,78.63) ; UH1.AU9 UH1.AU10 ; UH1.N6 UH1.M6 ; UH1.N6 UH1.N5 UH1.N4 120.02,75.69 v2(119.69,75.35) 120,75.03 UH1.N3 UH1.N2 UH1.N1 ; v2(123.98,80.81) 123.66,81.14 UH1.H12 ; v2(123.98,80.81) 123.98,80.74 UH1.H11 ; v2(105.9,82.51) 106.03,82.51 UH1.AL14 ; UH1.J25 UH1.H25 123.62,91.44 v2(123.99,91.07) ; v2(92.02,74.7) 92.05,74.7 UH1.BH3 ; v2(115.01,81.87) 115.05,81.83 115.05,81.37 115.49,80.93 UH1.W12 ; v2(115.01,81.87) 114.9,81.87 UH1.Y14 ; v2(115.01,81.87) 114.68,81.55 UH1.Y13 ; UH2.B37 161.13,43.04 161.35,42.81 161.35,42.74 ; UH1.AU7 101.52,76.99 UH1.AT6 ; UH1.AU7 100.82,77.65 100.39,77.29 100.39,77.31 ; v2(127.24,83.17) 126.91,83.5 UH1.C15 126.91,83.7 UH1.D16 ; UH1.Y8 UH1.Y7 114.4,77.65 113.74,76.99 UH1.AB6 UH1.AC6 UH1.AC5 UH1.AC4 112.42,75.69 v2(112.12,75.39) 112.47,75.03 UH1.AC3 UH1.AC2 UH1.AC1 112.57,68.77 112.98,68.36 112.98,66.86 113.7,66.13 v2(114.42,66.13) ; UH1.Y8 114.95,78.67 v2(115.04,78.67) ; UH1.F36 124.68,99.06 UH1.H35 123.89,98.41 UH1.J36 ; UH1.F36 124.96,99.06 UH1.E35 125.61,97.74 UH1.E34 125.61,97.6 UH1.D33 126.57,96.64 v2(126.57,96.56) 126.57,96.5 UH1.C31 ; UH1.BF34 94.18,97.76 v2(94.5,97.43) 94.18,97.11 UH1.BF33 ; v2(125.28,80.02) 124.96,80.35 UH1.F11 ; 100.39,77.31 v2(100.39,77.33) ; v2(128.86,84.38) 128.86,84.42 128.8,84.35 UH1.A16 ; UH1.BG37 93.39,99.71 v2(93.72,99.38) ; v2(92.56,93.91) 92.24,94.23 UH1.BJ29 ; UH1.BG38 v2(93.72,100.68) ; UH1.BM5 90,76.26 UH1.BN4 89.44,75.7 89.1,75.7 v2(89.08,75.67) 88.84,75.67 88.68,75.5 88.1,75.5 87.85,75.75 UH1.BT4 UH1.BT3 ; v2(96.87,96.78) 96.54,97.11 UH1.BC33 ; UH1.AY33 98.91,97.11 v2(99.23,97.43) 98.9,97.76 UH1.AY34 ; UH1.AV37 100.48,99.71 v2(100.8,100.03) 100.47,100.36 UH1.AV38 ; UH1.L29 UH1.L30 121.67,95.14 121.32,95.49 v2(121.29,95.49) ; UH1.BT9 87.57,79.41 86.67,79.41 86.37,79.11 86.37,78.91 v2(86.4,78.88) ; v2(101.59,96.78) 101.26,97.11 UH1.AU33 ; v2(122.41,85.89) 122.45,85.93 UH1.J18 UH1.H18 123.69,85.84 124.22,85.84 UH1.G18 124.63,85.6 v2(124.63,85.53) 124.96,85.21 UH1.F17 125.28,84.81 v2(125.28,84.75) ; v2(86.99,99.05) UH1.BT36 88.12,99.05 UH1.BR36 ; UH1.G8 UH1.F8 124.96,78.12 v2(125.28,78.45) ; UH1.G8 124.25,77.99 123.96,77.99 UH1.J7 123.43,77.47 122.83,77.47 UH1.K7 v2(123.14,77.94) 122.79,78.3 UH1.K8 122.79,78.35 122.79,78.89 UH1.K9 122.66,78.95 v2(122.33,79.28) 122.41,79.28 UH1.K10 ; UH1.G8 124.31,77.53 v2(124.32,77.52) 124.32,77.51 124.32,77.04 UH1.G6 124.31,76.94 124.31,76.38 UH1.G5 ; UH1.G5 124.8,76.34 UH1.F5 ; UH1.A22 v2(128.85,89.08) ; UH1.AE34 UH1.AE33 v2(111.04,96.78) ; v2(119.65,77.34) 119.3,76.99 UH1.P6 ; UH2.D36 161.69,42.2 161.52,42.03 ; UH2.AH1 179.66,30.52 179.74,30.6 v2(179.74,30.52) ; UH1.W34 115.43,97.76 v2(115.78,97.42) ; UH2.BE40 159.39,21.84 159.39,21.55 v2(159.29,21.45) ; UH1.AL33 105.85,97.11 v2(105.53,97.43) 105.86,97.76 UH1.AL34 ; UH1.AF13 UH1.AF14 110.31,82.51 v2(110.46,82.51) ; UH1.BK22 UH1.BJ22 92.64,88.85 v2(92.69,88.9) ; v2(104.07,79.97) 103.88,79.97 UH1.AP11 103.97,80.61 v2(104.06,80.61) 104.07,80.6 v2(104.07,79.97) ; v2(104.06,78.7) 103.66,78.3 UH1.AP8 104.04,77.86 104.04,77.13 UH1.AN6 104.13,76.93 UH1.AN5 ; v2(104.06,78.7) 103.85,78.7 UH1.AP9 ; UH1.BT24 UH1.BR24 88.26,90.45 88.86,90.45 UH1.BP24 88.94,90.47 89.48,90.47 UH1.BN24 89.53,90.35 v2(89.86,90.03) 90.18,89.7 UH1.BM23 ; UH1.BH8 UH1.BH9 UH1.BH10 v2(93.09,79.97) UH1.BH11 ; UH1.BH8 v2(93.09,78.62) ; v2(127.24,92.6) 127.24,92.69 UH1.C27 126.91,93.15 UH1.D28 ; v2(103.17,100.68) 102.84,100.36 UH1.AR38 ; UH1.L33 121.74,97.11 v2(122.06,97.43) 121.73,97.76 UH1.L34 ; v2(87.08,97.02) 87.22,97.02 UH1.BT32 ; v2(98.44,99.38) 98.38,99.38 UH1.BA37 98.05,99.78 98.11,99.84 98.11,100.22 98.05,100.29 UH1.BA38 ; UH1.AE6 111.22,76.65 v2(111.31,76.65) 111.39,76.65 UH1.AD6 ; UH1.AH34 108.35,97.76 v2(108.68,97.43) 108.36,97.11 UH1.AH33 ; UH1.T3 UH1.T2 UH1.T1 117.55,73.73 v2(117.21,73.39) ; UH1.T3 UH1.T4 UH1.T5 ; UH1.T3 117.46,75.03 v2(117.15,74.72) ; UH1.BT14 87.7,82.67 88.11,82.67 UH1.BR14 88.23,82.62 v2(88.56,82.94) 88.88,82.61 UH1.BP14 UH1.BN14 ; v2(165.4,21.22) 165.4,21.44 165.72,21.76 UH2.BE28 ; v2(98.57,78.7) UH1.BA8 ; UH1.BH3 92.48,75 92.48,74.42 UH1.BH2 92.2,74.13 UH1.BH1 92.2,73.3 v2(92.11,73.22) ; UH1.AU12 UH1.AU11 ; UH1.AU11 UH1.AU10 ; UH1.AU11 101.3,79.99 101.31,79.95 v2(101.33,79.94) ; UH1.AU10 v2(101.32,79.34) ; UH1.AD9 111.86,78.92 111.86,78.32 UH1.AD8 ; v2(89.85,95.54) 89.85,95.62 UH1.BN31 88.88,96.58 UH1.BP33 ; v2(127.24,81.6) 126.91,81.92 UH1.C13 126.91,82.13 UH1.D14 ; v2(127.87,92.6) 127.87,92.56 UH1.A26 ; v2(127.24,89.47) 126.91,89.8 UH1.C23 126.91,90 UH1.D24 ; v2(127.24,84.75) 126.91,85.07 UH1.C17 126.91,85.28 UH1.D18 ; UH1.E9 125.61,78.77 v2(125.28,78.45) ; UH1.AC37 v2(112.61,99.38) ; UH1.Y37 v2(114.98,100.03) UH1.Y38 ; UH1.A24 v2(128.85,90.65) ; UH1.BD38 95.75,100.36 v2(96.08,100.03) 95.76,99.71 UH1.BD37 ; UH1.BG13 UH1.BG14 93.41,82.2 93.1,81.89 v2(93.1,81.88) 93.1,81.87 92.77,82.2 UH1.BH14 ; v2(91.35,96.78) 91.68,96.46 UH1.BJ32 ; UH1.BN34 89.53,97.44 v2(89.21,97.11) 88.88,97.44 UH1.BP34 UH1.BR34 ; UH1.W33 v2(115.76,96.78) ; v2(123.45,101.08) 122.73,100.36 UH1.K38 ; UH1.A10 128.74,79.63 v2(128.78,79.59) ; UH1.AD8 UH1.AD7 ; PU1000.18 204.58,118.4 v2(204.43,118.56) ; UH1.AC38 v2(112.61,100.68) ; UH1.A12 v2(128.85,81.2) ; UH1.AU34 101.27,97.76 v2(101.59,98.08) ; UH1.BP26 UH1.BR26 UH1.BT26 86.84,92 v2(86.5,92.34)
  BOTTOM w0.229: 177.61,81.43 v2(177.61,82.31)
  BOTTOM w0.25: v2(171.71,104.51) 171.92,104.51 172.26,104.17 172.26,104.12 172.48,103.91 v2(172.57,103.91) 172.14,103.48 172.14,103.33 172.11,103.3 172.11,102.92 172.14,102.89 UV1.N33 ; v2(157.49,99.81) 157.54,99.86 158.29,99.86 v2(158.31,99.88) ; v2(179.19,104.71) 179.19,104.7 178.73,104.25 178.73,104.25 v2(178.39,103.91) ; v2(182.54,101.11) 182.54,101.16 183.24,101.86 v2(183.24,101.91)
  BOTTOM w0.254: PU1503.3 133.85,127.74 133.69,127.9 v2(133.69,128.08) ; v2(127.23,94.17) 127.23,94.27 UH1.C29 126.91,94.65 126.58,94.99 ; UH1.A34 127.89,98.52 v2(127.89,98.59) 127.89,98.68 UH1.A36 ; 176.83,44.28 177.11,44.57 177.92,44.57 178.52,45.16 180.55,45.16 v2(181.33,45.95) 182.12,46.73 v2(185.05,46.73) 186.7,46.73 186.95,46.47 v2(186.95,44.58) 186.95,42.84 186.6,42.48 v2(185.05,42.48) 183.35,42.48 183.17,42.66 v2(182.2,42.66) 181.66,42.66 181.06,43.26 UH2.B1 ; PC1012.2 209.08,114.14 209.43,113.78 209.49,113.78 209.56,113.71 209.56,113.68 ; v2(76.09,38.8) 76.41,38.8 77.15,39.54 JDIMM1.27 ; JEDP1.8 62.03,27.51 61.77,27.26 ; 162.37,41.81 162.23,41.95 UH2.D35 ; JEDP1.13 61.78,30.01 v2(61.73,29.96) 61.73,30.26 61.99,30.51 JEDP1.14 ; v2(128.13,38.75) 128.15,38.78 JDIMM1.223 128.15,41.92 128.37,42.13 128.95,42.13 128.96,42.14 129.15,41.94 JDIMM1.227 ; v2(265.03,22.38) 265.03,22.29 264.78,22.04 UA2.7 ; JEDP1.24 62.7,35.51 63.41,35.51 v2(64.08,36.19) ; UH1.K10 123.05,79.91 v2(123.14,79.91) 123.3,79.91 UH1.J10 ; v2(124.65,79.25) 124.65,79.14 UH1.F9 ; v2(124.65,79.25) 124.31,79.59 UH1.G10 ; v2(124.65,79.25) 124.31,78.9 UH1.G9 ; UV1.AB5 164.64,80.22 v2(164.6,80.25) 164.64,80.29 UV1.AB7 ; JDIMM1.167 114.15,40.17 114.81,39.52 114.81,38.58 115.32,38.07 v2(116.21,38.07) ; PC1121.2 79.97,91.18 v2(80.02,91.18) 79.51,90.67 PC1122.2 ; v2(175.07,76.54) 174.89,76.72 174.86,76.72 174.67,76.91 UV1.K2 ; JEDP1.7 62.12,27.01 61.87,27.26 61.77,27.26 ; UH1.AY12 UH1.AW12 100.09,80.9 v2(100.39,81.19) ; v2(266.96,19.68) 266.82,19.54 UA2.11 ; UH1.F29 125.28,94.9 v2(125.28,94.98) ; UH1.BF12 94.58,81.02 95.26,81.02 UH1.BD12 95.54,80.9 95.84,80.6 v2(95.84,80.56) ; v2(156.69,97.29) 157.07,96.91 UV1.AL26 ; JNGFF1.49 198.31,21.02 198.89,20.44 v2(200.37,20.44) 199.81,20.99 JNGFF1.55 ; PH1100.1 v2(97.8,122.72) ; 61.77,27.26 v2(61.73,27.26) ; UH1.AL10 106.74,79.98 106.8,79.98 ; v2(126.48,100.81) 126.11,100.44 UH1.D38 ; 106.8,79.98 v2(106.8,79.34) ; 106.8,79.98 v2(106.82,80) ; UH1.BG12 93.38,80.9 v2(93.09,80.61) 92.92,80.61 92.64,80.9 UH1.BH12 ; UH1.BM13 UH1.BL13 ; PR213.2 46.55,42.9 PQ200.4 ; v2(131.33,125.24) 131.58,125.49 PU1503.10 ; v2(207.49,27.47) 207.64,27.33 JNGFF2.39 ; JNGFF1.43 196.81,22.87 v2(196.63,23.05) ; v2(172.86,16.71) 172.87,16.71 172.88,16.7 172.88,15.23 173.14,14.98 v2(175.19,14.98) 177.01,14.98 177.3,15.27 v2(177.3,16.47) ; v2(189.19,30.62) 189.14,30.57 188.88,30.57 188.56,30.24 JNGFF1.10 ; UV1.AH16 159.31,88.28 v2(158.89,88.28) ; UH1.BN30 89.51,95.15 89.2,95.46 v2(89.2,95.53) ; UV1.AN10 155.49,83.57 v2(155.91,83.99) ; v2(104.06,80.61) 104.35,80.9 UH1.AN12 104.64,81.02 105.31,81.02 UH1.AM12 UH1.AL12 ; UH1.BA12 98,81.02 97.32,81.02 UH1.BB12 97.08,81.02 96.41,81.02 UH1.BC12 UH1.BC13 ; v2(201.31,20.48) JNGFF1.61 ; JEDP1.36 61.8,41.51 v2(61.71,41.42) ; UV1.AL2 157.11,76.91 v2(156.73,77.29) ; PU500.15 101.16,10.16 101.16,9.37 v2(101.4,9.13) 101.43,9.1 101.43,8.37 PR505.2 102.19,7.56 102.35,7.56 PC507.2 ; JDIMM1.193 120.65,42.43 121.17,42.94 v2(122.08,42.94) 121.65,42.52 JDIMM1.197 ; JEDP1.33 v2(61.71,40.01) ; UH1.AH12 108.32,80.9 v2(108.62,81.19) ; UH1.BJ15 UH1.BK15 ; v2(203.77,104.07) 203.86,104.16 UV9.J10 ; v2(193.79,31.49) 193.79,30.98 193.06,30.25 JNGFF1.28 ; 211.59,63.06 v2(211.59,63.08) ; 211.59,63.06 212.13,63.06 212.47,62.71 PQ103.4 ; 211.59,63.06 211.17,63.48 PQ103.1 ; 96.16,26.26 v2(96.09,26.2) ; v2(182.11,125.13) 182.17,125.18 182.17,125.2 182.25,125.29 UV6.J10 ; v2(158.99,93.26) 159.29,93.26 UV1.AH22 ; v2(283.28,24.76) 283.27,24.74 RA14.2 ; v2(128.73,74.72) 128.46,74.99 UH1.A3 ; UH1.J33 123.3,97.05 123.3,96.52 UH1.J32 123.6,96.1 v2(123.64,96.1) 123.67,96.1 UH1.H32 124.66,96.46 UH1.F31 ; UH1.D30 126.26,95.3 126.58,94.99 ; JEDP1.11 62.7,29.01 63.72,29.01 64.17,28.57 64.7,28.57 v2(64.93,28.79) ; v2(128.76,99.79) UH1.A37 128.07,99.64 UH1.B37 126.81,99.64 UH1.C37 ; JDIMM2.175 116.16,29.3 v2(115.71,29.75) 115.16,29.2 JDIMM2.171 ; UV1.AH10 159.65,83.56 v2(159.99,83.9) 159.99,84.01 UV1.AH11 ; UH1.BT35 86.99,98.23 v2(86.97,98.25) ; JDIMM2.81 90.66,29.04 v2(91.2,29.58) ; v2(103.15,80.56) 103.26,80.56 UH1.AP12 ; 112.25,77.46 112.07,77.65 UH1.AD7 ; 112.25,77.46 v2(112.25,77.38) ; 112.25,77.46 112.57,77.15 UH1.AC6 ; UH2.AK42 158.38,29.3 v2(158.23,29.45) ; v2(179.19,104.71) 179.64,104.26 179.64,104.25 179.65,104.25 179.65,103.87 179.64,103.86 v2(179.64,103.36) ; JEDP1.39 62.7,43.01 63.33,43.01 63.59,43.27 v2(63.59,43.32) 63.4,43.51 62.7,43.51 JEDP1.40 ; v2(119.56,38.79) 119.42,38.79 119.07,39.15 119.07,39.62 118.65,40.03 JDIMM1.185 ; PR1007.2 210.04,114.16 209.56,113.68 ; v2(128.66,121.83) 128.64,121.83 128.61,121.86 128.56,121.86 128.53,121.83 PH1104.2 ; JEDP1.27 v2(61.67,37.01) ; 209.56,113.68 v2(209.56,113.66) ; v2(177.57,76.51) 177.57,75.7 v2(177.86,75.4) 177.86,74.59 178.04,74.41 178.04,74.13 178.39,73.78 178.97,73.78 ; 126.58,94.99 v2(126.58,94.96) ; UA2.4 v2(263.28,22.34) ; v2(110.47,81.19) 110.3,81.19 UH1.AF12 ; v2(197.46,88.08) 197.46,88.08 UV8.A1 ; v2(281.19,46.85) v2(279.41,46.85) 277.89,46.85 277.12,46.09 277.12,44.95 v2(277.76,44.31) 277.76,42.54 278.14,42.15 v2(279.54,42.15) 279.96,42.15 280.29,41.82 280.86,41.82 v2(281.57,42.54) ; JDIMM2.44 v2(81.41,21.22) ; UH1.G26 124.66,92.58 v2(124.66,92.61) 124.66,92.72 UH1.F27 ; v2(176.55,75.5) 176.41,75.37 176.41,74.45 176.04,74.08 176.03,74.08 175.73,73.78 175.73,73.35 v2(175.78,73.29) ; UH1.AY14 98.9,82.2 v2(98.57,82.52) ; v2(61.71,26.63) 61.83,26.51 JEDP1.6 ; PR214.2 45.54,38.08 PQ203.1 ; v2(113.6,30.75) 113.74,30.75 114.16,30.34 JDIMM2.167 ; UV8.J10 203.86,80.62 v2(203.72,80.76) ; UV1.AG11 160.62,84.41 161.29,83.73 v2(161.29,83.66) ; UT1.6 56.86,47.76 56.6,47.5 v2(56.6,47.22) ; JNGFF1.25 192.31,21.05 192.52,20.84 193.51,20.84 193.81,21.15 JNGFF1.31 193.81,22.87 v2(193.94,23) ; JNGFF2.3 206.7,36.33 206.38,36.64 206.38,37.15 v2(206.46,37.23) 206.86,36.83 JNGFF2.1 ; JEDP1.30 v2(61.65,38.51) ; JNGFF1.37 v2(195.31,23.08) ; JDIMM2.102 95.91,19.1 95.67,18.86 v2(95.67,18.74)
  BOTTOM w0.279: UV1.AN25 UV1.AM25 156.33,96.06 156.52,95.87 156.52,95.76 v2(156.69,95.59) 157.02,95.26 157.03,95.26 UV1.AL24 UV1.AL23 ; UV1.AH24 159.19,95.61 v2(159.19,95.7)
  BOTTOM w0.3: v2(183.64,82.31) 183.64,82.41 184.24,83.01 v2(184.24,83.13) ; v2(174.22,103.91) 174.71,103.41 174.71,102.78 UV1.K33
  BOTTOM w0.305: UH1.AD12 112,80.9 v2(112.29,80.61) ; v2(172.53,80.51) 172.15,80.89 172.15,81.01 UV1.N7 ; v2(131.1,43.05) 131.2,43.05 131.2,43.04 131.45,43.04 132.15,42.34 JDIMM1.239 ; JDIMM1.106 96.9,31.9 96.59,31.59 96.14,31.59 95.9,31.82 JDIMM1.102 95.9,33.84 v2(95.69,34.05) ; JNGFF1.15 189.81,20.78 v2(189.91,20.68) ; v2(82.39,26.83) 82.39,27.1 82.16,27.34 JDIMM2.47 82.16,29.12 81.85,29.43 81.44,29.43 81.16,29.15 JDIMM2.43 ; v2(182.54,101.11) 182.06,101.11 v2(181.69,101.48) 181.29,101.08 UV1.B31 ; JDIMM1.18 74.9,34.1 v2(74.93,34.13) ; JDIMM1.214 125.9,31.7 125.69,31.49 v2(124.85,31.49) ; v2(135.89,30.14) 135.2,30.14 134.16,29.1 JDIMM2.247 ; PU1401.4 v2(114.5,130.04) ; v2(206.66,78.28) UV8.N12 207.06,78.68 v2(207.46,78.28) ; JDIMM2.26 76.91,19.08 v2(76.55,18.72) 76.27,18.72 75.91,19.08 JDIMM2.22 ; UV6.T5 178.8,130.89 v2(179.2,131.29) ; UV6.T5 v2(178.4,131.29) ; UV6.T5 v2(178.4,130.49) 178,130.09 UV6.R4 v2(177.6,129.69) UV6.R3 ; UV1.AN19 UV1.AM19 156.29,90.84 156.93,90.21 UV1.AL18 UV1.AL17 157.07,89.41 v2(156.68,89.02) 156.29,88.63 UV1.AM16 UV1.AN16 ; v2(135.68,38.15) 135.41,38.15 134.15,39.4 JDIMM1.247 ; UV6.R12 184.4,130.09 v2(184.8,130.49) ; v2(91.2,29.58) 90.98,29.79 90.06,29.79 89.66,29.39 JDIMM2.77 ; v2(90.13,45.5) 89.74,45.5 88.65,44.41 JDIMM1.73 ; v2(209.06,86.28) UV8.R3 v2(208.26,85.48) UV8.R4 ; v2(131.07,31.36) 130.9,31.53 JDIMM1.234 ; v2(165.5,128.89) 165.1,128.49 UV7.E3 165.1,128.49 v2(164.7,128.09) ; v2(206.97,32) 207.14,31.83 JNGFF2.21 ; v2(119.21,18.66) 119.21,18.71 119.41,18.91 JDIMM2.188 ; v2(177.6,128.89) 177.2,128.49 UV6.N3 ; UV1.G32 176.74,102.31 UV1.G33 177.16,102.71 v2(177.57,103.11) ; UV9.F10 v2(205.86,104.26) 205.46,104.66 UV9.G10 v2(205.86,105.06) UV9.F10 ; UV9.F10 v2(206.66,105.06) ; JDIMM2.176 116.41,18.85 v2(116.21,18.66) ; UV6.H14 186,124.49 v2(185.6,124.09) UV6.H13 v2(184.8,124.89) ; v2(209.86,83.88) 209.46,84.28 UV8.T5 ; v2(81.47,34.71) 81.16,34.71 80.4,33.95 JDIMM1.40 80.4,31.84 80.65,31.59 81.15,31.59 81.4,31.85 JDIMM1.44 ; UV7.T10 159.49,119.69 v2(159.1,119.29) ; v2(167.3,126.07) 166.71,126.07 UV7.H1 166.7,126.09 v2(166.3,125.69) UV7.H2 ; JDIMM2.52 83.41,18.85 83.21,18.66 v2(82.61,18.66) ; UV9.E12 v2(207.46,106.66) ; v2(123.66,30.71) JDIMM2.205 ; JDIMM2.107 97.16,27.26 96.16,26.26 JDIMM2.103 ; UV1.AM13 156.29,86.01 v2(156.68,85.62) UV1.AL12 ; UV1.AM13 UV1.AN13 ; UV1.AM13 156.29,86.17 v2(156.68,86.56) 157.03,86.91 UV1.AL14 UV1.AL15 ; v2(155.7,118.89) v2(155.7,118.29) v2(155.1,118.29) ; v2(155.7,118.89) v2(155.1,118.89) ; v2(155.7,118.89) 156.29,118.89 UV7.U14 ; JDIMM2.14 73.91,18.93 v2(74.18,18.66) ; v2(197.86,105.06) 198.26,104.67 UV9.T10 ; JDIMM2.172 115.41,19.03 115.03,18.66 v2(114.84,18.66) 114.41,19.09 JDIMM2.168 ; v2(163.1,131.29) v2(163.9,130.49) 164.3,130.09 UV7.C4 ; UV1.AN22 UV1.AM22 156.34,93.56 156.73,93.17 ; UV7.N12 v2(157.5,122.49) ; JDIMM1.36 79.4,31.85 80.02,31.23 v2(80.23,31.23) ; JDIMM1.248 134.4,34.49 135.57,35.65 v2(135.71,35.65) ; v2(88.27,34.53) 88.4,34.4 JDIMM1.72 ; UV9.R12 199.06,106.26 v2(198.66,105.86) 199.06,105.47 UV9.R11 199.06,105.46 v2(199.46,105.06) 199.86,104.67 UV9.P10 ; v2(156.71,103.11) 156.74,103.11 UV1.AL33 156.74,102.31 UV1.AL32 ; v2(132.94,21.69) 133.41,21.22 JDIMM2.244 ; JDIMM1.27 77.15,41.9 77.39,42.13 77.86,42.13 78.15,41.83 JDIMM1.31 ; v2(209.75,30.45) 209.62,30.33 JNGFF2.27 ; UV7.L5 163.49,123.69 v2(163.1,123.29) UV7.M5 163.49,122.89 v2(163.1,122.49) ; v2(197.06,105.86) 197.46,106.26 UV9.U12 ; 119.67,97.45 119.76,97.45 UH1.N33 ; 119.67,97.45 v2(119.68,97.43) ; 119.67,97.45 119.98,97.76 UH1.N34 ; v2(176.8,131.29) UV6.U3 v2(177.6,132.09) ; JDIMM2.189 119.66,27.13 120.3,26.48 v2(120.33,26.48) ; UZ9.5 135.42,102.48 135.01,102.9 v2(135.01,103.16) ; v2(117.74,29.46) 118.38,29.46 118.66,29.18 JDIMM2.185 ; JDIMM1.77 89.65,41.98 89.96,42.28 v2(90.12,42.28) 90.25,42.28 90.65,41.87 JDIMM1.81 ; UV1.N5 172.2,79.31 v2(172.6,78.91) ; JDIMM1.217 126.65,42.26 126.13,42.79 125.41,42.79 v2(125.18,42.56) ; UV6.N3 v2(176.8,128.89) ; UV6.N3 v2(176.8,128.09) ; v2(155.09,103.91) v2(154.29,103.91) ; v2(155.09,103.91) UV1.AN34 ; v2(155.09,103.91) v2(155.09,104.61) ; UV8.A12 197.46,78.68 v2(197.06,79.08) ; UH1.AC12 112.77,80.9 113.12,81.24 v2(113.22,81.24) 113.22,81.3 113.62,80.9 UH1.AA12 ; v2(180.09,91.48) 180.49,91.08 UV1.C19 ; JDIMM2.227 129.16,29.21 v2(128.91,29.45) 128.85,29.39 128.44,29.39 128.16,29.1 JDIMM2.223 ; JDIMM2.23 76.16,29.26 75.97,29.45 75.36,29.45 75.16,29.24 JDIMM2.19 v2(75.16,26.69) ; v2(177.6,118.49) 177.2,118.89 UV6.A3 ; JDIMM1.43 81.15,43.41 v2(80.65,43.91) ; UV8.A3 197.46,85.88 v2(197.06,85.48) ; v2(176.8,122.49) UV6.E3 177.2,122.09 v2(176.8,121.69) ; v2(116.2,36.84) 116.08,36.84 114.01,34.76 114.01,33.84 113.9,33.74 JDIMM1.166 ; v2(159.1,128.09) UV7.F10 v2(159.9,127.29) 159.5,126.89 UV7.G10 ; JDIMM1.69 87.65,39.86 v2(88.19,39.32) ; v2(163.1,120.09) UV7.T5 163.49,119.69 v2(163.1,119.29) ; UV7.R14 156.29,120.49 v2(155.7,120.49) ; v2(207.46,99.46) 207.06,99.06 UV9.E3 ; UV8.R11 v2(208.26,79.88) 207.86,80.28 UV8.P10 ; v2(121.39,30.84) 120.66,30.12 JDIMM2.193 ; v2(174.4,124.39) v2(175,124.39) 175.1,124.49 UV6.H1 v2(176,124.09) UV6.H2 v2(176.8,124.89) ; UV1.AH13 159.61,86.06 v2(160,85.66) ; v2(197.86,79.88) 198.26,80.28 UV8.B10 ; v2(206.02,33.25) 206.24,33.47 207.31,33.47 207.45,33.33 JNGFF2.15 ; JDIMM2.89 92.66,29.13 v2(92.21,29.58) ; PU1402.23 101.55,126.8 v2(101.55,126.8) ; v2(164.7,131.29) 165.1,131.69 UV7.A3 165.1,131.69 v2(165.5,132.09) ; JDIMM2.243 133.16,29.94 132.85,30.24 v2(132.66,30.24) 132.38,30.24 132.06,29.92 132.06,29.21 132.16,29.11 JDIMM2.239 ; UV1.K32 175.06,101.48 v2(175.06,101.47) ; v2(164.7,118.49) 165.09,118.89 UV7.U3 ; v2(93.74,29.58) 93.66,29.5 JDIMM2.93 ; UV1.AH30 v2(160.06,99.88) UV1.AH29 v2(159.19,99.01) UV1.AH28 ; UV1.C28 180.49,98.58 v2(180.09,98.98) ; UV8.D10 v2(199.46,79.88) UV8.C11 199.06,79.48 v2(198.66,79.08) 199.06,78.68 UV8.C12 199.06,78.68 v2(199.46,78.28) ; JDIMM1.188 119.4,31.71 v2(119.25,31.55) 119.39,31.41 120.07,31.41 120.4,31.75 JDIMM1.192 ; JNGFF2.57 207.02,22.83 206.23,23.61 206.23,23.89 v2(206.21,23.92) 206.23,23.92 206.75,24.44 207.76,24.44 207.87,24.33 JNGFF2.51 ; UV1.AB2 164.64,75.49 v2(164.53,75.38) ; JDIMM1.19 75.15,39.6 v2(74.92,39.37) ; JDIMM2.51 83.16,29.9 v2(83.83,30.57) ; JDIMM2.5 71.66,29.16 71.38,29.44 70.88,29.44 70.66,29.22 JDIMM2.1 70.66,26.98 70.29,26.61 v2(70.29,26.56) ; v2(125.18,42.56) 124.65,42.03 JDIMM1.209 ; v2(125.18,42.56) 125.65,42.08 JDIMM1.213 ; v2(135.93,31.51) 136.1,31.51 136.4,31.82 JDIMM1.256 ; v2(94.88,26.66) 94.9,26.66 95.16,26.91 JDIMM2.99 ; v2(174.4,120.49) v2(175,120.49) 175.6,120.49 UV6.C1 175.6,120.49 v2(176,120.09) ; v2(121.42,18.66) 121.45,18.69 121.45,18.71 121.41,18.75 JDIMM2.196 ; v2(88.41,21.22) JDIMM2.72 v2(88.41,18.67) ; JDIMM1.52 83.4,34.2 v2(83.32,34.28) ; UV7.C4 v2(164.7,129.69) 165.1,130.09 ; UV7.C4 163.9,129.69 v2(163.9,129.69) ; JDIMM2.181 117.66,27.27 118.34,26.59 v2(118.51,26.59) ; JNGFF2.9 209.73,34.83 v2(209.85,34.7) ; v2(96.91,18.66) JDIMM2.106 ; v2(172.57,101.51) 172.17,101.91 UV1.N32 172.11,101.91 v2(171.71,102.31) 171.74,102.31 UV1.N33 ; UV1.AH2 159.32,76.59 159.32,76.57 159.25,76.49 159.26,76.49 v2(159.27,76.51) ; UV1.N28 171.74,98.21 v2(171.71,98.21) ; UV1.G13 v2(177.61,86.48) v2(178.04,86.06) ; JDIMM1.168 114.4,33.56 114.5,33.66 114.5,34.22 115.91,35.63 v2(116.2,35.63) ; v2(180.09,93.98) 180.49,93.58 UV1.C22 ; v2(135.89,30.85) 135.8,30.85 135.4,31.24 JDIMM1.252 ; JDIMM2.36 79.41,18.85 v2(79.28,18.72) ; v2(186.6,131.69) v2(186.6,132.49) v2(187.2,132.49) 187.2,131.69 v2(187.2,131.69) v2(186.6,131.69) ; v2(186.6,131.69) UV6.U14 ; UV7.J10 159.5,125.29 159.6,125.19 v2(160.08,125.19) ; v2(93.72,43.55) 93.1,43.55 91.65,42.1 JDIMM1.85 ; JDIMM1.26 76.9,31.72 v2(77.26,31.36) ; v2(154.29,100.63) 154.36,100.7 155.02,100.7 v2(155.09,100.63) 155.49,100.23 UV1.AN30 v2(155.09,99.81) ; v2(210.26,88.68) v2(210.26,88.08) ; v2(210.26,88.08) v2(211.06,88.08) v2(211.06,88.68) ; v2(210.26,88.08) UV8.U1 ; UV7.R12 157.9,120.49 v2(158.3,120.09) 158.69,120.49 UV7.R11 158.7,120.49 v2(159.1,120.89) 159.49,121.29 UV7.P10 ; JDIMM1.167 114.15,42.11 114.34,42.3 114.94,42.3 115.15,42.09 JDIMM1.171 ; v2(84.76,39.59) 84.65,39.69 JDIMM1.57 84.65,41.95 84.91,42.21 85.47,42.21 85.65,42.03 JDIMM1.61 ; 128.86,18.72 v2(128.86,18.69) ; 128.86,18.72 128.11,18.72 127.91,18.92 JDIMM2.222 ; 128.86,18.72 128.87,18.72 128.91,18.75 JDIMM2.226 ; v2(182.4,129.69) 182.4,129.69 182.8,129.29 UV6.P10 ; v2(167.56,98.21) 167.54,98.21 UV1.W28 ; v2(80.64,26.61) 80.41,26.61 80.16,26.86 JDIMM2.39 ; UV1.C13 v2(180.09,86.46) ; v2(203.46,106.66) UV9.K13 v2(202.66,107.46) UV9.K14 ; v2(159.1,128.89) UV7.D10 v2(159.9,129.69) ; JDIMM1.39 80.15,39.98 79.18,39 78.55,39 78.52,38.98 78.52,39.03 v2(78.53,39.04) ; v2(156.73,93.13) 156.73,93.17 ; 156.73,93.17 157.09,92.81 UV1.AL21 UV1.AL20 ; UV1.AJ7 158.74,81.13 v2(158.37,81.5) 158.33,81.5 UV1.AK7 ; UV9.L10 v2(201.86,105.06) UV9.M10 v2(201.06,105.06) ; v2(177.57,100.71) 177.17,100.31 UV1.G30 ; 206.22,18.83 206.22,18.63 206.52,18.33 JNGFF2.75 ; 206.22,18.83 v2(206.22,19.12) 206.43,19.33 JNGFF2.71 ; 206.22,18.83 JNGFF2.73 ; JDIMM2.15 74.16,29.23 74.74,29.81 v2(74.89,29.81) ; UV6.G10 v2(183.2,123.29) 182.8,122.89 UV6.F10 v2(183.2,122.49) ; JDIMM2.65 86.66,29.49 v2(86.75,29.58) 86.61,29.72 85.87,29.72 85.66,29.5 JDIMM2.61 ; JDIMM1.6 71.9,31.57 71.84,31.51 v2(71.84,31.46) 71.36,31.46 70.9,31.91 JDIMM1.2 ; UV9.G5 205.46,100.66 v2(205.86,101.06) 206.26,100.66 UV9.F5 206.26,100.66 v2(206.66,100.26) ; v2(156.69,98.98) 157.09,98.58 UV1.AL28 ; JDIMM2.2 70.91,19.09 71.34,18.66 v2(71.53,18.66) 71.91,19.03 JDIMM2.6 ; v2(184.52,23.61) 184.31,23.41 JNGFF1.1 ; JDEG1.10 253.72,35.04 v2(254.12,35.43) ; v2(157.49,99.81) UV1.AL30 156.69,100.61 v2(156.69,100.63) ; JDIMM1.89 92.65,42.09 93.48,42.92 v2(93.72,42.92) ; v2(198.66,83.88) 198.26,84.28 UV8.B5 198.26,84.28 v2(197.86,83.88) ; JDIMM1.107 97.15,41.9 v2(97.57,42.31) 97.31,42.56 96.88,42.56 96.15,41.83 JDIMM1.103 ; v2(118.37,18.69) 118.37,18.69 118.37,18.69 118.37,18.69 118.38,18.69 118.38,18.71 118.35,18.71 118.41,18.77 JDIMM2.184 ; v2(176.79,95.63) 176.79,95.66 UV1.G25 v2(177.61,96.48) 177.62,96.48 v2(178.04,96.06) ; v2(75.02,18.72) 74.91,18.83 JDIMM2.18 ; v2(78.36,21.55) 78.21,21.55 77.91,21.24 JDIMM2.30 77.91,18.75 v2(77.94,18.72) ; JNGFF1.7 v2(185.81,20.73) ; v2(178.4,123.29) UV6.G5 178.8,123.69 v2(179.2,123.29) 178.8,122.89 UV6.F5 178.8,122.89 v2(179.2,122.49) ; PU1400.4 v2(124.66,130.04) ; JDIMM1.22 75.9,31.66 75.51,31.27 v2(74.9,31.27) 74.43,31.27 73.9,31.79 JDIMM1.14 ; UV8.L5 205.46,84.28 v2(205.86,83.88) UV8.M5 v2(206.66,84.68) ; JDIMM1.175 116.15,42.07 116.33,42.25 117.5,42.25 117.65,42.1 JDIMM1.181 117.65,39.93 118.4,39.18 118.4,38.45 v2(118.4,38.45) ; JDIMM1.184 118.4,30.74 117.95,30.29 v2(117.69,30.29) 117.42,30.29 116.4,31.3 JDIMM1.176 ; v2(164.7,130.49) 165.1,130.09 ; 165.1,130.09 UV7.C3 ; JDIMM2.201 122.66,27.06 v2(122.32,26.73) 121.96,26.73 121.66,27.03 JDIMM2.197 ; PU1501.4 69.22,111.82 v2(69.19,111.85) ; UV7.L10 v2(159.1,123.29) UV7.M10 v2(159.1,122.49) ; v2(123.19,18.69) 123.07,18.69 122.91,18.84 JDIMM2.202 ; UV7.N3 v2(165.5,121.69) ; UV8.P10 v2(208.26,80.68) ; UV8.P10 v2(207.46,80.68) ; v2(201.06,101.06) 201.46,100.67 UV9.M5 v2(201.86,101.06) 202.26,100.67 UV9.L5 ; UV6.T10 182.8,130.89 v2(182.4,131.29) ; JDIMM1.202 122.9,31.68 123.23,31.36 v2(123.64,31.36) 123.65,31.36 123.9,31.61 JDIMM1.206 ; JDIMM1.238 131.9,31.76 132.18,31.49 v2(132.65,31.49) 132.99,31.49 133.4,31.9 JDIMM1.244 ; JDIMM1.48 82.4,33.61 82.48,33.68 82.48,35.3 81.77,36.02 v2(81.5,36.02) ; v2(180.11,88.98) 180.11,88.94 UV1.C16 ; v2(209.7,28.59) 209.46,28.83 JNGFF2.33 ; UV1.T28 v2(169.22,99.03) v2(169.64,99.46) ; PU1402.4 v2(104.6,129.91) ; v2(72.65,18.66) 72.91,18.91 JDIMM2.10 ; v2(154.99,80.7) 154.99,80.75 155.29,81.06 UV1.AN7 ; JDIMM2.86 91.91,18.9 91.72,18.72 v2(91.15,18.72) 90.91,18.96 JDIMM2.82 ; v2(238.97,24.9) 239.13,25.06 UE6.3 ; v2(154.93,78.81) 154.93,78.8 155.17,78.56 UV1.AN4 ; v2(92.17,80.57) 91.81,80.94 UH1.BJ12 ; v2(163.9,128.09) 163.5,127.69 UV7.F5 163.5,127.69 v2(163.1,127.29) 163.5,126.89 UV7.G5 ; v2(157.49,83.94) 157.51,83.94 UV1.AK10 ; v2(208.66,88.68) v2(208.66,88.08) UV8.R1 ; JDIMM2.206 123.91,18.92 v2(124.14,18.69) 124.17,18.72 124.55,18.72 124.91,19.07 JDIMM2.210 ; UV7.C12 v2(157.5,129.69) ; UV1.AB32 165.04,101.51 v2(165.06,101.51) ; v2(72.45,108.73) 72.36,108.82 PU1501.23 ; JDIMM2.180 117.41,18.84 v2(117.56,18.68) ; UV6.R11 183.6,130.09 v2(183.2,129.69) 183.2,129.69 UV6.P10 ; v2(185.6,129.69) 185.6,129.69 UV6.R14 v2(186.6,130.09) ; v2(210.26,76.48) v2(210.26,75.88) ; v2(172.14,99.46) 172.56,99.88 v2(172.57,99.88) UV1.N30 ; JDIMM2.9 72.66,27.06 72.81,26.9 v2(72.81,26.85) ; JDIMM1.226 128.9,30.61 v2(129.04,30.47) ; v2(75.02,42.26) 74.5,42.26 74.15,41.92 JDIMM1.15 ; JDIMM2.231 130.16,29.29 130.45,29.58 v2(131.07,29.58) 131.16,29.5 JDIMM2.235 ; v2(135.93,29.42) 135.43,29.42 135.16,29.14 JDIMM2.251 ; UV9.A12 v2(209.86,106.66) ; JDIMM2.56 84.41,18.92 84.61,18.72 v2(85.37,18.72) 85.41,18.75 JDIMM2.60 ; v2(91.82,35.16) 91.79,35.13 91.79,35.09 90.9,34.2 JDIMM1.82 90.9,31.73 90.73,31.55 90.13,31.55 89.9,31.78 JDIMM1.78 ; v2(162.56,99.03) UV1.AE28 162.54,98.21 v2(162.56,98.21) ; UV8.U12 v2(209.86,78.28) ; JDIMM1.205 123.65,42.32 v2(125.21,43.88) ; UV8.A14 197.46,77.08 v2(197.46,76.48) ; v2(138.11,32.02) 137.71,32.02 137.4,32.32 JDIMM1.260 ; UV7.C11 158.7,130.09 v2(159.1,130.49) UV7.B10 ; v2(126.23,34.86) 125.91,34.86 124.9,33.85 JDIMM1.210 ; UV7.U12 157.9,118.89 v2(158.3,118.49) ; v2(131.07,30.72) 130.73,30.72 129.9,31.55 JDIMM1.230 ; JDIMM2.57 84.66,29.01 v2(83.85,29.82) ; v2(93.74,34) 93.9,33.83 JDIMM1.94 ; v2(77.16,26.76) JDIMM2.27 ; UV6.E1 v2(175,122.09) ; v2(177.61,88.98) UV1.G16 ; v2(155.09,102.31) UV1.AP33 154.31,102.33 v2(154.28,102.33) ; UV1.E10 v2(178.46,83.13) v2(178.04,83.56) v2(177.61,83.98) UV1.G10 ; UV8.F5 v2(201.86,84.68) 202.26,84.28 UV8.G5 v2(201.86,83.88) UV8.F5 ; UV8.F5 v2(201.06,83.88) ; v2(161.71,104.61) 161.86,104.61 v2(162.56,103.91) 162.51,103.91 v2(161.71,103.11) 162.11,102.71 UV1.AE33 162.16,102.71 v2(162.56,102.31) 162.17,101.91 UV1.AE32 ; JDIMM1.1 70.65,42.11 70.85,42.3 71.47,42.3 71.65,42.11 JDIMM1.5 71.65,39.83 71.6,39.83 v2(71.51,39.74) ; v2(159.04,90.71) 159.28,90.95 159.48,90.95 UV1.AH19 ; v2(86.12,81.4) 85.7,81.81 UC1.3 ; v2(88.62,31.49) 87.67,31.49 87.4,31.75 JDIMM1.68 ; JDIMM1.231 130.15,42.1 130.46,42.41 131.04,42.41 131.06,42.39 v2(131.1,42.39) 131.1,42.34 131.15,42.29 JDIMM1.235 ; JDIMM1.65 86.65,39.31 87.95,38.01 v2(88.19,38.01) ; UV8.G10 v2(201.86,79.88) 201.86,79.88 UV8.F10 v2(201.06,79.88) ; UV7.H13 v2(157.5,125.69) ; UV9.U3 v2(197.06,98.66) ; JDIMM2.213 125.66,29.28 v2(124.85,30.09) 124.66,29.9 JDIMM2.209 ; v2(182.4,128.89) 182.4,128.89 UV6.P10 ; JDIMM2.166 113.91,21.06 v2(113.59,21.38) ; JDIMM2.68 87.41,18.85 87.28,18.72 v2(86.64,18.72) ; v2(154.11,76.43) 154.21,76.43 UV1.AP2 UV1.AN1 ; v2(179.2,121.69) 179.84,121.05 179.84,120.39 179.14,119.69 UV6.B5 ; v2(176.79,90.63) 176.79,90.66 UV1.G19 ; v2(184.8,128.89) 184.4,128.49 UV6.N12 184.4,128.49 v2(184,128.89) ; JDIMM2.256 136.41,18.16 v2(136.57,17.99) ; v2(75.02,42.9) 75.47,42.9 76.15,42.21 JDIMM1.23 ; v2(126.71,18.66) 126.91,18.85 JDIMM2.218 ; JDIMM1.180 117.4,33.87 v2(118.42,34.89) ; UV9.H13 v2(204.26,106.66) ; JDIMM2.85 91.66,27.06 92.11,26.61 v2(92.21,26.61) ; v2(179.29,96.48) 179.29,96.46 UV1.E25 ; v2(197.87,101.05) 198.26,100.67 UV9.T5 v2(198.66,101.06) ; UV1.B22 181.69,93.96 v2(181.69,93.98) ; v2(89.7,26.7) 89.21,26.7 88.66,27.25 JDIMM2.73 ; v2(208.26,104.26) 207.86,104.66 UV9.D10 v2(207.46,105.06) ; v2(211.06,108.46) v2(210.26,108.46) ; v2(210.26,108.46) v2(210.26,109.06) ; v2(210.26,108.46) UV9.A14 ; v2(184.8,120.89) 184.4,120.49 UV6.C12 184.4,120.49 v2(184,120.09) UV6.C11 v2(183.2,120.89) UV6.D10 ; UV6.L5 178.8,126.89 v2(179.2,127.29) UV6.M5 v2(178.4,128.09) ; UV1.E7 v2(178.46,80.63) UV1.F7 177.66,81.43 177.61,81.43 UV1.G7 ; v2(88.63,29.48) 87.97,29.48 87.66,29.17 JDIMM2.69 ; JDIMM1.189 119.65,41.99 119.47,42.17 118.94,42.17 118.65,41.88 JDIMM1.185 ; UV1.AH32 v2(159.24,102.31) UV1.AH33 159.24,103.11 v2(159.21,103.11) ; JDIMM1.201 122.65,40.01 122.44,39.79 121.96,39.79 121.65,40.1 JDIMM1.197 ; v2(176.79,98.21) UV1.G28 v2(177.61,99.03) ; v2(200.26,86.28) 200.66,85.88 UV8.E3 ; UV8.T10 v2(209.86,80.68) ; UV1.B25 181.29,96.03 v2(180.89,95.63) 180.49,96.03 UV1.C25 ; v2(131.38,18.66) 131.6,18.66 131.91,18.96 JDIMM2.238 ; v2(116.22,34.38) 115.97,34.38 115.4,33.82 JDIMM1.172 ; UV1.A33 v2(182.49,103.11) ; v2(77.26,30.77) 77.45,30.77 77.9,31.22 JDIMM1.30 ; v2(243.09,33.14) 243.02,33.07 JLPDE1.9 ; PU1500.23 91.26,126.8 v2(91.26,126.8) ; v2(84.76,34.51) 84.4,34.16 JDIMM1.56 84.4,31.78 84.59,31.59 85.22,31.59 85.4,31.78 JDIMM1.60 ; v2(164.22,98.21) 164.24,98.21 UV1.AB28 ; v2(120.71,70.26) 121.22,69.75 RH149.1 ; UV1.D31 v2(180.09,101.51) ; v2(92.62,18.65) 92.76,18.79 92.76,18.79 92.91,18.94 JDIMM2.90 ; v2(206.66,79.88) 206.26,80.28 UV8.M10 v2(205.86,80.68) UV8.L10 ; v2(170.06,101.51) 170.04,101.51 UV1.T32 ; UV8.R12 208.66,78.68 v2(209.06,78.28) ; v2(121.61,126.93) 121.62,126.93 PU1400.23 ; UV1.E5 v2(179.29,78.91) ; v2(174.64,99.46) 174.24,99.86 v2(174.24,99.91) UV1.K30 ; v2(183.09,76.51) 183.09,76.31 v2(182.49,75.71) v2(181.69,76.51) ; v2(83.37,38.96) 83.37,38.96 83.37,39 83.21,39.17 83.21,40.92 JDIMM1.51 83.15,41.98 82.98,42.16 82.41,42.16 82.15,41.9 JDIMM1.47 ; v2(209.86,104.26) 209.46,104.66 UV9.B10 v2(209.06,105.06) 208.66,105.46 UV9.C11 ; v2(133.31,38.24) 133.31,38.24 133.31,38.45 133.15,38.6 JDIMM1.243 ; UV9.N1 v2(200.66,96.86) ; v2(181.69,98.98) 181.29,98.58 UV1.B28 ; JDIMM1.86 91.9,31.84 92.23,31.51 92.65,31.51 92.9,31.76 JDIMM1.90 92.9,34.08 93.48,34.66 v2(93.74,34.66) ; UV6.E12 v2(184.8,121.69) ; UV1.AC18 163.09,90.31 v2(163.54,89.87) 162.98,89.31 UV1.AC17 ; v2(86.75,31.36) 86.4,31.71 JDIMM1.64 ; UV1.AE30 161.74,100.71 v2(161.71,100.71) ; UV1.K5 174.67,79.31 v2(175.06,78.91) ; v2(78.32,26.66) 78.16,26.82 JDIMM2.31 ; v2(201.06,98.66) 200.66,99.06 UV9.N3 ; v2(172.55,77.27) 172.5,77.27 UV1.N2 ; UV9.N12 v2(201.06,106.66) ; UV6.L10 182.8,126.89 v2(182.4,127.29) 182.8,127.69 UV6.M10 182.8,127.69 v2(183.2,128.09) ; UV1.A2 v2(181.69,76.51) ; v2(181.69,76.51) UV1.B1 ; UV1.AB30 v2(164.22,99.88) ; v2(121.4,31.52) JDIMM1.196 ; RH148.1 124.6,68.62 RH150.1 122.69,67.99 119.81,67.99 v2(119.37,67.55) ; UV1.AE5 162.32,79.48 v2(162.32,80) 162.32,80.83 UV1.AE7 ; v2(175.02,80.51) 175.02,80.63 UV1.K7 ; JDIMM1.222 127.9,34.18 v2(128.08,34.36) ; JDIMM1.251 135.15,39.96 v2(135.67,39.44) ; v2(95.69,34.66) 95.39,34.66 94.9,34.18 JDIMM1.98 ; UV1.G22 v2(176.76,93.13) ; v2(126.88,29.45) 126.66,29.23 JDIMM2.217 ; v2(165.5,120.09) UV7.R3 165.09,120.49 v2(164.7,120.09) UV7.R4 ; UV1.B4 181.29,78.53 v2(181.69,78.13) ; PU1401.23 111.46,126.93 v2(111.45,126.93) ; UV1.B34 v2(180.89,103.11) ; UV1.K28 175.04,98.21 v2(175.06,98.21) ; v2(179.29,93.13) 179.29,93.16 UV1.E22 ; JDIMM1.93 93.65,42.22 v2(93.72,42.28) ; JDIMM2.78 89.91,18.87 v2(89.75,18.72) ; JDIMM1.35 79.15,42.23 v2(78.97,42.41) ; JDIMM2.35 79.16,29.35 79.51,29.71 v2(80.25,29.71) ; v2(72.9,34.29) JDIMM1.10 ; v2(72.83,39.51) 72.65,39.69 JDIMM1.9 ; v2(134.24,18.02) 134.41,18.19 JDIMM2.248 ; v2(156.7,121.69) 156.69,121.69 UV7.N14 v2(155.7,122.09) ; UV9.C12 v2(209.06,106.66) ; JDIMM2.230 129.91,18.95 129.92,18.95 v2(130.2,18.67) 130.55,18.67 130.91,19.03 JDIMM2.234 ; JDIMM2.98 94.91,21.14 94.64,21.4 94.21,21.4 94.14,21.33 v2(93.91,21.33) JDIMM2.94 ; JDIMM2.192 v2(120.41,18.66) ; PU1500.4 v2(94.31,129.91) ; UV1.T7 169.23,80.6 v2(169.23,80.56) 169.5,80.28 169.5,79.44 UV1.T5 ; UV8.K2 v2(205.06,87.08) ; UV1.C7 180.89,80.66 v2(180.89,80.63) 181.29,81.03 UV1.B7 181.69,80.66 v2(181.69,80.63) ; v2(177.57,76.51) 177.54,76.51 UV1.G2 177.17,76.91 v2(177.57,77.31) 177.16,77.71 UV1.G3 ; v2(203.46,78.28) UV8.H13 v2(202.66,77.48) 203.06,77.08 UV8.H14 ; UV8.N3 v2(207.46,85.48) ; UV8.E12 200.66,78.68 v2(200.26,78.28) ; v2(126.9,31.36) JDIMM1.218 ; v2(125.91,21.28) JDIMM2.214 ; JNGFF2.45 v2(207.49,25.83) ; JDIMM1.99 95.15,39.72 94.78,39.34 94.78,37.56 95.75,36.58 v2(95.91,36.58) ; JDIMM2.252 v2(135.41,21.39) ; UV8.U3 v2(209.86,86.28) ; UV6.U12 v2(184.8,131.29) ; JNGFF1.67 v2(202.81,20.44) ; 178,120.49 UV6.C4 v2(177.6,120.89) 177.2,120.49 UV6.C3 177.2,120.49 v2(177.6,120.09) 178,120.49 ; 199.06,85.08 v2(198.66,85.48) 199.06,85.88 UV8.C3 v2(199.46,85.48) UV8.C4 199.06,85.08 ; 199.06,99.86 UV9.R4 v2(198.66,99.46) 199.06,99.07 UV9.R3 v2(199.46,99.46) 199.06,99.86 ; 180.89,83.96 UV1.B10 180.89,83.16 UV1.C10 180.89,83.96
  BOTTOM w0.33: v2(82.61,18.66) 82.41,18.85 JDIMM2.48 ; JDIMM2.40 80.41,19.05 80.74,18.72 v2(81.05,18.72) ; v2(86.64,18.72) 86.41,18.95 JDIMM2.64
  BOTTOM w0.356: CT81.2 v2(61.26,50.28) ; v2(169.21,77.3) 169.44,77.07 169.45,77.07 169.61,76.91 UV1.T2 ; v2(177.61,99.03) 178.04,98.61 UV1.F28 ; v2(177.63,79.74) 177.2,79.31 UV1.G5
  BOTTOM w0.381: UV7.H14 156.3,126.09 ; UV1.R23 v2(170.39,94.81) UV1.T22 ; UV1.T15 v2(170.39,86.81) UV1.R14 ; UV1.P13 v2(172.39,84.81) UV1.N12 ; UV1.P20 v2(171.39,91.81) UV1.R19 ; UV1.R12 170.42,84.78 170.41,84.78 170.41,84.79 v2(170.39,84.81) UV1.T13 ; UV1.Y21 v2(166.39,92.81) UV1.W20 ; UV1.V19 168.28,90.92 v2(168.41,90.92) 168.5,90.92 UV1.U19 ; v2(289.44,41.14) 289.49,41.09 CI24.2 ; v2(174.44,87.61) 174.14,87.31 UV1.M15 v2(173.29,87.91) UV1.N16 ; UV1.AB16 163.89,88.26 v2(163.42,87.78) 162.94,87.31 UV1.AC15 ; UV1.AA20 v2(165.39,91.81) UV1.Y19 ; UV1.Y16 v2(165.39,87.81) UV1.AA15 ; UV1.AB21 163.41,93.79 v2(163.41,93.82) 163.38,93.82 UV1.AC22 ; UV1.Y14 v2(166.39,86.81) UV1.W15 ; UV1.P18 v2(172.39,89.81) UV1.P17 ; PQ200.1 v2(49.22,44.89) ; UV1.P15 171.48,87.72 v2(171.38,87.72) 171.38,87.81 UV1.R16 ; v2(168.39,84.95) 168.39,84.81 ; 168.39,84.81 UV1.U12 ; 168.39,84.81 168.39,84.8 UV1.V12 ; DI7.3 v2(293.81,52.19) ; PC1677.2 v2(176.55,50.14) ; v2(185.6,128.09) 186,128.49 UV6.N14 v2(186.6,128.49) v2(187.2,128.49) ; UV1.AA17 v2(164.39,89.81) UV1.AA18 ; CE69.2 220.85,30.05 220.73,30.05 220.35,30.42 v2(220.35,30.62) 220.35,31.28 221.15,32.07 CE84.1 ; UV1.T18 v2(170.39,89.81) UV1.T17 ; UV1.N14 v2(173.39,85.81) UV1.M13 v2(174.29,84.91) ; v2(167.57,95.82) 167.57,95.81 167.57,95.62 UV1.V23 v2(168.39,94.81) UV1.U23 ; UV1.Y12 v2(166.39,84.81) UV1.W13 ; UV1.W18 v2(166.39,89.81) UV1.W17 ; v2(141.74,78.1) 142.23,77.6 UV14.3 ; UV1.M22 173.54,93.96 v2(173.54,93.79) 173.37,93.79 UV1.N21 ; v2(167.9,126.07) v2(167.3,126.07) ; UV1.T20 170.39,92.81 v2(170.39,93.08) 170.49,93.17 170.76,93.17 UV1.R21 ; UV1.Y23 v2(166.39,94.81) UV1.W22 ; PR808.2 PR810.2 223.53,39.41 223.53,39.03 223.76,38.8 224.42,38.8 v2(224.7,38.52) ; UV1.V21 v2(168.39,92.81) UV1.U21 ; UV1.U14 v2(168.39,86.81) UV1.V14 ; UV1.AC13 163.38,85.8 v2(163.41,85.8) 163.43,85.83 163.43,85.85 UV1.AB14 ; CE66.2 226.98,28.74 227.39,28.34 v2(227.39,28.13) ; v2(292.69,33.11) 292.67,33.14 DI9.3 ; UV1.U16 v2(168.39,88.81) UV1.V16 ; v2(165.5,124.89) 165.9,124.49 UV7.K2 v2(166.3,124.09) 166.7,124.49 UV7.K1 167.2,124.49 v2(167.3,124.39) ; UV1.M17 v2(174.39,89.81) UV1.M18 ; UV1.AB19 163.41,91.79 v2(163.41,91.86) 163.34,91.86 UV1.AC20 ; UV1.N19 173.37,91.79 v2(173.59,91.79) 173.59,92.01 UV1.M20 173.89,92.26 v2(174.44,91.71) ; UV1.AB23 163.95,95.31 v2(164.37,94.88) 164.89,94.37 UV1.AA22 ; UV1.N23 172.36,94.78 v2(172.27,94.78) 172.27,94.69 UV1.P22 ; UV1.AB12 v2(164.39,84.81) UV1.AA13
  BOTTOM w0.4: v2(174.4,131.69) v2(175,131.69) v2(175,132.49) v2(174.4,132.49) ; v2(175.69,104.06) 175.69,105.45 v2(175.89,105.64) ; v2(167.9,120.49) v2(167.3,120.49) ; v2(155.1,128.49) v2(155.7,128.49) ; 180.89,83.96 v2(180.89,83.98) ; v2(210.26,76.48) v2(211.06,76.48) v2(211.06,75.88) ; 180.89,83.16 v2(180.89,83.13) ; v2(167.9,124.39) v2(167.3,124.39) ; v2(197.46,88.08) v2(197.46,88.68) v2(196.86,88.68) ; v2(207.06,96.26) v2(207.06,96.86) ; v2(166.71,102.31) 166.74,102.31 UV1.W32 ; 156.3,126.09 v2(155.71,126.09) ; v2(182.49,83.13) v2(182.49,83.98) ; 176.74,102.31 v2(176.71,102.31) ; v2(174.4,118.89) v2(175,118.89) v2(175,118.29) ; v2(174.4,128.49) v2(175,128.49) ; v2(207.06,88.68) v2(207.06,88.08) ; v2(167.3,128.49) v2(167.9,128.49) ; v2(196.86,75.88) v2(196.86,76.48) ; v2(211.06,96.26) v2(211.06,96.86) ; v2(203.84,88.68) v2(203.84,88.08) ; v2(197.46,96.26) 197.46,96.86 v2(197.46,96.86) v2(196.86,96.86) v2(196.86,96.26) ; UV9.E14 v2(207.06,108.46) v2(207.06,109.06) ; v2(155.1,131.69) v2(155.7,131.69) v2(155.7,132.49) v2(155.1,132.49) ; v2(207.06,76.48) v2(207.06,75.88) ; 156.74,102.31 v2(156.71,102.31) ; v2(155.7,120.49) v2(155.1,120.49) ; v2(197.46,109.06) v2(197.46,108.46) v2(196.86,108.46) v2(196.86,109.06) v2(197.46,109.06)
  BOTTOM w0.406: v2(201.06,87.08) UV8.E1 200.66,87.55 v2(200.66,88.08) ; v2(156.7,130.49) 156.3,130.09 UV7.C14 v2(155.7,130.09) v2(155.1,130.09) ; v2(204.99,75.89) 204.99,76.15 v2(204.66,76.48) 204.66,77.08 UV8.K14 ; UV9.U14 197.46,107.87 v2(197.46,108.46) ; v2(179.22,102.27) 179.64,102.69 UV1.D33 v2(179.64,103.36) ; UV9.H2 v2(204.26,97.86) 204.66,97.46 UV9.H1 204.66,96.96 v2(204.56,96.86) v2(204.56,96.26) ; v2(155.1,122.09) v2(155.7,122.09) ; v2(158.3,128.09) UV7.E12 v2(157.5,128.89) ; v2(166.3,129.69) 166.7,130.09 UV7.C1 v2(167.3,130.09) v2(167.9,130.09) ; v2(209.06,98.66) 208.66,99.06 UV9.C3 208.66,99.06 v2(208.26,99.46) 208.26,99.46 UV9.C4 208.66,99.86 v2(209.06,100.26) UV9.B5 ; UV7.A12 v2(157.5,131.29) ; v2(198.66,87.08) 199.06,87.48 UV8.C1 199.06,87.48 v2(199.06,88.08) v2(199.06,88.68) ; v2(175,118.89) 175.6,118.89 UV6.A1 ; UV6.K14 v2(186.6,126.09) v2(187.2,126.09) v2(187.2,126.89) ; UV6.K2 UV6.K1 175.5,126.19 v2(175,126.19) v2(174.4,126.19) ; v2(210.66,99.46) 210.26,99.06 UV9.A3 v2(209.86,98.66) ; v2(176,130.49) 175.6,130.09 UV6.R1 v2(175,130.09) v2(174.4,130.09) ; v2(47.56,39.08) 47.85,39.38 PQ203.4 ; v2(176,128.89) 175.6,128.49 UV6.N1 v2(175,128.49) ; v2(186.6,130.09) v2(187.2,130.09) ; v2(202.96,96.86) 203.06,96.96 UV9.K1 203.06,97.46 v2(202.66,97.86) 202.66,97.86 UV9.K2 203.06,98.26 v2(203.46,98.66) ; v2(175,131.69) UV6.U1 v2(176,132.09) ; v2(208.66,75.88) v2(208.66,76.48) 208.66,77.08 UV8.R14 v2(208.26,77.48) ; v2(166.3,120.89) UV7.R1 v2(167.3,120.49) ; v2(210.26,96.26) v2(210.26,96.86) ; v2(210.26,96.86) v2(211.06,96.86) ; v2(210.26,96.86) UV9.A1 210.26,97.46 v2(210.66,97.86) ; v2(157.5,124.89) 157.12,124.51 157.12,124.51 UV7.K13 v2(156.7,124.09) UV7.K14 ; v2(197.86,97.86) UV9.U1 197.46,97.46 v2(197.46,96.86) ; v2(155.7,128.49) UV7.E14 ; UV7.E14 156.3,128.49 v2(156.7,128.89) ; UV7.E14 v2(156.7,128.09) ; v2(184,118.49) 184.4,118.89 UV6.A12 ; UV9.H14 v2(204.66,108.46) v2(204.66,109.06) ; v2(208.66,96.26) v2(208.66,96.86) UV9.C1 208.66,97.46 v2(209.06,97.86) ; v2(204.66,88.68) v2(204.66,88.08) 204.66,87.48 UV8.K1 v2(205.06,87.08) ; v2(185.6,121.69) 186,122.09 UV6.E14 v2(186.6,122.09) v2(187.2,122.09) ; v2(155.7,131.69) UV7.A14 ; v2(199.06,75.88) v2(199.06,76.48) 199.06,77.08 UV8.C14 199.06,77.08 v2(198.66,77.48) ; v2(207.06,76.48) 207.06,77.08 UV8.N14 ; v2(199.46,97.86) UV9.R1 v2(199.06,96.86) v2(199.06,96.26) ; v2(184.8,125.69) 185.2,126.09 UV6.K13 ; v2(207.46,97.86) 207.06,97.46 UV9.E1 v2(207.06,96.86) ; v2(206.66,107.46) UV9.E14 ; 163.5,130.89 UV7.B5 ; v2(167.3,128.49) UV7.E1 166.7,128.49 v2(166.3,128.09) ; UV6.B10 v2(183.2,119.29) ; v2(199.06,109.06) v2(199.06,108.46) 199.06,107.87 UV9.R14 199.06,107.86 v2(198.66,107.46) ; UV8.K13 v2(204.26,78.28) ; v2(206.66,87.08) UV8.N1 v2(207.06,88.08) ; v2(202.96,88.68) v2(202.96,88.08) 203.06,87.98 UV8.H1 v2(202.66,87.08) UV8.H2 v2(203.46,86.28) ; v2(209.86,100.26) 209.46,100.66 UV9.B5 ; v2(200.66,109.06) v2(200.66,108.46) 200.66,107.87 UV9.N14 200.26,107.47 v2(200.26,107.46) ; v2(208.66,109.06) v2(208.66,108.46) UV9.C14 v2(208.26,107.46) ; v2(210.26,76.48) UV8.U14 ; v2(200.26,77.48) 200.66,77.08 UV8.E14 200.66,77.08 v2(200.66,76.48) v2(200.66,75.88) ; v2(200.66,96.26) v2(200.66,96.86) ; UV9.B5 209.86,101.06 v2(209.86,101.06) ; UV7.R14 156.3,120.49 v2(156.7,120.09) ; v2(187.2,120.49) v2(186.6,120.49) UV6.C14 186,120.49 v2(185.6,120.09)
  BOTTOM w0.457: v2(211.06,75.88) 210.91,75.73 CV887.2 ; v2(48.88,39.14) 49.15,39.14 PC204.2 ; CV393.2 195.94,88.68 v2(196.86,88.68) ; v2(152.58,77.49) 151.74,76.65 QV88.1 ; v2(210.26,88.68) 210.26,89.94 CV889.2 ; v2(259.42,24.32) 260,23.74 260,23 CD93.2 ; CL33.2 287.3,99.5 v2(286.45,98.64)
  BOTTOM w0.508: v2(177.05,60.12) 177.05,60.95 176.07,61.93 UV23.3 ; v2(55.31,17.03) 55.38,17.11 PR405.1 ; v2(231.25,20.61) 231.28,20.59 RE23.2 CE82.2 ; YH2.2 v2(185.9,44.57) ; JUART.6 v2(215.61,64.2) ; RV591.2 152.77,72.99 152.19,73.56 152.07,73.56 v2(151.8,73.83) ; v2(179.66,18.07) 179.38,18.35 CH50.1 ; v2(167.9,128.49) 167.95,128.43 168.6,128.43 168.73,128.56 CV856.2 ; v2(187.2,128.49) 187.89,128.49 188.22,128.82 CV871.2 ; PQ201.3 46.75,47.12 v2(46.24,46.6) ; QE24.4 286.92,56.49 v2(287.16,56.25) ; v2(26.98,42.99) 26.93,42.94 PC321.2 ; v2(50.94,45.41) 51.31,45.03 PR204.1 ; v2(89.49,125.62) 89.49,125.82 90.08,126.41 PC1500.2 ; v2(288.29,63.34) 288.29,61.54 SW5.4 ; PR404.2 56.8,23.36 v2(57.24,23.79) ; PC1408.2 v2(128.53,132.83) ; v2(64.07,85.13) PR1105.1 PC1104.1 ; PC1420.1 v2(104.02,132.54) ; v2(96.91,18.66) 96.91,18.33 96.71,18.13 96.48,18.13 96,17.64 CD69.2 ; YL2.4 v2(277.76,45.67) ; CE67.2 225.38,14.77 v2(225.82,14.77) ; RL30.2 286.56,36.9 v2(286.59,36.87) ; CV398.2 200.66,95.11 v2(200.66,96.26) ; v2(234.65,25.26) 234.66,25.26 234.66,25.19 234.96,24.88 CE62.2 CE86.2 RE27.1 ; v2(201.08,112.82) 200.67,112.41 200.67,111.88 ; RH113.2 182.03,35.88 v2(181.54,36.36) ; v2(120.65,125.85) 120.65,126.21 PC1400.2 ; v2(174.4,122.09) 173.09,122.09 CV163.2 ; v2(200.66,75.88) 200.66,74.77 CV389.2 ; PR604.2 v2(253.37,10.66) ; CV181.2 202.96,89.97 v2(202.96,88.68) ; CV863.2 173.09,132.49 v2(174.4,132.49) ; v2(294.78,61.2) 294.85,61.2 CV599.1 ; v2(155.1,132.49) 153.83,132.49 CV864.2 ; CZ44.2 231.61,44.97 v2(231.28,44.64) ; PR411.2 v2(52.71,26.66) ; PC1407.2 v2(127.64,132.83) ; YV1.2 177.4,69.59 v2(177.84,70.02) ; CZ86.2 130.31,99.73 129.81,100.24 v2(129.81,100.92) ; v2(155.1,126.89) 154.47,126.89 154.06,127.29 CV854.2 ; PC602.2 v2(250.83,20.16) ; PC313.1 28.2,30.91 29.03,30.91 v2(29.22,30.72) ; v2(67.07,96.46) PR1143.2 PC1136.2 ; v2(219.14,33.72) 219.14,33.49 219.38,33.25 CD41.2 CD39.2 ; CV598.2 295.08,68.19 294.78,68.19 294.14,68.82 v2(294.01,68.82) ; PQ202.3 47.99,46.05 v2(48.52,46.57) ; v2(200.66,88.68) 200.66,89.98 CV885.2 ; PR406.2 54.49,26.15 54.26,26.38 54.26,26.39 54.16,26.49 v2(54.16,26.58) ; v2(203.06,109.06) 203.06,109.19 203.77,109.9 CV199.2 ; v2(57.26,27.22) 56.91,27.22 PC422.2 ; PR907.2 138.26,110.1 v2(138.21,110.05) ; v2(289.63,56.06) 289.63,56.38 290.14,56.89 DI8.1 ; CL39.2 280.68,54.37 v2(279.71,55.34) ; CV919.2 175.56,59.69 v2(175.89,60.02) 176.01,60.02 176.51,59.51 PR1602.2 ; JHDD1.9 191.67,13.13 191.54,13.26 v2(191.54,13.91) ; v2(76.97,99.28) 77.43,98.82 PC1130.2 ; RH41.2 v2(116.63,104.78) ; CV870.2 188.4,126.83 187.26,126.83 v2(187.2,126.89) ; v2(205.46,109.06) 205.46,110.27 CV880.2 ; v2(58.79,19.52) 58.35,19.09 PR403.1 ; v2(155.15,17.8) 155.04,17.91 CC27.2 ; v2(290.61,37.89) 290.18,37.46 DI10.1 ; v2(146.87,17.86) 147.15,17.58 PC1800.2 ; v2(207.06,96.26) 207.06,95.11 CV194.2 ; PR1116.2 PR1115.2 ; PR1115.2 75.83,82.67 v2(75.96,82.54) ; PR1115.2 PR1114.2 ; CV601.1 295.46,78.91 v2(295.54,78.98) ; RV27.2 172.73,72.96 v2(172.55,72.79) ; CV903.2 186.22,114.06 185.96,113.81 v2(185.2,113.81) ; UH7.3 168.55,15.93 v2(168.74,16.11) ; v2(155.1,122.09) 154.22,122.09 CV865.2 ; RD10.1 v2(205.11,20.49) ; PD401.1 v2(53.1,28.06) ; v2(294.97,17.9) 294.97,17.82 294.46,17.31 CA61.2 ; v2(151.46,17.87) 150.78,18.54 CT79.2 ; v2(124.34,132.71) 124.34,132.07 PC1401.1 ; v2(83.75,91.51) 83.91,91.35 84.34,91.35 RH61.1 ; v2(83.7,87.75) RH188.2 RH57.1 RH59.2 RH58.1 ; CV71.1 175.65,73.17 v2(175.78,73.29) ; v2(48.47,9.29) 48.03,8.84 JBAT10.12 ; v2(177.28,17.16) 177.28,17.4 176.61,18.07 CH45.2 ; v2(204.66,88.68) 204.66,89.92 CV888.2 ; v2(83.7,93.36) 83.71,93.36 83.98,93.36 84,93.34 RH166.1 ; CE85.2 235.39,29.33 CE77.2 235.14,30.29 v2(235.47,30.62) ; v2(239.94,30.6) 240.42,30.11 JLPDE1.12 ; v2(121.19,104.71) 120.61,104.13 PC1389.2 ; JDEG1.11 v2(248.17,37.46) ; PC1124.2 63.43,92.7 v2(63.05,93.08) ; YL2.2 v2(280.51,42.41) ; PC1114.2 v2(64.96,89.65) ; v2(205.24,39.23) 206.55,37.93 JNGFF2.76 ; PC1011.2 203.79,118.05 v2(203.79,118.53) ; PC1135.2 71.51,95.85 71.28,96.08 71.28,97.1 70.78,97.6 PC1138.2 70.62,97.91 v2(70.11,98.42) 69.73,98.03 PC1139.2 ; v2(229.64,41.89) 228.73,40.98 JCAM1.16 ; JCAM1.8 v2(234.02,42.36) ; v2(113.42,132.71) 113.67,132.45 PC1411.1 ; PD101.1 22.34,14.09 v2(21.85,13.6) ; CH48.2 182.81,43.3 v2(182.2,43.3) ; v2(265.44,24.63) RA66.2 CD95.2 ; CV200.2 153.96,126.43 154.24,126.15 155.65,126.15 v2(155.71,126.09) ; RV142.2 205.04,74.99 205.04,75.83 204.99,75.88 v2(204.99,75.89) ; RV142.2 CV895.2 ; RV142.2 CV177.2 ; CL34.2 v2(285.25,39.11) ; RL31.1 v2(280.11,47.48) 279.66,47.92 UL2.2 ; v2(187.2,122.09) 187.26,122.15 187.61,122.15 188.4,121.35 CV872.2 ; v2(97.5,15.94) PR510.2 ; JCAM1.5 v2(237.02,44.64) ; v2(283.35,49.52) 283.4,49.47 CL19.2 ; v2(37.6,16.25) 38.24,16.88 39.05,16.88 PC110.2 ; CV188.2 203.06,96.17 v2(202.96,96.26) ; CV158.2 RV127.2 187.4,125.89 v2(187.2,126.09) ; v2(57.14,39.46) JEDP1.43 58.91,39.46 59.78,40.33 v2(60.51,40.33) ; 200.23,13.93 198.95,15.21 JHDD1.14 ; PC507.2 PC506.2 103.64,7.51 103.79,7.36 v2(104.23,7.36) ; CV597.2 294.84,66.17 v2(295.03,65.98) ; v2(125.24,12.03) 124.24,11.03 JBL1.5 ; PC813.2 219.39,41.6 v2(219.81,42.01) ; CV396.2 207.06,89.83 v2(207.06,88.68) ; v2(138.03,43.42) 137.83,43.63 JDIMM1.262 ; v2(155.2,117.47) 155.81,116.86 CV904.2 ; v2(155.1,124.55) 155.1,124.55 154.19,124.55 PC907.2 ; RE35.2 CE91.2 222.36,23.03 v2(221.84,23.55) 221.45,23.94 CE79.2 ; v2(132.6,130.88) 132.85,130.62 PC1520.1 ; CZ43.2 207.96,51.63 v2(207.68,51.35) ; RV612.2 232.67,16.65 231.99,17.34 v2(231.99,17.58) 231.99,18.06 CV923.2 ; CV862.2 173.05,126.19 v2(174.4,126.19) ; CV859.2 188.45,132.49 v2(187.2,132.49) ; PC323.2 24.83,40.63 24.32,40.12 v2(24.32,39.69) ; v2(179.18,72.9) 179.18,72.6 v2(179.49,72.29) 178.95,71.76 YV1.4 ; v2(179.18,72.9) 179.12,72.84 178.65,72.84 CV70.1 ; v2(179.18,72.9) 179.18,73.56 178.97,73.78 ; CE72.2 CE71.2 228.31,15.56 v2(229,14.87) ; CE80.2 v2(150.73,13.43) ; v2(110.96,8.14) 110.32,8.14 PC504.2 ; v2(57.29,28.06) JEDP1.44 59.39,28.06 59.52,28.2 60.39,28.2 v2(60.63,27.96) ; RV62.2 RV63.2 150.4,84.36 v2(150.33,84.43) ; v2(110.12,126.74) 110.61,126.74 PC1410.2 ; CV905.2 192.16,78.43 v2(192.31,78.58) ; v2(26.04,32.12) 26.04,32.34 26.34,32.63 26.34,33.7 PC311.2 ; PC906.2 142.12,110.1 v2(142.63,109.59) 143.11,109.59 PR902.1 ; v2(140.4,34.71) 140.4,35.5 140.97,36.07 JDIMM2.261 ; v2(180.55,55.54) 180.53,55.51 PC1608.2 ; CV162.2 188.41,123.75 187.68,124.49 v2(187.2,124.49) ; v2(78.22,89.17) 78.19,89.14 PC1116.2 ; UV17.2 294.21,65.71 293.63,66.28 v2(291.47,66.28) ; PC1101.2 v2(71.76,82.29) PC1102.2 ; PC1509.1 v2(66.56,111.24) ; JTP.10 141.44,12.6 v2(140.9,12.07) ; PC1501.1 93.74,132.32 v2(93.39,132.67) ; CL15.2 CL43.2 290.54,47.03 290.97,47.46 v2(290.97,47.87) ; RE67.1 227.14,25.53 v2(227.14,25.14) ; v2(210.26,96.26) 210.26,95 CV893.2 ; RA16.2 279.36,15.98 279.87,15.47 v2(279.87,14.9) ; JHDD1.13 199.29,12.21 199.31,12.19 ; v2(135.96,14.66) 135.76,14.86 JTP.5 ; v2(45.45,42.59) PR213.2 ; v2(173.75,18.98) 173.7,18.93 CH46.2 ; JUART.4 215.33,59.5 v2(215.61,59.22) JUART.5 ; v2(95.54,15.92) 95.54,14.85 96.43,14.85 96.5,14.93 v2(96.5,15.87) ; YH2.4 183.56,45.67 183.31,45.91 CH47.2 v2(182.25,45.91) ; PC1312.2 v2(95.77,110.61) ; RA67.2 CD94.2 263.66,24.67 v2(263.67,24.68) ; v2(292.86,22.95) 293.38,22.43 DA4.1 ; CV891.2 197.46,95 v2(197.46,96.26) ; v2(174.4,118.89) 173.14,118.89 CV861.2 ; RH29.2 RH33.2 108.05,104.27 v2(108.24,104.46) ; PC611.2 v2(247.91,10.68) ; CLRP1.2 175.8,13.59 176.34,13.05 v2(176.34,12.55) ; v2(262.47,32.35) 262.47,31.99 CA67.2 ; v2(195.69,76.09) 195.18,75.58 193.66,75.58 QV21.3 ; PU1800.8 147.5,24.81 148.16,25.47 PR1804.2 148.51,25.83 v2(149.11,26.43) ; PC612.2 v2(252.49,10.66) ; PC309.1 23.86,35.84 v2(23.57,35.55) ; CA31.2 272.73,25.01 CA33.2 271.71,24.96 v2(271.54,25.14) ; v2(207.06,109.06) 207.06,109.58 207.32,109.85 CV881.2 ; v2(203.62,20.46) 203.62,22.36 JNGFF1.69 ; v2(146.06,76.44) 146.06,76.57 145.48,77.16 CV212.2 ; QA1.3 265.2,28.71 v2(264.93,28.44) ; CV600.1 295.46,70.93 v2(295.67,70.73) ; v2(224.29,36.31) CE73.2 ; JNGFF2.77 208.85,15.19 212.66,11.38 v2(212.66,9.52) ; v2(155.1,128.49) 154.72,128.49 154.14,129.07 CV855.2 ; v2(77.05,93.47) 77.66,92.87 PR1135.2 PC1120.2 ; PC518.2 98.74,15.48 v2(99.1,15.84) ; JBL1.6 115.94,9.63 v2(116.94,8.63) ; RH187.2 v2(83.73,86.86) ; JRTC.3 156.74,9.15 v2(157.08,8.8) ; JLPDE1.11 249.12,30.36 v2(248.89,30.59) ; PR1113.2 PR1123.2 78.14,86.22 v2(78.27,86.35) ; v2(146.09,78.56) 146.89,77.76 RV616.1 ; RH95.1 v2(190.38,36.57) ; PR211.2 v2(50.3,45.56) ; PR1612.2 181.26,56.33 v2(181.26,55.59) ; PC1508.2 v2(72.4,106.29) ; RH186.2 v2(84.39,84.24) ; v2(174.4,128.49) 173.19,128.49 CV873.2 ; RH60.1 v2(81.32,95.49) ; v2(66.43,82.29) PC1100.1 PR1100.1 ; v2(234.3,17.64) 234.93,18.28 CE68.2 ; PC415.2 36.1,37.81 35.7,38.22 v2(35.7,38.85) ; PC415.2 36.69,37.81 36.97,38.09 v2(36.97,38.85) ; PC415.2 v2(36.33,38.85) ; DI3.1 v2(62.09,18.86) ; PR605.2 249.74,11.13 v2(250.21,10.66) 250.66,11.1 PR607.2 ; PC1803.2 v2(142.58,25.96) ; CL36.2 v2(281.82,46.54) ; JTP.9 131.42,12.6 v2(131.72,12.9) ; CV584.2 v2(232.23,47.73) ; v2(180.58,8.51) 180.58,8.25 181.09,7.74 UH8.4 ; PC1418.2 v2(100.26,126.41) ; JDIMM2.262 67.29,32.07 v2(67.95,32.73) ; v2(293,41.09) 292.74,41.34 US2.2 ; CV906.2 195.67,105.27 v2(195.95,104.99) ; CD38.2 CD40.2 v2(218.35,17.99) ; v2(282.08,39.11) 282.46,39.49 CL24.2 ; JNGFF1.68 v2(183.21,24.52) ; JCAM1.1 241.02,42.95 v2(240.52,42.46) 240.02,42.96 JCAM1.2 ; v2(284.49,39.11) 284.49,39.61 CL35.2 284.31,39.79 CL42.2 ; v2(131.33,125.24) 130.77,125.24 PC1523.2 ; v2(80.49,83.81) CH197.2 ; v2(202.3,112.82) 202.7,112.41 202.7,111.88 ; PR214.2 45.06,37.89 v2(44.66,37.49) ; RH185.2 v2(83.73,85.91) ; v2(282.46,43.55) 282.13,43.22 CL37.2 ; PR115.2 209.81,57.24 v2(209.43,57.62) ; PR318.2 24.39,38.47 v2(24.19,38.27) ; PC613.2 248.85,10.91 v2(249.11,10.66) ; CV860.2 189.21,117.55 QV20.3 ; RA62.2 269.43,21.45 269.76,21.78 v2(269.86,21.78) ; CV390.2 207.51,75.06 207.06,75.51 v2(207.06,75.88) ; v2(98.66,6.77) PR506.2 ; v2(155.1,120.49) 154.34,120.49 CV866.2 ; 278.77,54.22 279.49,53.51 RL27.1 ; v2(193.43,13.93) 193.43,14.19 193.17,14.44 JHDD1.6 ; v2(56.3,22.24) 56.32,22.22 PC400.2 ; PC1108.1 v2(63.05,88.76) ; v2(223.91,30.47) 223.91,29.78 RE22.2 223.56,29.89 CE12.2 ; EC5206.2 v2(241.69,35.17) ; PC420.2 48.32,19.75 v2(48.4,19.68) ; PR323.2 24.67,42.81 v2(24.44,42.81) ; v2(231.38,36.1) 231.51,35.97 233.45,35.97 233.96,36.48 DV12.1 ; PR1144.2 68.84,98.03 v2(69.1,98.29) ; JDEG1.12 255.82,38.91 v2(256.63,39.72) ; RH77.2 v2(170.58,14.33) ; v2(30.3,43.18) 30.49,42.99 PR329.2 PC322.1 ; v2(62.83,45.91) 62.73,46.01 JEDP1.41 60.57,45.69 v2(61.63,44.63) ; v2(242.68,43.25) 242.32,42.89 JCAM1.15 ; PC1514.2 v2(66.71,114.8) ; PC421.2 v2(48.5,23.64) ; JDIMM1.261 69.59,48.87 68.97,48.25 68.97,47.36 v2(68.08,46.47) ; v2(276.69,24.93) 276.59,24.83 CA32.2 ; v2(219.39,36.19) 219.39,35.98 219.72,35.65 CD36.2 ; PC1380.2 v2(120.47,102.01) ; v2(227.97,38.47) 227.59,38.85 PC812.2 PR807.2 ; v2(204.56,96.26) 204.56,95.01 CV892.2 ; CV886.2 197.46,74.62 v2(197.46,75.88) ; RA9.2 278.71,22.79 v2(279.35,22.79) ; v2(78.17,94.25) 78.55,93.87 PC1123.2 ; v2(268.89,25.06) 269.2,24.76 RA64.2 ; JRTC.2 v2(152.94,12.44) ; PC1309.2 v2(93.99,110.61) ; PD102.1 v2(25.41,17.21) ; JRTC.4 v2(150.39,8.87) ; v2(218.75,41.89) 218.75,42.05 PC811.2 ; v2(211.06,109.06) 211.06,110.19 CV894.2 ; PC601.2 v2(249.95,20.16) ; PC1424.2 v2(107.58,132.58) ; v2(167.9,126.07) 169.14,126.07 CV168.2 169.3,124.71 CV172.2 168.98,124.39 v2(167.9,124.39) ; JEDP1.42 60.57,20.48 60.36,20.27 v2(59.26,20.27) ; EC5205.2 v2(240.67,35.22) ; PC1645.2 v2(180.58,54.22) ; RV58.1 140.22,77.56 v2(141.28,78.63) ; v2(99.86,15.84) PC514.2 ; CE10.2 146.12,15.33 v2(145.64,14.85) 146.12,14.37 CE9.2 ; v2(65.55,70.02) 64.87,70.7 PC700.2 ; QE24.1 284.81,58.98 v2(284.74,59.05) ; v2(148.73,99.43) RV50.1 ; RA58.2 v2(269.78,17.59) ; DE4.2 v2(146.28,9.24) ; v2(34.93,43.07) 34.81,43.07 34.17,42.43 PR201.2 ; PC1103.2 v2(73.42,82.29) ; v2(81.16,85.46) PC1111.2
  vias: v2(0.49,42.41) v2(0.49,40.68) v2(0.49,38.95) v2(0.49,37.23) v2(0.49,35.5) v2(0.49,33.77) v2(0.49,32.04) v2(0.49,30.32) v2(0.49,28.59) v2(0.49,26.86) v2(0.49,25.14) v2(0.49,23.41) v2(0.49,21.68) v2(0.49,19.95) v2(0.49,18.23) v2(0.49,16.5) v2(0.49,14.77) v2(0.49,13.05) v2(1.99,43.6) v2(2.25,12.08) v2(2.36,17.29) v2(3.72,43.6) v2(3.86,19.43) v2(3.97,12.08) v2(4.35,17.29) v2(4.71,35.55) v2(4.73,32.35) v2(4.73,31.71) v2(4.73,30.85) v2(5.45,43.6) v2(5.7,12.08) v2(5.86,19.4) v2(6.6,40.5) v2(6.63,19.4) v2(7.17,43.6) v2(7.43,12.08) v2(7.45,29.58) v2(8.9,43.6) v2(8.95,29.05) v2(9.03,25.75) v2(9.15,12.08) v2(10.63,43.6) v2(10.88,12.08) v2(12.35,43.6) v2(12.61,12.08) v2(14.01,10.76) v2(14.01,9.03) v2(14.01,7.31) v2(14.08,43.6) v2(14.11,22.98) v2(14.26,5.83) v2(14.36,39.49) v2(14.36,22.34) v2(14.49,21.58) v2(14.95,39.36) v2(15.81,43.6) v2(16.52,25.77) v2(17.41,33.39) v2(17.41,32.76) v2(17.41,32.12) v2(17.41,31.23) v2(17.41,30.6) v2(17.41,29.58) v2(17.41,28.95) v2(17.41,27.8) v2(17.41,27.17) v2(17.76,43.6) v2(19.59,43.6) v2(20.55,27.66) v2(20.55,27.08) v2(21.19,27.42) v2(21.16,26.84) v2(21.18,26.25) v2(21.24,25.09) v2(21.24,24.5) v2(21.26,25.67) v2(21.5,43.6) v2(21.75,26.79) v2(21.8,26.15) v2(21.85,25.52) v2(21.85,24.88) v2(21.98,24.25) v2(22.62,24.25) v2(23.4,43.6) v2(24.7,5.76) v2(25.38,43.65) v2(26.43,5.76) v2(27.26,43.81) v2(28.15,5.76) v2(28.41,13.71) v2(28.8,38.41) v2(28.8,36.27) v2(28.75,14.34) v2(29.04,13.71) v2(29.35,44.08) v2(29.42,14.34) v2(29.8,13.71) v2(29.87,37.34) v2(29.88,5.76) v2(30.06,14.34) v2(30.44,13.71) v2(30.69,14.34) v2(31,44.39) v2(31.07,13.71) v2(31.33,14.34) v2(31.51,32.22) v2(31.63,34.79) v2(31.61,5.76) v2(31.71,13.71) v2(31.94,33.52) v2(31.94,31.79) v2(31.94,31.21) v2(31.91,14.34) v2(31.95,32.93) v2(32.34,13.71) v2(32.52,31.79) v2(32.52,31.21) v2(32.52,30.62) v2(32.5,14.34) v2(32.88,44.82) v2(32.95,13.71) v2(33.23,14.26) v2(33.33,5.76) v2(33.54,13.71) v2(34.66,45.33) v2(35.06,5.76) v2(36.59,45.99) v2(36.79,5.76) v2(38.52,5.76) v2(38.54,46.75) v2(40.24,5.76) v2(40.35,47.59) v2(41.97,5.76) v2(42.07,48.5) v2(43.7,5.76) v2(43.82,49.52) v2(44.27,18.41) v2(44.27,17.64) v2(45.43,5.76) v2(45.5,50.66) v2(45.86,36.95) v2(45.86,36.31) v2(45.86,35.68) v2(45.86,35.04) v2(45.86,18.02) v2(45.86,17.39) v2(46.49,36.95) v2(46.49,36.31) v2(46.49,35.68) v2(46.49,35.04) v2(47.13,36.95) v2(47.13,36.31) v2(47.13,35.68) v2(47.13,35.04) v2(47.15,51.68) v2(47.15,5.76) v2(47.76,36.95) v2(47.76,36.31) v2(47.76,35.68) v2(47.76,35.04) v2(47.76,13.33) v2(47.76,12.69) v2(48.4,36.95) v2(48.4,36.31) v2(48.4,35.68) v2(48.4,35.04) v2(48.71,24.69) v2(48.88,5.76) v2(49.21,51.76) v2(49.92,27.55) v2(49.92,26.91) v2(50.17,8.63) v2(50.61,5.76) v2(50.81,8.63) v2(51.08,42.24) v2(51.08,40.39) v2(51.08,38.61) v2(51.44,51.45) v2(51.6,33.98) v2(51.65,21.55) v2(52.25,36.21) v2(52.27,22.18) v2(52.27,21.55) v2(52.27,20.93) v2(52.33,5.76) v2(52.9,21.55) v2(53.3,52.36) v2(53.27,8.63) v2(53.86,8.63) v2(54.06,5.76) v2(54.32,54.17) v2(55.1,57.32) v2(55.79,5.76) v2(55.86,55.67) v2(55.99,59.09) v2(56.68,62.78) v2(57.51,59.73) v2(57.52,5.76) v2(57.54,55.24) v2(57.67,64.58) v2(58.18,13.67) v2(58.43,66.16) v2(58.94,56.12) v2(59.19,67.88) v2(59.16,59.09) v2(59.24,14.82) v2(59.24,5.76) v2(59.45,57.39) v2(59.9,69.84) v2(60.46,71.62) v2(60.92,73.37) v2(60.97,5.76) v2(61.58,76.67) v2(61.68,9.41) v2(61.68,8.83) v2(61.78,78.27) v2(62.01,123.56) v2(62.01,121.83) v2(62.01,120.11) v2(62.01,118.38) v2(62.01,116.65) v2(62.01,114.93) v2(62.01,113.2) v2(62.01,111.47) v2(62.01,109.74) v2(62.01,108.02) v2(62.01,106.29) v2(62.01,104.56) v2(62.01,102.83) v2(62.01,101.11) v2(62.01,99.38) v2(62.01,97.65) v2(62.01,95.93) v2(62.01,94.2) v2(62.01,92.47) v2(62.01,90.74) v2(62.01,89.02) v2(62.01,87.29) v2(62.01,85.56) v2(62.01,83.84) v2(62.01,82.11) v2(62.09,125.31) v2(62.27,9.41) v2(62.27,8.83) v2(62.7,5.76) v2(62.85,9.41) v2(62.85,8.83) v2(63.13,76.83) v2(63.43,9.41) v2(63.43,8.83) v2(63.73,66.52) v2(63.76,125.49) v2(63.79,78.59) v2(63.76,75.3) v2(63.81,65.85) v2(64.02,8.83) v2(64.08,66.99) v2(64.04,9.41) v2(64.26,66.27) v2(64.41,65.7) v2(64.42,5.76) v2(64.5,67.4) v2(64.62,66.76) v2(64.84,66.22) v2(65.03,67.17) v2(65.31,74.66) v2(65.41,79.11) v2(65.49,125.49) v2(66.15,5.76) v2(66.83,75.29) v2(66.94,78.35) v2(67.22,125.49) v2(67.47,76.82) v2(67.5,67.49) v2(67.88,5.76) v2(68.95,125.49) v2(69.53,22.73) v2(69.61,5.76) v2(69.77,91.53) v2(69.77,89.57) v2(69.77,87.6) v2(69.86,61.84) v2(70.24,21.17) v2(70.49,62.6) v2(70.49,61.97) v2(70.67,125.49) v2(70.91,21.2) v2(71.16,62.58) v2(71.33,5.76) v2(71.43,111.51) v2(71.43,110.55) v2(71.54,38.52) v2(71.59,37.07) v2(71.74,91.53) v2(71.74,89.57) v2(71.74,87.6) v2(72.27,67.43) v2(72.27,66.79) v2(72.27,66.16) v2(72.27,65.52) v2(72.27,63.62) v2(72.4,125.49) v2(72.53,119.62) v2(72.53,118.99) v2(72.53,118.35) v2(72.53,117.72) v2(72.53,117.08) v2(72.53,116.45) v2(72.53,115.69) v2(72.57,113.99) v2(72.57,113.13) v2(72.57,112.26) v2(72.57,111.4) v2(72.83,37.68) v2(72.83,36.51) v2(72.81,24.95) v2(72.83,23.71) v2(73.03,48.43) v2(73.03,47.64) v2(73.06,5.76) v2(73.16,119.62) v2(73.16,118.99) v2(73.16,118.35) v2(73.16,117.72) v2(73.16,115.43) v2(73.35,113.99) v2(73.35,113.13) v2(73.35,112.26) v2(73.35,111.4) v2(73.71,91.53) v2(73.71,89.57) v2(73.71,87.6) v2(73.8,119.62) v2(73.8,118.99) v2(73.8,118.35) v2(73.8,117.72) v2(74.13,125.49) v2(74.13,113.99) v2(74.13,113.13) v2(74.13,112.26) v2(74.13,111.4) v2(74.43,119.62) v2(74.43,118.99) v2(74.43,118.35) v2(74.43,117.72) v2(74.43,117.08) v2(74.43,116.45) v2(74.43,115.81) v2(74.79,5.76) v2(74.93,35.43) v2(74.94,38.1) v2(75.07,119.62) v2(75.07,118.99) v2(75.07,118.35) v2(75.07,117.72) v2(75.07,117.08) v2(75.07,116.45) v2(75.07,115.86) v2(75.14,25.47) v2(75.14,24.3) v2(75.14,22.86) v2(75.7,119.62) v2(75.7,118.99) v2(75.7,118.35) v2(75.7,117.72) v2(75.7,117.08) v2(75.85,125.49) v2(76.12,37.63) v2(76.11,36.43) v2(76.34,119.62) v2(76.34,118.99) v2(76.34,118.35) v2(76.34,117.72) v2(76.34,117.08) v2(76.51,5.76) v2(77.12,25.47) v2(77.1,24.3) v2(77.09,23) v2(77.58,125.49) v2(78.03,108.8) v2(78.03,70.4) v2(78.11,6.58) v2(78.24,5.76) v2(78.43,23.54) v2(78.51,37.73) v2(78.55,110.32) v2(78.55,107.25) v2(78.55,71.92) v2(78.55,68.85) v2(78.55,36.55) v2(78.55,34.55) v2(78.75,6.58) v2(79.19,63.47) v2(79.31,125.49) v2(79.51,6.58) v2(79.64,111.12) v2(79.64,72.72) v2(79.8,106.43) v2(79.8,68.03) v2(80,64.35) v2(79.97,5.76) v2(80.72,65.87) v2(80.67,25.37) v2(80.67,24.1) v2(80.67,22.83) v2(80.93,125.82) v2(81.15,111.18) v2(81.2,75.48) v2(81.15,72.78) v2(81.42,115.99) v2(81.42,115.35) v2(81.42,114.67) v2(81.35,106.49) v2(81.35,68.09) v2(81.49,133.04) v2(81.5,39.13) v2(81.51,37.92) v2(81.48,37.33) v2(81.7,5.76) v2(81.82,134.28) v2(82.26,66.52) v2(82.48,110.26) v2(82.53,107.42) v2(82.48,75.49) v2(82.48,71.86) v2(82.53,69.02) v2(82.49,25.49) v2(82.48,23.59) v2(82.49,22.3) v2(82.8,128.82) v2(82.97,108.79) v2(82.97,70.39) v2(83.07,114.54) v2(83.4,37.07) v2(83.42,5.76) v2(83.45,15.48) v2(83.58,134.31) v2(83.56,127.17) v2(83.69,130.59) v2(84.08,15.48) v2(84.41,79.01) v2(84.59,24.36) v2(84.57,22.42) v2(84.76,38.32) v2(84.74,37.07) v2(84.76,35.78) v2(85.21,131.23) v2(85.21,126.66) v2(85.18,77.51) v2(85.3,134.31) v2(85.73,80.23) v2(85.74,25.89) v2(85.73,24.57) v2(85.73,23.3) v2(86.62,127.37) v2(86.86,130.59) v2(87.03,134.31) v2(87.03,71.17) v2(87.06,72.94) v2(87.26,128.77) v2(87.89,26.02) v2(87.9,24.78) v2(87.9,23.51) v2(87.98,71.9) v2(88.21,37.39) v2(88.26,35.81) v2(88.76,134.31) v2(89.5,67.93) v2(89.5,66.17) v2(89.85,23.65) v2(89.85,21.9) v2(90.11,71.43) v2(90.48,134.31) v2(90.51,38.52) v2(90.51,36.92) v2(90.51,34.98) v2(91.27,80.51) v2(91.74,36.46) v2(91.77,38.38) v2(92.21,134.31) v2(92.19,25.34) v2(92.19,24.07) v2(92.19,22.8) v2(93.04,127.74) v2(93.79,5.76) v2(93.91,134.31) v2(93.89,126.6) v2(93.89,125.81) v2(93.89,125.03) v2(94,127.74) v2(94.27,12.89) v2(94.24,12.31) v2(94.53,95.48) v2(94.47,70.96) v2(94.75,126.6) v2(94.75,125.81) v2(94.75,125.03) v2(94.9,12.89) v2(94.88,12.31) v2(95.29,95.49) v2(95.51,12.94) v2(95.51,12.31) v2(95.51,5.76) v2(95.62,125.81) v2(95.62,125.03) v2(95.64,134.31) v2(95.92,37.88) v2(96.15,12.94) v2(96.28,69.86) v2(96.29,67.97) v2(96.35,72.35) v2(96.42,22.47) v2(96.48,126.6) v2(96.48,125.81) v2(96.48,125.03) v2(96.54,23.79) v2(96.78,12.94) v2(96.87,95.49) v2(97.14,38.22) v2(97.14,37.05) v2(97.15,35.87) v2(97.24,5.76) v2(97.37,134.31) v2(97.34,124.27) v2(97.42,12.94) v2(97.64,95.5) v2(97.88,126.25) v2(97.88,125.62) v2(97.88,125.03) v2(97.93,119.12) v2(97.93,118.48) v2(97.93,117.85) v2(97.95,124.2) v2(98.06,24.7) v2(98.05,12.94) v2(98.18,126.8) v2(98.36,124.68) v2(98.59,125.24) v2(98.56,119.12) v2(98.56,118.48) v2(98.56,117.85) v2(98.77,127) v2(98.99,124.7) v2(98.97,5.76) v2(99.1,134.31) v2(99.07,124.07) v2(99.07,123.43) v2(99.07,122.85) v2(99.2,119.12) v2(99.2,118.48) v2(99.2,117.85) v2(99.2,95.49) v2(99.4,127) v2(99.35,125.24) v2(99.43,122.34) v2(99.54,68.46) v2(99.44,21.96) v2(99.51,11.89) v2(99.63,124.65) v2(99.56,72.11) v2(99.56,70.32) v2(99.7,124.07) v2(99.7,123.43) v2(99.76,122.85) v2(99.83,119.12) v2(99.83,118.48) v2(99.83,117.85) v2(99.93,125.16) v2(100.02,95.49) v2(100.09,125.75) v2(100.11,122.34) v2(100.09,11.89) v2(100.24,124.65) v2(100.31,124.04) v2(100.29,123.46) v2(100.24,24.17) v2(100.39,122.88) v2(100.47,119.12) v2(100.47,118.48) v2(100.47,117.85) v2(100.62,17.57) v2(100.59,14.11) v2(100.7,5.76) v2(100.82,134.31) v2(100.82,124.55) v2(100.77,122.34) v2(100.85,123.79) v2(101.03,122.88) v2(101.1,119.12) v2(101.1,118.48) v2(101.1,117.85) v2(101.2,17.57) v2(101.33,124.25) v2(101.31,123.41) v2(101.36,122.32) v2(101.61,95.49) v2(101.64,34.81) v2(101.65,38.7) v2(101.65,37.53) v2(101.65,36.36) v2(101.75,24.79) v2(101.79,17.57) v2(102.12,68.85) v2(102.14,70.32) v2(102.15,66.94) v2(102.22,65.02) v2(102.36,95.5) v2(102.37,17.57) v2(102.42,5.76) v2(102.55,134.31) v2(102.71,22.17) v2(103.33,127.74) v2(103.62,35.29) v2(103.72,110.56) v2(103.72,109.92) v2(103.72,109.29) v2(103.64,37.68) v2(103.64,36.48) v2(103.82,23.93) v2(103.95,95.49) v2(104.23,134.31) v2(104.18,126.6) v2(104.18,125.81) v2(104.18,125.03) v2(104.15,5.76) v2(104.29,127.74) v2(104.72,95.48) v2(105.04,126.6) v2(105.04,125.81) v2(105.04,125.03) v2(105.47,38.76) v2(105.46,36.83) v2(105.57,24.52) v2(105.67,23.29) v2(105.7,21.54) v2(105.91,126.6) v2(105.91,125.81) v2(105.91,125.03) v2(105.88,5.76) v2(105.95,134.31) v2(106.32,95.49) v2(106.77,126.6) v2(106.77,125.81) v2(106.77,125.03) v2(106.94,110.67) v2(106.94,110.04) v2(106.94,109.4) v2(107.07,95.49) v2(107.07,71.59) v2(107.07,69.61) v2(107.07,67.67) v2(107.1,65.86) v2(107.05,15.84) v2(107.2,18.66) v2(107.6,5.76) v2(107.68,134.31) v2(107.64,110.73) v2(107.64,110.1) v2(107.64,109.46) v2(107.73,15.84) v2(107.83,18.66) v2(108.32,37.51) v2(108.32,36.2) v2(108.32,34.97) v2(108.34,15.87) v2(108.47,126.8) v2(108.47,125.21) v2(108.47,124.58) v2(108.47,123.97) v2(108.47,123.34) v2(108.47,122.7) v2(108.47,122.04) v2(108.47,121.4) v2(108.47,120.77) v2(108.47,120.13) v2(108.47,119.5) v2(108.93,15.87) v2(108.98,24.75) v2(109,23.53) v2(108.97,22.05) v2(109.1,126.8) v2(109.1,125.21) v2(109.1,124.58) v2(109.1,123.97) v2(109.1,123.34) v2(109.1,122.7) v2(109.1,122.04) v2(109.1,121.4) v2(109.1,120.77) v2(109.1,120.13) v2(109.1,119.5) v2(109.33,5.76) v2(109.41,134.31) v2(109.51,15.87) v2(109.74,125.21) v2(109.74,124.58) v2(109.74,123.97) v2(109.74,123.34) v2(109.74,122.7) v2(109.74,122.04) v2(109.74,121.4) v2(109.74,120.77) v2(109.74,120.13) v2(109.74,119.5) v2(110.08,71.97) v2(110.37,125.21) v2(110.37,124.58) v2(110.37,123.94) v2(110.37,123.31) v2(110.37,122.7) v2(110.37,122.04) v2(110.37,121.4) v2(110.37,120.77) v2(110.37,120.13) v2(110.37,119.5) v2(110.8,110.1) v2(110.8,109.46) v2(110.8,108.83) v2(110.78,38.74) v2(110.78,37.14) v2(110.84,35.95) v2(110.91,34.27) v2(110.96,25.7) v2(110.97,23.58) v2(111.13,134.31) v2(111.06,5.76) v2(111.17,85.59) v2(111.29,70.47) v2(111.64,8.12) v2(111.82,95.48) v2(111.87,86.91) v2(111.9,85.58) v2(112.3,8.12) v2(112.79,5.76) v2(112.86,134.31) v2(112.89,8.12) v2(113.23,127.87) v2(113.16,62.82) v2(113.15,61.38) v2(113.14,60.03) v2(113.31,34.55) v2(113.41,95.49) v2(113.42,35.8) v2(113.45,38.31) v2(113.47,37) v2(113.52,8.12) v2(113.65,92.45) v2(113.95,24.27) v2(113.95,23.08) v2(114.08,126.72) v2(114.08,125.94) v2(114.08,125.16) v2(114.2,127.87) v2(114.19,95.49) v2(114.51,5.76) v2(114.59,134.31) v2(114.72,22.1) v2(114.95,126.72) v2(114.95,125.94) v2(114.95,125.16) v2(115.31,24.24) v2(115.29,23.6) v2(115.27,22.32) v2(115.49,92.45) v2(115.81,126.72) v2(115.81,125.94) v2(115.81,125.16) v2(115.75,95.49) v2(115.79,64.8) v2(115.99,90.72) v2(115.99,90.08) v2(115.99,89.45) v2(115.99,88.81) v2(116.21,37.46) v2(116.29,134.31) v2(116.24,5.76) v2(116.39,70.5) v2(116.56,95.5) v2(116.68,126.72) v2(116.68,125.94) v2(116.68,125.16) v2(116.83,79.27) v2(117.07,63.6) v2(117.29,69.66) v2(117.4,92.45) v2(117.61,24.37) v2(117.61,23.09) v2(118.02,134.31) v2(117.97,5.76) v2(118.06,126.16) v2(118.15,95.5) v2(118.37,126.93) v2(118.37,125.34) v2(118.37,124.7) v2(118.37,124.07) v2(118.37,123.43) v2(118.37,122.8) v2(118.37,122.16) v2(118.37,121.53) v2(118.37,120.89) v2(118.37,120.26) v2(118.37,119.62) v2(118.4,36.7) v2(118.51,68.4) v2(118.5,24.67) v2(119.01,125.34) v2(119.01,124.7) v2(119.01,124.07) v2(119.01,123.43) v2(119.01,122.8) v2(119.01,122.16) v2(119.01,121.53) v2(119.01,120.89) v2(119.01,120.26) v2(119.01,119.62) v2(119.03,71.99) v2(119.06,127.1) v2(119.56,37.53) v2(119.54,36.31) v2(119.69,127.1) v2(119.64,125.34) v2(119.64,124.7) v2(119.64,124.07) v2(119.64,123.43) v2(119.64,122.8) v2(119.64,122.16) v2(119.64,121.53) v2(119.64,120.89) v2(119.64,120.26) v2(119.64,119.62) v2(119.68,95.48) v2(119.69,5.76) v2(119.75,134.31) v2(119.86,71.13) v2(120.15,72.71) v2(120.17,66.66) v2(120.28,124.7) v2(120.28,124.07) v2(120.28,123.43) v2(120.28,122.8) v2(120.28,122.16) v2(120.28,121.53) v2(120.28,120.89) v2(120.28,120.26) v2(120.33,25.31) v2(120.33,23.99) v2(120.34,22.77) v2(121.05,38.53) v2(121.1,34.41) v2(121.38,71.46) v2(121.42,5.76) v2(121.47,134.31) v2(122.31,36.82) v2(122.31,34.84) v2(122.27,25.48) v2(122.27,24.29) v2(122.29,23.02) v2(123.2,134.31) v2(123.15,5.76) v2(123.39,127.87) v2(123.97,72.55) v2(123.99,38.99) v2(123.99,37.75) v2(123.99,36.48) v2(124.04,24.44) v2(124.03,22.5) v2(124.24,126.72) v2(124.24,125.94) v2(124.24,125.16) v2(124.36,127.87) v2(124.93,134.31) v2(124.88,5.76) v2(125.11,126.72) v2(125.11,125.94) v2(125.11,125.16) v2(125.09,24.44) v2(125.11,23.2) v2(125.97,126.72) v2(125.97,125.94) v2(125.97,125.16) v2(126.02,35.68) v2(126.26,39.02) v2(126.26,37.75) v2(126.35,23.73) v2(126.6,5.76) v2(126.65,134.31) v2(126.84,126.72) v2(126.84,125.94) v2(126.84,125.16) v2(127.9,119.62) v2(127.92,118.99) v2(128.13,36.81) v2(128.22,126.16) v2(128.15,35.61) v2(128.18,24.48) v2(128.18,23.21) v2(128.33,5.76) v2(128.48,134.28) v2(128.53,126.93) v2(128.53,125.34) v2(128.53,124.7) v2(128.53,124.07) v2(128.53,120.89) v2(128.53,120.26) v2(128.53,119.62) v2(128.53,118.99) v2(128.69,123) v2(128.69,122.42) v2(128.66,108.83) v2(129.07,115.08) v2(129.09,113.2) v2(129.09,112.61) v2(129.09,112) v2(129.17,126.93) v2(129.17,125.34) v2(129.17,124.7) v2(129.17,124.07) v2(129.17,121.53) v2(129.17,120.89) v2(129.17,120.26) v2(129.17,119.62) v2(129.17,118.99) v2(129.25,123.43) v2(129.25,122.8) v2(129.25,122.16) v2(129.52,111.12) v2(129.52,110.48) v2(129.52,109.85) v2(129.52,109.21) v2(129.51,21.7) v2(129.58,26.07) v2(129.57,24.22) v2(129.55,23) v2(129.8,126.93) v2(129.8,125.34) v2(129.8,124.7) v2(129.8,124.07) v2(129.83,123.43) v2(129.83,122.8) v2(129.83,122.16) v2(129.8,121.53) v2(129.8,120.89) v2(129.8,120.26) v2(129.8,119.62) v2(129.8,118.99) v2(130.06,5.76) v2(130.21,134.28) v2(130.44,121.53) v2(130.44,120.89) v2(130.44,120.26) v2(130.44,119.62) v2(130.44,118.99) v2(130.67,38.73) v2(130.69,37.48) v2(131.38,25.43) v2(131.35,24.23) v2(131.53,21.96) v2(131.71,38.97) v2(131.71,37.73) v2(131.74,36.44) v2(131.76,34.91) v2(131.79,5.76) v2(131.94,134.28) v2(132.47,123.82) v2(132.7,26.01) v2(132.7,24.75) v2(132.93,23.56) v2(133.33,36.33) v2(133.44,125.93) v2(133.51,5.76) v2(133.66,134.28) v2(133.68,124.88) v2(134.38,22.09) v2(134.48,124.88) v2(135.24,5.76) v2(135.27,124.88) v2(135.27,123.82) v2(135.39,134.28) v2(135.38,23.94) v2(135.71,36.92) v2(135.84,25.12) v2(136.79,108.58) v2(136.87,123.97) v2(136.89,123.38) v2(136.85,122.68) v2(136.92,122.09) v2(136.92,121.5) v2(136.94,120.89) v2(136.97,5.76) v2(137.12,134.28) v2(137.04,111.37) v2(137.04,110.73) v2(137.04,109.97) v2(137.04,109.34) v2(137.17,113.66) v2(137.17,113.02) v2(137.17,62.83) v2(137.14,61) v2(137.14,58.97) v2(137.14,56.91) v2(137.14,55.06) v2(137.3,104.56) v2(137.3,71.01) v2(137.42,123.69) v2(137.35,123) v2(137.42,122.42) v2(137.45,121.78) v2(137.45,121.2) v2(137.45,120.56) v2(137.55,112.39) v2(137.83,106.09) v2(137.83,72.54) v2(137.93,124.02) v2(137.93,123.38) v2(137.93,122.77) v2(137.87,103) v2(137.89,95.67) v2(137.87,94.19) v2(137.87,69.45) v2(137.98,122.11) v2(137.98,121.53) v2(138.01,120.89) v2(138.44,123.69) v2(138.47,123.08) v2(138.47,122.49) v2(138.59,124.35) v2(138.69,5.76) v2(138.85,134.28) v2(138.92,132.5) v2(138.92,131.92) v2(138.95,131.31) v2(138.97,130.67) v2(138.95,106.9) v2(138.95,73.35) v2(139.13,102.17) v2(139.13,68.62) v2(139.53,132.53) v2(139.56,131.92) v2(139.56,131.33) v2(139.58,130.72) v2(139.83,113.63) v2(139.83,112.44) v2(140.12,132.53) v2(140.14,131.92) v2(140.14,131.33) v2(140.17,130.72) v2(140.42,5.76) v2(140.48,106.92) v2(140.47,73.37) v2(140.57,134.28) v2(140.7,132.55) v2(140.73,131.94) v2(140.73,131.36) v2(140.68,102.24) v2(140.68,68.69) v2(140.75,130.75) v2(140.81,113.03) v2(141.28,132.55) v2(141.31,131.94) v2(141.31,131.36) v2(141.34,130.75) v2(141.78,113.63) v2(141.78,112.44) v2(141.78,106.01) v2(141.78,72.46) v2(141.89,132.55) v2(141.92,131.94) v2(141.92,131.36) v2(141.86,103.16) v2(141.86,69.61) v2(141.95,130.75) v2(142.22,134.31) v2(142.19,54.8) v2(142.19,54.16) v2(142.18,53.52) v2(142.18,52.88) v2(142.18,52.25) v2(142.17,51.62) v2(142.17,50.99) v2(142.17,50.35) v2(142.17,49.72) v2(142.17,49.08) v2(142.18,48.4) v2(142.18,47.76) v2(142.15,5.76) v2(142.29,104.54) v2(142.29,70.99) v2(142.5,132.55) v2(142.5,131.94) v2(142.53,131.36) v2(142.53,130.75) v2(142.71,46.83) v2(142.81,55.69) v2(142.75,55.1) v2(142.75,54.47) v2(142.75,53.83) v2(142.74,53.21) v2(142.74,52.57) v2(142.74,51.94) v2(142.75,51.29) v2(142.75,50.66) v2(142.75,50.02) v2(142.75,49.39) v2(142.75,48.76) v2(142.75,48.12) v2(142.75,47.49) v2(142.94,15.41) v2(143.09,132.17) v2(143.11,131.54) v2(143.11,130.93) v2(143.27,114.39) v2(143.27,113.81) v2(143.27,113.22) v2(143.33,55.36) v2(143.33,54.73) v2(143.33,54.09) v2(143.33,53.46) v2(143.33,52.82) v2(143.33,52.19) v2(143.33,51.55) v2(143.33,50.92) v2(143.33,50.28) v2(143.33,49.65) v2(143.33,49.01) v2(143.33,48.38) v2(143.33,47.74) v2(143.33,47.11) v2(143.33,46.47) v2(143.52,112.64) v2(143.58,15.38) v2(143.88,114.93) v2(143.88,114.34) v2(143.85,113.71) v2(143.88,113.12) v2(143.9,55.11) v2(143.9,54.47) v2(143.9,53.84) v2(143.9,53.2) v2(143.9,52.57) v2(143.9,51.93) v2(143.9,50.03) v2(143.9,49.39) v2(143.9,48.76) v2(143.9,48.12) v2(143.9,47.49) v2(143.9,46.85) v2(143.9,46.22) v2(143.88,5.76) v2(143.95,134.31) v2(144.41,114.62) v2(144.38,113.99) v2(144.41,113.4) v2(144.41,112.77) v2(144.71,22.44) v2(144.71,20.68) v2(145.59,21.55) v2(145.6,5.76) v2(145.68,134.31) v2(146.09,82.37) v2(146.31,38.85) v2(146.31,38.22) v2(146.48,22.46) v2(146.48,20.68) v2(146.54,69.89) v2(146.54,69.28) v2(146.69,82.36) v2(147.13,70.37) v2(147.15,63.64) v2(147.33,5.76) v2(147.41,134.31) v2(147.79,70.4) v2(147.79,63.64) v2(148.47,114.19) v2(148.47,113.6) v2(148.47,112.97) v2(148.73,110.63) v2(148.65,63.59) v2(148.75,109.79) v2(149.13,134.31) v2(149.06,114.26) v2(149.06,113.68) v2(149.06,112.99) v2(149.06,5.76) v2(149.23,82.44) v2(149.23,63.59) v2(149.62,32.88) v2(149.84,63.62) v2(150.43,63.62) v2(150.78,5.76) v2(150.86,134.31) v2(151.14,103.37) v2(151.37,63.62) v2(151.52,102.51) v2(151.52,101.84) v2(151.52,100.96) v2(151.52,100.32) v2(151.93,32.88) v2(151.95,63.62) v2(152.51,5.76) v2(152.59,134.31) v2(152.66,63.62) v2(153.25,63.62) v2(153.96,63.62) v2(154.24,5.76) v2(154.31,134.31) v2(154.29,101.48) v2(154.54,63.62) v2(154.7,45.48) v2(154.7,44.87) v2(155.23,63.62) v2(155.81,63.62) v2(155.97,112.31) v2(155.97,5.76) v2(156.04,134.31) v2(156.14,50.7) v2(156.4,63.59) v2(156.6,51.07) v2(156.71,104.61) v2(156.73,43.42) v2(156.65,41.95) v2(156.98,63.59) v2(157.03,21.84) v2(157.04,112.31) v2(157.06,50.46) v2(157.11,37.84) v2(157.19,75.1) v2(157.19,51.04) v2(157.34,49.95) v2(157.69,63.62) v2(157.64,50.46) v2(157.69,5.76) v2(157.77,134.31) v2(157.77,51.04) v2(157.95,49.94) v2(158.23,50.46) v2(158.22,40.61) v2(158.21,38.5) v2(158.3,94.78) v2(158.28,63.62) v2(158.39,103.11) v2(158.39,102.31) v2(158.39,101.51) v2(158.35,51.04) v2(158.59,49.95) v2(158.86,75.1) v2(158.86,50.74) v2(158.91,39.59) v2(158.99,63.62) v2(159.1,132.09) v2(159.09,40.6) v2(159.09,36.36) v2(159.21,105.34) v2(159.21,101.51) v2(159.21,100.71) v2(159.14,94.78) v2(159.17,87.37) v2(159.23,78.95) v2(159.23,78.12) v2(159.34,42.54) v2(159.37,38.5) v2(159.5,134.31) v2(159.47,34.18) v2(159.57,63.62) v2(160.23,34.18) v2(160.19,26.23) v2(160.28,63.59) v2(160.26,28.26) v2(160.44,38.34) v2(160.57,107.06) v2(160.61,40.05) v2(160.56,25.09) v2(160.59,7.66) v2(160.89,92.09) v2(160.87,63.59) v2(160.94,30.57) v2(161.05,56.12) v2(161.05,55.49) v2(161.05,54.85) v2(161.05,54.22) v2(161.05,53.58) v2(161.05,52.95) v2(161.05,52.31) v2(161.12,50.44) v2(161.04,36.45) v2(161.22,134.31) v2(161.15,105.6) v2(161.2,40.05) v2(161.4,9.44) v2(161.5,130.49) v2(161.5,63.59) v2(161.58,55.77) v2(161.55,55.17) v2(161.55,54.54) v2(161.55,53.9) v2(161.55,53.27) v2(161.55,52.63) v2(161.55,52) v2(161.55,51.4) v2(161.61,50.78) v2(161.58,50.08) v2(161.68,31.69) v2(161.81,29.42) v2(161.76,26.21) v2(161.84,45.25) v2(162.09,63.59) v2(162.06,54.85) v2(162.06,54.22) v2(162.06,53.58) v2(162.06,52.95) v2(162.06,52.31) v2(162.06,51.68) v2(162.11,51.09) v2(162.06,50.41) v2(162.24,112.81) v2(162.24,110.71) v2(162.32,42.6) v2(162.31,23.01) v2(162.34,41.24) v2(162.44,38.47) v2(162.57,50.73) v2(162.57,50.08) v2(162.7,37.37) v2(162.82,63.62) v2(162.98,134.31) v2(163.1,129.69) v2(163.1,121.69) v2(163.13,51.02) v2(163.08,50.41) v2(163.13,30.57) v2(163.23,35.03) v2(163.15,31.69) v2(163.39,100.71) v2(163.41,63.62) v2(163.34,37.37) v2(163.5,25.84) v2(163.71,51.04) v2(163.71,50.41) v2(163.81,10.91) v2(163.9,132.09) v2(163.9,121.69) v2(163.89,32.96) v2(164.09,63.59) v2(164.1,35.16) v2(164.04,30.5) v2(164.22,50.73) v2(164.22,50.09) v2(164.42,42.59) v2(164.36,37.4) v2(164.49,22.99) v2(164.7,134.31) v2(164.68,63.59) v2(164.73,51.04) v2(164.73,50.41) v2(165.24,50.73) v2(165.24,50.09) v2(165.24,111.61) v2(165.31,107.38) v2(165.28,33.96) v2(165.34,33.21) v2(165.34,32.39) v2(165.29,30.11) v2(165.34,108.71) v2(165.39,63.62) v2(165.5,118.49) v2(165.74,51.04) v2(165.74,50.41) v2(165.77,39.86) v2(165.77,28.03) v2(165.92,44.77) v2(165.97,63.62) v2(166.08,83.25) v2(166.06,33.97) v2(166.05,30.07) v2(166.3,131.29) v2(166.3,121.69) v2(166.3,119.29) v2(166.25,50.73) v2(166.25,50.09) v2(166.43,134.31) v2(166.63,28.12) v2(166.6,24.24) v2(166.58,10.4) v2(166.71,104.61) v2(166.68,63.59) v2(166.75,51.03) v2(166.79,39.51) v2(166.77,28.83) v2(166.79,25.9) v2(166.87,34.74) v2(166.85,30.09) v2(166.99,44.76) v2(167.3,131.69) v2(167.3,118.89) v2(167.27,63.59) v2(167.35,50.99) v2(167.61,34.74) v2(167.61,33.16) v2(167.9,131.69) v2(167.9,125.27) v2(167.9,118.29) v2(167.93,63.59) v2(168.06,8.88) v2(168.16,134.31) v2(168.34,37.52) v2(168.36,83.68) v2(168.38,34.75) v2(168.4,33.92) v2(168.39,33.16) v2(168.39,32.39) v2(168.51,63.59) v2(168.49,45.48) v2(168.54,7.23) v2(169.22,42.57) v2(169.19,39.86) v2(169.18,34.75) v2(169.18,33.92) v2(169.18,33.16) v2(169.18,32.39) v2(169.25,69.36) v2(169.29,68.7) v2(169.29,68.1) v2(169.28,37.49) v2(169.83,45.1) v2(169.89,134.31) v2(169.91,30.09) v2(170.32,40.5) v2(170.27,28.81) v2(170.71,30.15) v2(170.89,99.88) v2(171.31,42.57) v2(171.32,23.04) v2(171.52,26.72) v2(171.61,134.31) v2(171.62,36.62) v2(171.74,46.16) v2(171.79,29.15) v2(172.22,36.3) v2(172.3,44.52) v2(172.52,29.11) v2(172.57,104.51) v2(172.55,28.29) v2(172.68,5.76) v2(172.77,31.64) v2(172.88,63.22) v2(173.03,63.79) v2(172.96,37.66) v2(173.21,62.74) v2(173.21,45.1) v2(173.34,134.31) v2(173.31,27.22) v2(173.42,29.1) v2(173.42,28.29) v2(173.5,63.44) v2(173.49,30.44) v2(173.63,62.31) v2(173.57,45.79) v2(173.54,25.09) v2(173.54,23.92) v2(173.69,42.59) v2(173.8,62.93) v2(173.82,39.28) v2(174.13,61.86) v2(174.22,106.51) v2(174.22,105.11) v2(174.23,62.47) v2(174.21,38.77) v2(174.24,37.3) v2(174.31,36.42) v2(174.31,34.01) v2(174.43,114.57) v2(174.41,5.76) v2(174.63,116.2) v2(174.79,45.18) v2(174.87,41.41) v2(175.02,54.93) v2(175.07,134.31) v2(175.06,100.71) v2(175.06,99.88) v2(175.06,36.4) v2(175.64,55.55) v2(175.64,54.31) v2(175.59,45.92) v2(175.58,40.4) v2(175.73,39.26) v2(175.82,33.99) v2(175.89,107.77) v2(175.89,103.11) v2(175.89,99.03) v2(176.13,5.76) v2(176.17,41.12) v2(176.26,54.93) v2(176.38,38.43) v2(176.53,40.43) v2(176.57,42.59) v2(176.54,39.26) v2(176.58,33.99) v2(176.71,42.01) v2(176.79,134.31) v2(176.79,86.48) v2(176.9,25.85) v2(177.3,112.61) v2(177.6,125.69) v2(177.6,124.89) v2(177.66,45.08) v2(177.84,40.78) v2(177.76,38.51) v2(177.78,34.03) v2(177.79,31.66) v2(177.78,27.12) v2(177.86,5.76) v2(178.4,129.69) v2(178.4,121.69) v2(178.39,78.11) v2(178.52,134.31) v2(178.46,97.31) v2(178.46,96.48) v2(179.2,129.69) v2(179.29,99.81) v2(179.29,80.63) v2(179.48,23.19) v2(179.62,22.24) v2(179.59,5.76) v2(180.09,82.31) v2(180.09,80.63) v2(180.09,79.81) v2(180.07,23.19) v2(180.25,134.31) v2(180.32,33.8) v2(180.48,34.89) v2(180.48,31.82) v2(180.89,99.81) v2(180.89,79.81) v2(181.06,40.35) v2(181.2,114.29) v2(181.28,115.56) v2(181.32,5.76) v2(181.69,79.81) v2(181.69,74.91) v2(181.98,134.31) v2(182.49,99.81) v2(182.52,98.98) v2(182.49,95.63) v2(182.64,97.75) v2(182.92,60.8) v2(183.09,93.13) v2(183.09,78.13) v2(183.04,5.76) v2(183.2,132.09) v2(183.24,98.98) v2(183.52,60.8) v2(183.7,134.31) v2(183.69,95.63) v2(183.69,93.98) v2(183.8,112.59) v2(183.92,98.98) v2(183.89,96.91) v2(183.92,80.63) v2(183.96,17.14) v2(184.13,60.8) v2(184.74,60.8) v2(184.77,5.76) v2(185.24,30.77) v2(185.23,7.36) v2(185.43,134.31) v2(185.35,60.8) v2(185.8,30.98) v2(185.94,60.8) v2(185.89,17.14) v2(186.04,9.34) v2(186.38,30.97) v2(186.6,118.89) v2(186.6,118.29) v2(186.55,60.8) v2(187,71.95) v2(187.16,134.31) v2(187.2,118.89) v2(187.2,118.29) v2(187.18,68.24) v2(187.16,60.8) v2(187.63,71.9) v2(187.72,67.88) v2(187.74,60.8) v2(187.94,92.29) v2(188.15,61.41) v2(188.27,71.92) v2(188.27,68.21) v2(188.27,9.52) v2(188.35,60.85) v2(188.51,42.98) v2(188.76,61.41) v2(188.81,41.8) v2(188.88,134.31) v2(188.91,68.21) v2(188.94,60.82) v2(188.95,71.92) v2(188.99,67.25) v2(188.99,66.67) v2(188.99,66.06) v2(188.96,65.45) v2(188.96,64.84) v2(188.96,64.23) v2(188.96,63.62) v2(188.96,63.03) v2(189.06,44.85) v2(189.16,92.24) v2(189.59,86.99) v2(189.58,18.09) v2(189.71,83.28) v2(190,9.52) v2(190.06,41.83) v2(190.21,44.87) v2(190.16,43.5) v2(190.17,18.09) v2(190.24,33.18) v2(190.64,134.31) v2(190.79,86.99) v2(190.91,83.28) v2(191.48,92.22) v2(191.7,128.82) v2(191.73,9.52) v2(191.88,31.74) v2(191.99,86.99) v2(192.14,102.78) v2(192.36,134.31) v2(192.46,127.17) v2(192.59,130.59) v2(193.13,43.98) v2(193.18,84.45) v2(193.3,42) v2(193.33,40.05) v2(193.41,104.06) v2(193.46,9.52) v2(193.99,27.53) v2(194.09,134.31) v2(194.11,131.23) v2(194.11,126.66) v2(194.17,20.21) v2(194.27,78.6) v2(194.61,20.59) v2(194.66,59.43) v2(194.66,58.79) v2(194.76,122.91) v2(194.98,119.04) v2(195.08,71.49) v2(195.08,70.86) v2(195.08,70.22) v2(195.08,69.59) v2(195.13,42) v2(195.13,40.12) v2(195.18,9.52) v2(195.4,122.89) v2(195.41,72) v2(195.46,118.63) v2(195.63,127.29) v2(195.63,31.49) v2(195.72,71.49) v2(195.72,70.86) v2(195.72,70.22) v2(195.72,69.59) v2(195.82,134.31) v2(195.76,130.59) v2(195.79,27.55) v2(196.07,72.02) v2(196.05,41.7) v2(196.05,39.54) v2(196.16,59.43) v2(196.17,58.8) v2(196.27,128.82) v2(196.38,91.96) v2(196.35,71.49) v2(196.35,70.86) v2(196.35,70.22) v2(196.35,69.59) v2(196.73,72) v2(196.8,59.43) v2(196.8,58.8) v2(196.91,9.52) v2(197.01,71.47) v2(196.99,70.86) v2(196.99,70.22) v2(196.99,69.59) v2(197.55,134.31) v2(197.62,71.49) v2(197.62,70.86) v2(197.62,70.22) v2(197.62,69.59) v2(197.65,91.99) v2(197.72,40.58) v2(198.08,133.16) v2(198.26,71.49) v2(198.26,70.86) v2(198.26,70.22) v2(198.26,69.59) v2(198.64,125.85) v2(198.85,91.99) v2(198.89,71.49) v2(198.89,70.86) v2(198.89,70.22) v2(199.37,40.77) v2(199.35,39.79) v2(199.53,71.49) v2(199.53,70.86) v2(199.53,70.22) v2(199.45,33.26) v2(200.19,71.44) v2(200.16,70.86) v2(200.16,70.22) v2(200.26,101.06) v2(200.26,100.26) v2(200.26,84.68) v2(200.26,83.88) v2(200.8,71.49) v2(200.8,70.86) v2(200.8,70.22) v2(200.85,125.49) v2(201.03,39.84) v2(201.28,40.39) v2(201.43,71.49) v2(201.43,70.86) v2(201.43,70.22) v2(201.43,69.59) v2(201.38,33.26) v2(202.07,71.49) v2(202.07,70.86) v2(202.07,70.22) v2(202.07,69.59) v2(202.57,125.49) v2(202.7,71.49) v2(202.7,70.86) v2(202.7,70.22) v2(202.7,69.59) v2(203.34,71.49) v2(203.34,70.86) v2(203.34,70.22) v2(203.34,69.59) v2(203.26,39.26) v2(203.41,40.25) v2(203.46,85.48) v2(203.49,59.3) v2(204.07,59.27) v2(204.3,125.49) v2(204.26,99.46) v2(204.26,85.48) v2(204.57,52.96) v2(205.19,53.58) v2(205.19,52.34) v2(205.81,52.96) v2(206.03,125.49) v2(206.13,113.66) v2(206.13,113.02) v2(207.02,118.4) v2(207.15,112.77) v2(207.76,125.49) v2(207.84,9.53) v2(208.26,101.06) v2(208.26,100.26) v2(208.26,84.68) v2(208.26,83.88) v2(209.06,102.66) v2(209.2,9.52) v2(209.48,125.49) v2(210.27,118.61) v2(210.66,105.06) v2(210.66,84.68) v2(210.66,79.88) v2(210.86,118.58) v2(210.93,9.52) v2(211.21,125.49) v2(211.31,28.09) v2(211.44,118.66) v2(211.46,30.25) v2(211.97,53.08) v2(212.64,54.79) v2(212.61,51.43) v2(212.99,125.31) v2(213.09,123.59) v2(213.09,121.86) v2(213.09,120.13) v2(213.09,118.4) v2(213.09,116.68) v2(213.09,114.95) v2(213.09,113.22) v2(213.09,111.5) v2(213.09,109.77) v2(213.09,108.04) v2(213.09,106.31) v2(213.09,104.59) v2(213.09,102.86) v2(213.09,101.13) v2(213.09,99.41) v2(213.09,97.68) v2(213.09,95.95) v2(213.09,94.22) v2(213.09,92.5) v2(213.09,90.77) v2(213.09,89.04) v2(213.09,87.32) v2(213.09,85.59) v2(213.09,83.86) v2(213.09,82.13) v2(213.14,80.51) v2(213.34,78.04) v2(213.65,75.86) v2(214.08,73.6) v2(214.16,50.86) v2(214.18,10.91) v2(214.26,55.36) v2(214.39,9.52) v2(214.67,71.47) v2(214.77,10.91) v2(215.33,69.36) v2(215.68,51.49) v2(215.71,43.02) v2(215.71,42.38) v2(215.78,54.6) v2(216.11,9.52) v2(216.19,67.17) v2(216.42,52.95) v2(216.34,43.02) v2(216.34,42.38) v2(216.98,43.02) v2(216.98,42.38) v2(217.08,65.29) v2(217.61,43.02) v2(217.61,42.38) v2(217.84,9.52) v2(217.97,63.57) v2(219.01,61.79) v2(219.57,9.52) v2(220.23,59.96) v2(220.53,55.92) v2(220.61,53.66) v2(220.99,57.95) v2(221.29,9.52) v2(222.11,51.88) v2(223.02,9.52) v2(223.16,43.65) v2(224.32,51.43) v2(224.75,9.52) v2(226.48,9.52) v2(226.55,51.96) v2(226.55,45.18) v2(226.55,44.54) v2(226.83,47.36) v2(226.83,46.73) v2(226.84,46.05) v2(227.14,45.18) v2(227.14,44.54) v2(228.13,36.11) v2(228.2,9.52) v2(228.31,51.53) v2(229.93,50.41) v2(229.93,9.52) v2(231.68,49.29) v2(231.66,9.52) v2(233.39,9.52) v2(233.72,48.12) v2(234.07,11.17) v2(234.71,11.17) v2(235.11,9.52) v2(235.34,11.17) v2(235.47,47.23) v2(235.98,11.17) v2(236.84,9.52) v2(237.47,46.37) v2(237.5,17.01) v2(238.13,17.01) v2(238.57,9.52) v2(238.8,16.73) v2(239.43,16.73) v2(239.63,45.58) v2(240.29,9.52) v2(241.84,44.92) v2(242.02,9.52) v2(243.65,44.49) v2(243.75,9.52) v2(245.3,44.16) v2(245.48,9.52) v2(246.97,43.91) v2(247.2,9.52) v2(248.85,43.7) v2(248.93,9.52) v2(250.45,15.61) v2(250.56,43.6) v2(250.66,9.52) v2(251.22,39.77) v2(252.28,43.58) v2(252.38,9.52) v2(253.1,15.43) v2(253.12,14.85) v2(253.12,14.21) v2(253.3,39.74) v2(253.43,16.53) v2(253.76,15.43) v2(253.76,14.85) v2(253.76,14.21) v2(254.06,43.65) v2(254.11,9.52) v2(254.39,15.43) v2(254.39,14.85) v2(254.86,42.25) v2(255.03,15.43) v2(255.03,14.85) v2(255.84,9.52) v2(256.02,43.81) v2(256.36,42.27) v2(257.24,18.63) v2(257.24,18.02) v2(257.24,17.41) v2(257.24,16.83) v2(257.55,37.48) v2(257.57,35.92) v2(257.57,9.52) v2(257.74,44.03) v2(258.79,37.96) v2(258.81,36.19) v2(259.29,9.52) v2(259.55,44.34) v2(260.18,43.4) v2(260.79,15.56) v2(261.02,9.52) v2(261.27,44.74) v2(261.38,15.59) v2(261.52,42.36) v2(262.09,20.23) v2(262.09,18.79) v2(262.09,17.34) v2(262.75,9.52) v2(263.08,45.25) v2(263.53,20.23) v2(263.53,18.79) v2(263.53,17.34) v2(263.53,15.48) v2(263.51,14.9) v2(264.47,9.52) v2(264.78,45.79) v2(264.98,20.23) v2(264.98,18.79) v2(264.98,17.34) v2(265.49,37.95) v2(265.49,36.61) v2(265.49,35.26) v2(265.49,33.91) v2(265.69,15.48) v2(266.2,9.52) v2(266.33,15.48) v2(266.43,46.42) v2(266.84,37.95) v2(266.84,36.61) v2(266.84,35.26) v2(266.84,33.91) v2(267.09,28.44) v2(267.07,22.34) v2(267.6,28.08) v2(267.62,22.62) v2(267.93,9.52) v2(268.08,28.44) v2(268.21,47.18) v2(268.19,37.95) v2(268.19,36.61) v2(268.19,35.26) v2(268.19,33.91) v2(269.53,37.95) v2(269.53,36.61) v2(269.53,35.26) v2(269.53,33.91) v2(269.66,9.52) v2(270.09,48.12) v2(271.22,30.29) v2(271.74,21.81) v2(271.94,49.16) v2(273.09,20.41) v2(273.11,9.52) v2(273.62,27.78) v2(273.92,28.36) v2(273.95,50.46) v2(274.84,9.52) v2(275.93,51.91) v2(276.57,9.52) v2(277.61,40.06) v2(277.73,41.29) v2(277.89,53.56) v2(278.01,33.19) v2(278.29,9.52) v2(278.6,33.19) v2(279.21,33.16) v2(279.35,26.72) v2(279.35,24.76) v2(279.44,40.06) v2(279.77,41.3) v2(280.02,9.52) v2(280.98,37.96) v2(281.09,33.06) v2(281.31,26.72) v2(281.31,24.76) v2(281.31,22.79) v2(281.34,57.11) v2(281.35,35.42) v2(281.95,36.02) v2(281.95,34.83) v2(282.2,104.77) v2(282.55,35.42) v2(282.79,58.89) v2(282.92,32.78) v2(283.12,103.44) v2(283.28,26.72) v2(283.28,22.79) v2(283.5,107.82) v2(284.03,60.65) v2(284.16,49.57) v2(284.26,106.16) v2(284.29,101.77) v2(284.39,109.59) v2(284.62,52.77) v2(284.62,50.84) v2(284.9,45.81) v2(285,62.14) v2(285.05,114.11) v2(285.39,100.03) v2(285.46,49.72) v2(285.91,110.23) v2(285.91,105.66) v2(286.01,115.94) v2(286.01,44.69) v2(286.01,43.58) v2(286.12,64.13) v2(286.3,54.05) v2(286.61,48.94) v2(286.65,52.24) v2(286.98,65.83) v2(287.13,45.81) v2(287.13,44.69) v2(287.13,43.58) v2(287.16,54.14) v2(287.16,38.78) v2(287.43,106.29) v2(287.56,109.59) v2(287.69,48.33) v2(287.89,116.78) v2(287.87,67.83) v2(287.96,96.52) v2(287.97,42.23) v2(288.07,107.82) v2(288.62,69.92) v2(288.66,94.61) v2(289.04,38.47) v2(289.16,92.92) v2(289.16,71.64) v2(289.61,91.16) v2(289.62,73.35) v2(289.69,42.68) v2(290.03,89.13) v2(290,75.02) v2(289.94,49.88) v2(290.26,117.22) v2(290.31,87.44) v2(290.28,76.7) v2(290.5,85.66) v2(290.51,78.63) v2(290.52,48.37) v2(290.57,84.2) v2(290.69,122.82) v2(290.69,121.1) v2(290.69,119.37) v2(290.66,82.26) v2(290.66,80.38) v2(290.84,43.17) v2(290.84,9.44) v2(291.22,45.33) v2(291.68,123.48) v2(291.65,8.85) v2(292.31,81.27) v2(292.34,8.14) v2(292.52,49.77) v2(292.52,49.14) v2(293.3,7.17) v2(293.41,123.48) v2(293.46,35.78) v2(293.56,37.81) v2(293.67,81.19) v2(294.17,69.46) v2(294.26,6.21) v2(294.59,57.86) v2(294.59,56.04) v2(295.08,81.27) v2(295.41,5.07) v2(295.56,123.48) v2(296.35,69.43) v2(296.81,58.07) v2(296.8,45.02) v2(296.8,36.83) v2(296.81,24.63) v2(296.89,81.27) v2(296.86,3.58) v2(297.25,1.39) v2(297.39,123.5) v2(298,85.33) v2(299.65,123.48) v2(299.7,44.17) v2(299.64,37.98) v2(299.79,23.49) v2(299.92,85.33) v2(299.87,58.66) v2(300.44,0.5) v2(300.92,85.33) v2(301.2,37.96) v2(301.38,23.49) v2(301.6,58.66) v2(301.7,123.5) v2(301.74,44.17) v2(302.17,0.5) v2(302.4,119.12) v2(302.68,80.19) v2(302.68,78.67) v2(302.68,77.14) v2(302.68,75.09) v2(302.65,73.43) v2(302.68,71.76) v2(302.68,69.9) v2(302.68,68.3) v2(302.85,85.33) v2(302.87,81.87) v2(302.89,65.48) v2(302.93,37.96) v2(303.11,23.49) v2(303.16,117.47) v2(303.29,120.89) v2(303.32,58.66) v2(303.46,44.17) v2(303.9,0.5) v2(304.17,81.91) v2(304.81,121.53) v2(304.81,116.96) v2(304.78,65.42) v2(305.62,0.5) v2(305.8,81.91) v2(306.33,117.59) v2(306.46,120.89) v2(306.59,83.56) v2(306.58,40.94) v2(306.6,39.79) v2(306.68,42.18) v2(306.97,119.12) v2(307.03,63.9) v2(307.24,58.68) v2(307.27,62.45) v2(307.25,60.4) v2(307.25,44.16) v2(307.25,37.96) v2(307.4,23.47) v2(307.5,90.77) v2(307.5,89.04) v2(307.5,87.32) v2(307.5,85.59) v2(307.63,83.86) v2(307.78,92.85) v2(307.88,0.61) v2(308.11,6.52) v2(308.1,4.92) v2(308.1,3.86) v2(308.09,2.39) v2(308.19,114.95) v2(308.75,114.7) v2(309.18,112.49) v4(14.3,20.92) v4(17.49,26.34) v4(22.36,26.91) v4(35.57,14.58) v4(47.89,34.28) v4(58.52,16.42) v4(62.56,68.16) v4(62.57,7.2) v4(63.28,66.14) v4(81.58,116.55) v4(81.95,120.83) v4(83.54,16.82) v4(107.26,17.77) v4(109.2,118.38) v4(130.53,122.29) v4(141.31,129.87) v4(142.06,64.37) v4(142.16,55.36) v4(151.91,103.37) v4(160.26,52.44) v4(171.88,62.28) v4(174.69,63.07) v4(175.41,16.64) v4(178,71.35) v4(184.48,44.57) v4(188.72,59.98) v4(195.41,58.74) v4(197.81,68.81) v4(202.97,68.9) v4(204.01,71.07) v4(216.56,41.57) v4(216.85,41.27) v4(221.47,37.19) v4(227.33,48.83) v4(228.23,47.22) v4(233.97,10.56) v4(239.48,15.75) v4(255.09,14.29) v4(268.31,22.34) v4(268.87,43.59)
