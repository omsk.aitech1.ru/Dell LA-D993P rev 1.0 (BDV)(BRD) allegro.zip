# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
BT_RADIO_DIS#_R: length 6.1
  BOTTOM w0.114: JNGFF1.46 197.56,31.58 196.53,32.61 v3(196.53,34.05) 196.53,34.67 DN2.2
BTST_CHG:
  vias: v3(29.85,34.08)
CAM_CBL_DET#: length 98.1
  TOP w0.114: v2(232.57,42.42) v3(231.94,42.42)
  IN3 w0.127: v2(232.57,42.42) 232.83,42.16 232.83,41.55 230.3,39.03 227.04,39.03 226,37.98 224.93,36.91 224.93,35.94 224.65,35.66 220.72,35.66 217.26,35.66 216.28,34.69 215.78,34.18 209.23,34.18 206.91,36.49 194.6,36.49 192.06,39.03 188.48,39.03 v2(187.62,38.17)
  IN4 w0.094: v2(155.2,37.84) 155.51,37.84 157.67,40 157.67,42.03 158.89,43.25 163.28,43.25 163.7,43.67 176.24,43.67 178.24,41.67 178.24,41.22 180.26,39.2 180.7,39.2 181.73,38.17 v2(187.62,38.17)
  BOTTOM w0.114: JCAM1.10 232.02,42.7 232.29,42.42 v2(232.57,42.42) ; v2(155.2,37.84) 155.05,37.84 154.54,37.33 RH79.1 154.52,37.23 155.03,36.72 155.88,36.72 156.41,36.19 156.7,36.19 157.01,35.87 157.75,35.87 UH2.U43
CAP_LED: length 29.4
  TOP w0.114: JKB1.4 197.84,54.51 199.23,53.12 199.23,50.56 199.93,49.85 199.93,48.91 202.2,46.64 207.49,46.64 207.78,46.35 207.78,42.46 v4(208.89,41.35) 212.19,38.05 212.19,36.73 211.64,36.19 RE2.2
CAPS_LED#: length 33.3
  TOP w0.114: v2(237.15,32.96) 237.02,32.83 236.45,32.83 234.81,31.2 234.81,30.18 234.82,30.18 234.82,29.12 234.99,28.94 UE1.93 ; QE3.3 215.53,32.96 RE120.1 v4(217.9,32.96) 218.96,32.96 v2(219.75,33.75)
  IN3 w0.127: v2(237.15,32.96) 237.15,34.07 233.47,37.75 228.74,37.75 228.41,37.42 227.69,37.42 226.25,35.97 226.25,35.73 226.25,35.17 225.47,34.39 220.72,34.39 220.07,33.75 v2(219.75,33.75)
CFG0: length 2.3
  TOP w0.114: v3(90.32,91.04) 90.32,91.19 89.91,91.6 v2(89.86,91.6) 89.86,91.57 RH183.1
  BOTTOM w0.114: UH1.BN25 89.53,91.28 v2(89.86,91.6)
CFG2: length 2.3
  TOP w0.114: v3(89.43,92.06) 89.43,91.82 v2(89.21,91.6) 89.01,91.6 RH184.1
  BOTTOM w0.114: v2(89.21,91.6) 89.53,91.93 UH1.BN26
CFG4: length 6.1
  BOTTOM w0.114: UH1.BR20 88.18,87.27 87.84,86.93 86.88,86.93 85.85,85.91 RH185.1 84.82,85.42 83.45,85.42 v3(83.07,85.04)
CFG5: length 7.9
  BOTTOM w0.114: UH1.BM20 90.36,87.1 90.52,86.94 90.52,86.35 90.27,86.1 86.67,86.1 85.53,84.95 RH186.1 85.3,84.42 v3(85.7,84.03)
CFG6: length 5
  BOTTOM w0.114: UH1.BT20 86.76,87.27 86.34,86.86 RH187.1 84.83,86.39 v3(82.92,86.39)
CFG7: length 3.8
  BOTTOM w0.114: UH1.BP20 88.53,87.62 85.43,87.62 RH188.1
CFG_RCOMP: length 3
  BOTTOM w0.254: RH59.1 85.56,89.53 87.24,91.21 UH1.BT25
CHG_B+:
  vias: v2(17.54,23.74) v2(17.54,23.1) v2(17.54,22.47) v2(17.54,21.83) v2(18.17,23.74) v2(18.17,23.1) v2(18.17,22.47) v2(18.17,21.83) v2(18.81,23.74) v2(18.81,23.1) v4(17.4,19.51)
CHG_SMBCLK: length 4.2
  BOTTOM w0.114: PU300.12 30.27,39.98 30.59,40.3 31.47,40.3 31.58,40.41 v3(31.9,40.41) 32.38,40.41 PR328.1
CHG_SMBDAT: length 3.6
  BOTTOM w0.114: PR327.1 31.94,40.86 31.48,40.86 31.15,40.53 30.48,40.53 29.87,39.92 PU300.11
CLK_PCI_LPC_MEC: length 81.7
  TOP w0.114: RH168.2 170.57,16.81 170.39,16.63 CC4.2 170.39,16.19 170.1,15.9 170.1,14.08 170.47,13.71 170.67,13.71 172.37,12 172.37,11.62 173.08,10.91 173.77,10.91 174.94,9.74 175.7,9.74 v2(175.78,9.67) ; v2(220.07,16.04) 220.07,15.59 220.57,15.09 220.57,14.08 220.95,13.69 220.95,12.04 222.84,10.15 227.87,10.15 v3(228.52,10.8) 229.55,11.84 229.55,12.46 RE10.2 228.99,13.82 229.63,14.46 229.85,14.46 230.45,15.05 231.23,15.05 231.45,15.28 UE1.57
  IN4 w0.094: v2(220.07,16.04) 219.13,16.98 217.82,16.98 217.62,17.18 215.42,17.18 214.11,15.87 211.83,15.87 210.54,17.16 200.44,17.16 195.07,11.79 183.06,11.79 180.41,9.15 176.3,9.15 v2(175.78,9.67)
CLK_PCI_LPDEBUG: length 72.4
  TOP w0.114: v3(185.93,27.19) 185.74,27.01 v2(185.74,26.7) 185.74,26.25 185.19,25.69 RH16.2 185.19,24.29 CC5.2
  IN4 w0.094: v2(185.74,26.7) 188.59,29.54 190.9,29.54 v2(191.85,30.49) 192.61,30.49 193.96,29.14 204.01,29.14 204.44,28.71 208.26,28.71 208.57,29.02 212.85,29.02 213.27,28.6 214.72,28.6 216.01,27.31 217.14,27.31 217.2,27.25 217.2,27.25 217.94,26.51 220.58,26.51 221.39,25.71 223.75,25.71 224.01,25.97 224.22,26.18 229.41,26.18 229.42,26.16 233.31,26.16 233.43,26.28 235.5,26.28 236.8,27.59 242.16,27.59 242.51,27.23 v2(243.26,27.23)
  BOTTOM w0.114: v2(191.85,30.49) 191.56,30.2 JNGFF1.22 ; v2(243.26,27.23) 243.09,27.23 242.13,28.2 242.13,30.99 242.52,31.38 JLPDE1.10
CLK_PCIE_LAN: length 127
  IN1 w0.094: v2(289.44,42.15) 289.16,42.15 289.07,42.06 289.07,41.61 287.83,40.37 281.59,40.37 279.18,37.96 275.45,37.96 274.91,37.42 273.33,37.42 272.15,36.24 271.39,36.24 270.14,34.99 270.14,33.65 269.42,32.93 264.61,32.93 263.09,31.41 263.09,30.48 262.6,29.99 261.72,29.99 261.2,30.51 255.73,30.51 255,29.78 234.44,29.78 234.38,29.72 219.52,29.72 218.53,30.72 211.44,30.72 210.04,32.11 207.91,32.11 206.13,33.89 201.25,33.89 200.67,34.47 189.79,34.47 186.29,37.97 183.78,37.97 182.86,38.88 181.86,38.88 180.98,39.76 180.63,39.76 178.65,41.74 178.06,41.74 v2(177.82,41.5)
  BOTTOM w0.114: v2(289.44,42.15) 289.24,42.35 289.24,43.24 288.93,43.55 288.68,43.55 288.54,43.69 UL1.15 ; UH2.F2 v2(177.82,41.5)
CLK_PCIE_LAN#: length 127
  IN1 w0.094: v2(288.58,42.15) 288.76,42.15 288.88,42.03 288.88,41.69 287.75,40.55 281.52,40.55 279.1,38.14 275.37,38.14 274.84,37.61 273.25,37.61 272.07,36.42 271.31,36.42 269.95,35.07 269.95,33.72 269.35,33.12 264.53,33.12 262.9,31.49 262.9,30.55 262.52,30.17 261.8,30.17 261.27,30.7 255.65,30.7 254.92,29.97 234.36,29.97 234.3,29.91 219.6,29.91 218.6,30.9 211.52,30.9 210.12,32.3 207.99,32.3 206.21,34.08 201.33,34.08 200.75,34.66 189.86,34.66 186.37,38.15 183.86,38.15 182.94,39.07 181.94,39.07 181.06,39.94 180.71,39.94 178.72,41.93 177.4,41.93 v2(177.35,41.98)
  BOTTOM w0.114: v2(288.58,42.15) 288.71,42.03 288.81,42.03 289.02,42.24 289.02,43.15 288.84,43.33 288.59,43.33 288.59,43.33 288.55,43.29 UL1.16 ; v2(177.35,41.98) 177.75,41.98 UH2.D3
CLK_PCIE_SSD: length 52.2
  IN1 w0.094: v2(210.88,30.1) 210.7,30.1 210.5,30.3 210.5,30.62 209.6,31.52 205.78,31.52 204.66,32.65 199.04,32.65 195.96,29.58 189.61,29.58 188.47,30.72 188.47,32.41 186.31,34.57 182.64,34.57 181.03,36.17 178.83,36.17 178.2,36.81 175.66,36.81 175.54,36.93 175.54,37.07 175.77,37.3 v2(175.77,37.3)
  BOTTOM w0.114: v2(210.88,30.1) 210.88,29.56 211.99,28.45 211.99,27.42 210.29,25.73 210.29,23.81 209.81,23.33 JNGFF2.55 ; v2(175.77,37.3) 176.15,36.92 UH2.R7
CLK_PCIE_SSD#: length 52.2
  IN1 w0.094: v2(175.01,37.3) 175.17,37.3 175.33,37.14 175.33,36.87 175.58,36.62 178.12,36.62 178.76,35.99 180.95,35.99 182.56,34.38 186.23,34.38 188.28,32.33 188.28,30.64 189.53,29.39 196.04,29.39 199.11,32.46 204.58,32.46 205.71,31.34 209.52,31.34 210.31,30.55 210.31,30.14 v2(210.19,30.03)
  BOTTOM w0.114: JNGFF2.53 209.23,23.83 209.51,23.55 209.72,23.55 210.07,23.9 210.07,25.82 211.76,27.51 211.76,28.36 210.65,29.47 210.65,29.74 210.37,30.03 v2(210.19,30.03) ; v2(175.01,37.3) 175.39,36.92 UH2.R8
CLK_PCIE_WLAN: length 42
  IN1 w0.094: v2(190.84,33.19) 191.04,33.38 191.04,33.65 190.84,33.85 189.58,33.85 186.05,37.38 183.44,37.38 182.55,38.27 181.64,38.27 180.78,39.13 180.3,39.13 179.63,39.8 177.91,39.8 177.17,40.54 177.17,40.73 176.95,40.95 176.95,40.96 176.79,41.11 v2(176.77,41.11)
  BOTTOM w0.114: JNGFF1.39 195.81,22.8 195.94,22.93 195.94,24.51 196.28,24.84 196.28,27.8 196.02,28.06 193.91,28.06 192.75,26.89 188.96,26.89 187.39,28.47 187.39,30.18 188.54,31.33 189.15,31.33 190.46,32.64 190.95,32.64 191.12,32.81 191.12,32.91 v2(190.84,33.19) ; UH2.G4 177.24,40.64 v2(176.77,41.11)
CLK_PCIE_WLAN#: length 42
  IN1 w0.094: v2(191.6,33.19) 191.45,33.19 191.22,33.42 191.22,33.73 190.92,34.03 189.66,34.03 186.13,37.56 183.52,37.56 182.63,38.45 181.72,38.45 180.85,39.31 180.38,39.31 179.7,39.99 177.98,39.99 177.35,40.62 v2(177.35,41.11)
  BOTTOM w0.114: UH2.E5 177.28,41.57 177.38,41.47 177.38,41.14 v2(177.35,41.11) ; JNGFF1.41 196.31,22.8 196.16,22.95 196.16,24.41 196.5,24.75 196.5,27.9 196.11,28.28 193.82,28.28 192.66,27.12 189.05,27.12 187.61,28.56 187.61,30.08 188.63,31.11 189.24,31.11 190.55,32.42 191.04,32.42 191.34,32.72 191.34,32.93 v2(191.6,33.19)
CLK_PEG_N16P: length 82.6
  IN4 w0.094: v2(157.49,86.45) 157.08,86.05 157.08,85.39 156.9,85.21 156.9,83.58 159.54,80.94 162.19,78.29 164.8,78.29 166.53,76.56 167.84,76.56 169.04,75.35 170.01,75.35 170.76,74.61 170.91,74.61 171.24,74.61 172.37,73.48 172.96,73.48 174.3,72.14 174.3,68.02 174.88,67.43 174.88,65.98 193.3,47.56 193.56,47.56 193.9,47.21 193.9,43.6 193.59,43.28 193.32,43.28 v2(193.2,43.4)
  BOTTOM w0.114: v2(157.49,86.45) 157.1,86.06 UV1.AL13 ; v2(193.2,43.4) 192.9,43.09 192.75,43.09 191.93,42.28 191.93,41.65 190.23,39.95 187.84,39.95 187.69,39.8 186.9,39.8 185.84,38.74 185.84,38.31 185.4,37.86 181.08,37.86 179.21,36 178.7,36 178.65,35.96 178.24,35.96 177.97,35.68 UH2.U3
CLK_PEG_N16P#: length 82.7
  IN4 w0.094: v2(193.25,42.59) 193.13,42.71 193.13,42.92 193.21,43 193.37,43 193.47,43.1 193.66,43.1 194.09,43.52 194.09,47.29 193.63,47.74 193.38,47.74 175.07,66.06 175.07,67.51 174.48,68.09 174.48,72.21 173.03,73.66 172.45,73.66 171.32,74.79 170.83,74.79 170.09,75.54 169.12,75.54 167.91,76.74 166.61,76.74 164.88,78.48 162.27,78.48 159.73,81.01 159.73,81.01 157.08,83.66 157.08,85.13 157.27,85.32 157.27,85.59 157.36,85.68 v2(157.49,85.68)
  BOTTOM w0.114: UH2.U2 178.37,35.66 178.37,35.48 178.42,35.42 178.62,35.42 178.7,35.5 178.7,35.72 178.78,35.8 179.33,35.8 181.17,37.64 185.49,37.64 186.06,38.22 186.06,38.65 186.99,39.58 187.78,39.58 187.93,39.72 190.33,39.72 192.16,41.55 192.16,42.19 192.83,42.87 193.1,42.87 193.25,42.71 v2(193.25,42.59) ; v2(157.49,85.68) 157.87,86.06 UV1.AK13
CLK_REQ: length 18.9
  TOP w0.114: QV3.3 147.46,79.45 148.17,78.74 148.69,78.74 148.95,79 148.95,81.61 149.37,82.03 149.41,82.03 149.69,82.31 149.69,82.35 149.91,82.57 150.44,82.57 150.97,82.03 RV57.1 151.42,82.37 151.91,82.37 152.08,82.54 152.38,82.54 152.58,82.74 154.06,82.74 156.17,84.85 156.94,84.85 157.03,84.94 158.64,84.94 159.17,85.46 v2(159.17,85.69)
  BOTTOM w0.114: v2(159.17,85.69) 158.28,85.69 157.89,85.3 UV1.AK12
CLK_SMB: length 21.8
  BOTTOM w0.114: JBAT10.4 40.69,12.6 39.93,13.36 39.93,13.86 39.57,14.21 38.21,14.21 36.57,15.85 26.49,15.85 v2(26.27,16.07) 26.06,15.85 24.38,15.85 23.72,15.19 23.72,14.48 PR108.1
CLK_TP_SIO: length 124.4
  TOP w0.114: UE1.78 237.06,22.94 v2(237.14,23.03)
  IN4 w0.094: v2(237.14,23.03) 236.72,23.03 236.39,22.69 232.94,22.69 232.04,21.78 228.96,21.78 227.39,20.21 225.65,20.21 225.04,20.82 224.04,20.82 223.6,21.25 220.2,21.25 219.65,21.8 217.79,21.8 217.1,22.48 214.95,22.48 214.51,22.93 199.76,22.93 198.17,21.33 195.89,21.33 195.29,20.73 195.29,19.16 193.46,17.34 189.14,17.34 188.32,18.15 182.83,18.15 179.22,14.55 173.31,14.55 171.67,16.19 170,16.19 168.35,17.84 156.17,17.84 154.99,19.02 151.35,19.02 149.37,21 148.54,21 v2(148.14,20.6)
  BOTTOM w0.114: v2(237.14,23.03) 237.07,23.1 RE24.2 ; JTP.1 139.76,15 138.99,14.23 138.99,11.57 139.62,10.94 144.14,10.94 145.33,12.12 DE4.4 145.33,14.21 145.22,14.32 145.22,15.01 145.68,15.47 145.68,15.57 145.95,15.84 146.64,15.84 CE10.1 147.55,15.73 147.55,15.9 147.81,16.16 147.81,17.64 148.58,18.41 148.58,20.16 v2(148.14,20.6)
CLKDET#: length 2
  TOP w0.114: v2(169.08,23.05) 169.4,23.05 RH126.1
  BOTTOM w0.089: UH2.BB22 168.75,23.13 169.01,23.13 v2(169.08,23.05)
CLKOUT_LPC0: length 4.9
  TOP w0.114: v2(170.54,20.64) 170.34,20.64 170.16,20.46 170.16,19.52 170.57,19.11 RH168.1
  BOTTOM w0.076: v2(170.54,20.64) 170.82,20.93 170.82,21.99 171.16,22.32 171.16,22.63 UH2.BC17
CLKOUT_LPC1: length 18.6
  TOP w0.114: RH16.1 184.27,25.66 v3(184.77,26.15) 185.16,26.54 v2(185.16,26.7)
  IN4 w0.094: v2(170.25,25.81) 170.62,25.44 172.4,25.44 172.45,25.49 173.77,25.49 174.32,26.04 175.92,26.04 176.49,25.47 177.59,25.47 177.72,25.61 184.07,25.61 v2(185.16,26.7)
  BOTTOM w0.089: v2(170.25,25.81) 170.2,25.81 UH2.AV19
CLKREQ_PCIE#0: length 5.3
  BOTTOM w0.076: 167.98,19.55 167.47,19.55 167.35,19.68 167.35,20.23 167.6,20.49 167.6,21.52 167.43,21.69 167.43,22.2 167.36,22.27 167.36,22.56 167.52,22.72 UH2.BC24
  BOTTOM w0.102: 167.98,19.55 168.42,19.11 RP2.6
CLKRUN#: length 84.8
  TOP w0.114: v2(231.05,23.84) 231.25,23.64 231.25,22.96 232.3,21.91 232.3,20.58 233.25,19.63 233.25,19.29 233.91,18.63 233.91,17.05 233.85,16.99 UE1.63 ; v2(168.01,25.14) 168.01,24.75 v3(168.24,24.52) 168.56,24.19 168.56,22.75 168.99,22.33 168.99,21.3 168.91,21.22 168.91,18.98 RH85.1
  IN4 w0.094: v2(231.05,23.84) 230.98,23.91 229.59,23.91 229.29,23.6 224.38,23.6 223.95,24.03 220.69,24.03 220.1,24.62 216.14,24.62 214.08,26.68 211.98,26.68 211.56,26.27 205.19,26.27 204.2,25.27 193.99,25.27 191.27,22.56 180.52,22.56 180.39,22.68 179.04,22.68 178.28,21.93 173.64,21.93 172.15,23.42 170.82,23.42 170.79,23.38 170.08,23.38 169.69,23.76 169.69,24.32 168.88,25.14 v2(168.01,25.14)
  BOTTOM w0.089: UH2.AW22 168.49,24.63 168.01,25.11 v2(168.01,25.14)
CMP_STRAP0: length 4
  TOP w0.114: v2(226.07,30.39) 225.85,30.61 UE1.118 225.85,33.01 v3(226.22,33.38)
  BOTTOM w0.114: RE28.1 v2(226.07,30.39)
CMP_VIN0: length 19.6
  TOP w0.114: UE1.20 221.17,22.54 221.33,22.38 221.33,21.96 221.94,21.36 221.94,20.44 222.44,19.94 v2(222.44,18.85)
  BOTTOM w0.114: v2(222.44,18.85) 223.01,18.85 223.31,19.15 224.9,19.15 v3(225.37,19.62) 225.8,19.62 226.76,20.58 226.76,21.15 227.86,22.25 228.84,22.25 231.34,24.76 RE33.1 233.56,25.72 RE73.1
CMP_VOUT0: length 281.4
  TOP w0.114: v2(234.03,25.27) 234.03,25.54 234.24,25.74 UE1.85 ; v2(138.77,17.99) 138.77,18.16 139.37,18.77 142.51,18.77 143.91,20.17 143.91,23.71 146.07,25.87 146.07,28.32 145.13,29.26 145.13,35.4 v2(141.75,38.78)
  IN1 w0.094: v2(230.39,20.67) 229.18,20.67 228.52,20.02 226.03,20.02 225.61,20.44 222.95,20.44 222.51,20 217.39,20 216.94,20.45 213.74,20.45 213.03,21.15 211.97,21.15 210.37,19.55 200.14,19.55 197.71,17.12 188.56,17.12 188.13,16.69 183.67,16.69 180.26,13.28 172.56,13.28 171.54,12.26 170.2,12.26 167.98,14.48 160.2,14.48 159.52,15.15 159.52,16.41 159.09,16.84 150.92,16.84 150.25,16.17 147.37,16.17 144.78,18.77 139.86,18.77 139.07,17.99 v2(138.77,17.99) 137.66,19.09 103.47,19.09 103.03,18.66 103.03,17.59 102.6,17.16 99.78,17.16 99.25,17.69 74.78,17.69 74.11,17.02 65.9,17.02 61.61,21.31 61.61,23.65 59.08,26.19 59.08,29.8 v2(57.44,31.44)
  IN4 w0.094: v2(142.61,75.35) 143.96,75.35 144.46,74.86 144.46,73.02 143.85,72.41 143.85,65.45 140.24,61.84 140.24,43.48 142.17,41.55 142.17,39.19 v2(141.75,38.78)
  BOTTOM w0.114: v2(230.39,20.67) 230.39,21.55 231.24,22.41 v3(233.07,22.41) 233.51,22.85 RE38.2 RE33.2 234.02,25.27 v2(234.03,25.27) ; PR419.1 56.8,32.07 v2(57.44,31.44) ; v2(142.61,75.35) 143.04,75.35 143.3,75.09 145.52,75.09 145.79,75.36 148.77,75.36 149.79,76.39 QV88.3
CMPIN: length 5.4
  BOTTOM w0.114: PU300.13 30.67,39.77 30.97,40.07 32.37,40.07 32.69,40.39 v3(33.2,40.39) 33.25,40.39 PR201.1 PR200.2
CMPOUT: length 21.3
  TOP w0.114: v2(33.66,40.12) v3(34.91,40.12)
  TOP w0.254: PR207.1 PR206.1 46.23,43.08 PR205.2 46.23,41.89 v2(45.86,41.52)
  IN3 w0.254: v2(33.66,40.12) 33.74,40.05 38.17,40.05 39.69,38.52 43.37,38.52 45.86,41.01 v2(45.86,41.52)
  BOTTOM w0.203: PU300.14 31.07,39.56 31.25,39.74 32.41,39.74 32.67,40.01 33.55,40.01 v2(33.66,40.12)
CMSRC_CHG:
  vias: v3(26.68,36.97)
CODEC_BITCLK_R: length 2
  TOP w0.114: v2(277.38,24.93) 277.4,24.95 HDA1.6
  BOTTOM w0.114: v2(277.38,24.93) 277.28,24.83 RA31.2
CODEC_SDOUT_R: length 3
  TOP w0.114: HDA1.5 277.07,25.36 v2(276.87,25.56)
  BOTTOM w0.114: RA29.2 v3(276.46,25.9) 276.59,25.9 276.87,25.62 v2(276.87,25.56)
CPU_24MHZ_N: length 108.9
  IN4 w0.094: v2(137.42,95.33) 137.19,95.11 137.03,95.11 136.82,94.9 136.82,94.17 139.05,91.94 141.87,91.94 150.92,82.89 150.92,78.67 151.42,78.18 153.17,78.18 156.93,74.41 157.23,74.41 157.61,74.03 162.85,74.03 163.2,73.68 166.67,73.68 168.16,72.2 168.99,72.2 170.99,70.2 170.99,67.65 170.99,64.06 174.61,60.44 176.12,60.44 176.43,60.13 176.43,59.42 179.64,56.22 179.64,55.72 179.64,55.72 179.64,55.57 180.55,54.65 181.73,54.65 189.59,46.8 189.59,44.51 v2(189.37,44.29)
  BOTTOM w0.076: 130.1,95.13 130.08,95.14 130.04,95.14 129.16,96.02 127.93,96.02 127.79,95.88 126.05,95.88 125.96,95.97 125.96,96.13 126.04,96.21 126.22,96.21 UH1.D31
  BOTTOM w0.114: v2(137.42,95.33) 137.07,94.98 130.24,94.98 130.1,95.13 ; v2(189.37,44.29) 189.54,44.11 189.54,43.98 189.29,43.72 188.36,43.72 186.71,42.07 182.98,42.07 182.8,42.25 180.64,42.25 179.47,41.09 179.31,41.09 179.21,41.18 179.21,41.37 179.08,41.5 178.97,41.5 178.81,41.34 UH2.F1
CPU_24MHZ_P: length 108.9
  IN4 w0.094: v2(137.42,94.57) 137.49,94.65 137.49,94.81 137.38,94.92 137.11,94.92 137,94.82 137,94.25 139.13,92.13 141.94,92.13 151.11,82.96 151.11,78.75 151.5,78.36 153.24,78.36 157.01,74.6 157.3,74.6 157.69,74.22 162.93,74.22 163.28,73.87 166.75,73.87 168.23,72.38 169.07,72.38 171.18,70.27 171.18,67.57 171.18,64.14 174.69,60.63 176.2,60.63 176.62,60.21 176.62,59.5 179.82,56.29 179.82,55.64 180.63,54.84 181.81,54.84 189.77,46.87 189.77,44.52 v2(190,44.29)
  BOTTOM w0.076: UH1.E31 125.8,95.98 125.8,95.9 125.98,95.72 127.86,95.72 128,95.86 129.09,95.86 129.92,95.02 129.92,94.98 129.94,94.97
  BOTTOM w0.114: UH2.G1 178.98,40.86 179.57,40.86 180.73,42.03 182.7,42.03 182.88,41.85 186.8,41.85 188.45,43.5 189.38,43.5 189.77,43.89 189.77,44.05 v2(190,44.29) ; 129.94,94.97 130.15,94.76 137.22,94.76 v2(137.42,94.57)
CPU_TRIGGER: length 112.9
  TOP w0.114: RH192.1 134.92,94.31 v2(135.79,94.31)
  IN3 w0.127: v2(180.98,30.51) 180.98,33.49 183.5,36.01 183.5,36.75 180.77,39.47 180.7,39.47 178.97,41.21 178.97,41.33 176.86,43.44 161.74,43.44 161.43,43.75 161.43,44.83 160.83,45.43 157.08,45.43 155.12,43.46 143.29,43.46 140.08,46.67 140.08,66.07 143.21,69.2 143.21,72.42 141.83,73.8 141.83,76.87 136.2,82.49 136.2,93.89 v2(135.79,94.31)
  BOTTOM w0.076: v2(180.98,30.51) 180.98,30.3 v3(180.69,30.01) 180.16,29.48 UH2.AK1
CPU_TRIGGER_R: length 13.1
  TOP w0.114: v2(123.97,90.24) 124.89,91.16 124.89,91.2 125.53,91.84 v3(127.37,91.84) 127.4,91.87 131.82,91.87 133.33,93.38 133.33,93.86 RH192.2
  BOTTOM w0.076: v2(123.97,90.24) 123.34,90.24 UH1.J23
CPU_XDP_TCK: length 5.3
  TOP w0.114: v3(87.44,92.47) 87.92,92.94 v2(87.92,93.18)
  BOTTOM w0.076: 86.5,93.06 87.23,93.06 87.36,93.18 v2(87.92,93.18) 88.23,93.5 UH1.BR28
  BOTTOM w0.102: RH38.2 85.63,92.19 86.5,93.06
  BOTTOM w0.114: RH61.2 RH38.2
CPU_XDP_TDI: length 7.1
  TOP w0.114: RH118.2 RH56.2 86.25,95.88 86.51,96.13 v4(87.13,96.13) v2(91.35,96.13)
  BOTTOM w0.114: v2(91.35,96.13) 91.03,96.46 UH1.BL32
CPU_XDP_TDO: length 3.8
  TOP w0.114: RH115.2 RH497.2 86.76,93.21 v2(86.98,93.43) 87.36,93.81 v4(87.36,94.24)
  BOTTOM w0.076: UH1.BT28 87.12,93.57 v2(86.98,93.43)
CPU_XDP_TMS: length 184.6
  TOP w0.114: v2(184.97,35.77) v4(184.97,34.47) 184.97,33.97 184.16,33.16 184.16,31.94 RH492.2
  IN3 w0.127: v2(184.97,35.77) 185.17,35.97 185.17,36.49 183.35,38.3 182.59,38.3 180.96,39.93 180.89,39.93 179.79,41.03 179.79,42.2 178.24,43.75 178.24,45.41 176.84,46.81 171.54,46.81 170.68,45.95 151.3,45.95 149.27,43.92 143.48,43.92 140.54,46.86 140.54,65.79 143.66,68.92 143.66,72.64 143.23,73.07 143.23,73.84 143.38,73.99 143.38,76.51 144.22,77.35 144.22,78.39 142.32,80.29 141.42,80.29 139.43,82.28 139.43,96.06 131.86,103.62 90.1,103.62 88.5,102.03 88.5,100.51 87.64,99.64 87.64,96.66 v2(83.73,92.75)
  BOTTOM w0.076: UH1.BP28 88.55,93.9 86.74,93.9 86.62,93.79
  BOTTOM w0.102: 86.62,93.79 85.63,92.8 84.97,92.8
  BOTTOM w0.114: RH496.2 83.42,92.75 v2(83.73,92.75) 83.78,92.8 84.97,92.8
CPU_XDP_TRST#: length 185.4
  TOP w0.114: v2(81.32,96.28) v4(81.91,96.28)
  IN1 w0.094: v2(144.18,82.01) 142.65,80.48 142.65,79.33 142.62,79.3 142.62,75.9 143.59,74.94 143.59,74.43 144.41,73.61 144.41,68.95 142.91,67.46 142.88,67.42 140,64.54 140,45.9 149.38,36.52 149.38,35.81 150.05,35.15 150.05,30.61 151.25,29.4 153.43,29.4 155.08,27.75 164.14,27.75 165.03,26.87 165.99,26.87 166.55,26.31 167.54,26.31 169.1,24.76 169.48,24.76 169.72,24.51 170.44,24.51 171,25.07 171.8,25.07 172.01,24.86 172.01,24.05 172.59,23.47 175.74,23.47 176.26,23.99 v2(176.29,23.99)
  IN3 w0.127: v2(81.32,96.28) 81.92,96.89 81.92,98.54 90.31,106.92 132.22,106.92 141.64,97.5 141.64,84.01 143.65,82.01 v2(144.18,82.01)
  BOTTOM w0.089: v2(176.29,23.99) 176.51,24.22 UH2.AY5
  BOTTOM w0.114: UH1.BP30 88.66,95.15 88.36,95.44 87.21,95.44 87.05,95.29 86.55,95.29 85.8,96.04 84.02,96.04 83.47,95.49 RH60.2 82.97,95.49 82.18,96.28 v2(81.32,96.28)
CSON_1: length 25.1
  TOP w0.254: v2(34.73,36.82) 34.72,36.83 PC319.2 34.03,36.82 PC320.1
  IN4 w0.254: v2(41.28,19.29) 41.44,19.45 41.44,22.79 36.08,28.15 36.08,30.36 33.36,33.08 33.36,36.14 33.84,36.62 34.53,36.62 v2(34.73,36.82)
  BOTTOM w0.254: PR314.3 41.6,18.98 v2(41.28,19.29) ; PR324.2 v2(34.73,36.82)
CSOP_1: length 26.2
  TOP w0.114: PC318.2 v3(33.11,34.84)
  TOP w0.254: PC318.2 34.03,35.93 PC319.1 34.54,35.92 v2(34.81,36.19)
  IN4 w0.254: v2(42.05,19.29) 41.82,19.52 41.82,22.95 36.46,28.31 36.46,30.52 33.74,33.24 33.74,35.98 34,36.24 34.75,36.24 v2(34.81,36.19)
  BOTTOM w0.254: PR314.2 41.6,19.74 v2(42.05,19.29) ; PR322.2 34.55,35.93 v2(34.81,36.19)
CSSN_1: length 4.6
  BOTTOM w0.254: PR302.3 26.53,29.39 26.35,29.57 26.35,31.04 v3(26.04,31.35) 25.41,31.98 25.41,32.79 PR305.1
CSSN_2: length 4.1
  BOTTOM w0.203: PC311.1 26.5,35.47 v3(26.71,35.68) 26.73,35.7 27.06,35.7 27.5,36.14 PU300.1
  BOTTOM w0.254: PC311.1 PC310.2 25.61,33.91 PR305.2
CSSP_1: length 4.6
  BOTTOM w0.254: PR304.1 24.9,32.79 v3(24.9,32.02) 24.9,31.82 25.92,30.81 25.92,29.64 25.66,29.39 PR302.2
CSSP_2: length 5.7
  BOTTOM w0.114: v3(23.76,33.9) PR304.2
  BOTTOM w0.203: PU300.2 27.31,36.54 27.14,36.36
  BOTTOM w0.254: 27.14,36.36 26.96,36.19 26.01,36.19 PC309.2 24.7,34.88 PC310.1 24.71,34.76 PR304.2
DAT_SMB: length 20.8
  BOTTOM w0.114: JBAT10.5 39.19,12.73 39.71,13.25 39.71,13.77 39.48,14 38.12,14 36.48,15.64 24.47,15.64 24.15,15.32 v2(24.15,14.95) 24.15,14.51 PR109.1
DAT_TP_SIO: length 126.5
  TOP w0.114: UE1.79 236.87,23.34 236.97,23.44 237.32,23.44 237.41,23.34 v2(237.73,23.03) ; v3(149.13,19.22) 148.83,19.52 v2(148.83,20.6)
  IN4 w0.094: v2(148.83,20.6) 149.49,20.6 151.27,18.82 154.91,18.82 156.09,17.64 168.27,17.64 169.95,15.96 171.55,15.96 173.16,14.35 179.41,14.35 183.02,17.96 188.24,17.96 189.06,17.14 193.55,17.14 196.89,20.48 196.89,20.8 197.23,21.13 198.25,21.13 199.85,22.73 214.43,22.73 214.87,22.29 217.02,22.29 217.71,21.6 219.57,21.6 220.12,21.06 223.52,21.06 223.96,20.62 224.96,20.62 225.56,20.02 227.48,20.02 229.04,21.59 232.12,21.59 232.99,22.46 236.43,22.46 236.6,22.63 237.33,22.63 v2(237.73,23.03)
  BOTTOM w0.114: v2(148.83,20.6) 148.83,18.35 148.02,17.55 148.02,16 147.77,15.74 147.77,14.98 CE9.1 147.15,13.78 147.23,13.71 DE4.6 147.23,11.94 146.99,11.7 145.21,11.7 144.21,10.7 139.53,10.7 138.76,11.47 JTP.2 ; RE55.2 236.76,23.99 v2(237.73,23.03)
DDC_CLK_HDMI: length 178.8
  TOP w0.114: v2(189.54,57.29) 189.7,57.14 189.7,56.92 190.18,56.44 190.78,56.44 191.2,56.85 191.2,58.7 191.7,59.21 191.7,60.69 192.49,61.47 QV90.6 ; v2(269.48,30.71) 269.48,30.65 269.65,30.48 RM581.1 269.95,30.28 269.95,30.92 269.68,31.18 268.48,31.18 267.71,31.95 UM1.7
  IN4 w0.094: v2(189.54,57.29) 189.62,57.29 189.75,57.17 189.75,56.88 190.2,56.42 190.59,56.42 200.88,46.12 204.78,46.12 205.36,45.55 206.3,45.55 210.91,40.93 224.12,40.93 226.82,43.63 229.38,43.63 231.41,45.66 235.92,45.66 236.39,45.18 237.8,45.18 239.26,43.73 242.98,43.73 243.93,42.77 259.82,42.77 260.22,42.37 260.7,42.37 v2(261.14,42.82) 261.14,43.17 261.48,43.51 271.27,43.51 275.95,48.18 280.99,48.18 281.83,47.34 284.4,47.34 285,46.75 290.44,46.75 290.93,47.24 291.29,47.24 291.92,47.88 291.92,57.46 298.17,63.71 298.17,66.7 300.23,68.76 300.85,68.76 300.99,68.89 301.31,69.24 301.43,69.59 301.43,69.84 301.27,70.13 301.27,70.58 JHDMI1.15
  BOTTOM w0.114: v2(269.48,30.71) 269.54,30.77 270.09,30.77 270.26,30.6 270.26,29.81 269.59,29.14 267.27,29.14 262.01,34.39 262.01,39.35 260.89,40.47 260.89,42.57 v2(261.14,42.82)
DDC_DAT_HDMI: length 178.8
  TOP w0.114: v2(190.47,57.29) 190.47,58.27 190.35,58.4 190.1,58.4 189.98,58.27 189.98,56.99 190.28,56.68 190.68,56.68 190.95,56.95 190.95,58.8 191.46,59.31 191.46,60.03 191.32,60.17 QV90.3 ; UM1.8 268.11,32.48 267.95,32.32 267.95,32.05 268.58,31.42 269.78,31.42 270.19,31.02 270.19,30.33 RM578.1 270.54,30.56 v2(270.68,30.7)
  IN4 w0.094: JHDMI1.16 300.72,70.73 300.92,70.73 301.05,70.61 301.05,70.07 301.21,69.78 301.21,69.62 301.11,69.36 300.83,69.05 300.76,68.98 300.14,68.98 297.95,66.79 297.95,63.8 291.7,57.55 291.7,47.97 291.2,47.46 290.84,47.46 290.34,46.97 285.09,46.97 284.49,47.56 281.92,47.56 281.09,48.4 275.85,48.4 271.18,43.73 261.39,43.73 v2(260.49,42.83) 260.33,42.99 244.02,42.99 243.07,43.95 239.35,43.95 237.89,45.41 236.48,45.41 236.01,45.88 231.32,45.88 229.29,43.85 226.73,43.85 224.03,41.16 211,41.16 206.39,45.77 205.45,45.77 204.87,46.35 200.97,46.35 190.68,56.64 190.3,56.64 189.97,56.97 189.97,57.69 190.08,57.8 190.32,57.8 190.47,57.65 v2(190.47,57.29)
  BOTTOM w0.114: v2(260.49,42.83) 260.65,42.67 260.65,40.37 261.77,39.25 261.77,34.29 267.17,28.9 269.69,28.9 270.5,29.71 270.5,30.53 v2(270.68,30.7)
DDI1_DDPB_CTRLCLK: length 2.3
  TOP w0.114: RH141.1 v3(176.86,23.74) 176.62,23.74 v2(176.29,23.41)
  BOTTOM w0.089: v2(176.29,23.41) 176.47,23.41 UH2.BA5
DDI1_DDPB_CTRLDAT: length 1.9
  TOP w0.114: v3(176.92,22.02) 176.92,22.11 v2(177.25,22.44) 177.66,22.85 RH142.1
  BOTTOM w0.089: UH2.BC4 177.29,22.48 v2(177.25,22.44)
DDR4_DRAMRST#: length 18
  TOP w0.114: v2(95.62,26.55) v3(95.62,27.1) 95.62,28.63 97.87,30.88 v2(98.32,30.88)
  BOTTOM w0.114: JDIMM1.108 97.4,31.8 v2(98.32,30.88) ; v2(95.62,26.55) 95.62,22.58 97.41,20.8 JDIMM2.108 97.41,17.94 RD31.1
DDR_A_ACT#: length 49.5
  IN4 w0.152: v2(97.14,35.27) 94.57,35.27 94.14,35.7 94.14,39.92 94.19,39.97 94.19,44.11 93.92,44.38 93.92,58.2 96.96,61.23 96.96,68.47 97.72,69.23 97.72,70.59 98.65,71.53 v2(99.52,71.53)
  BOTTOM w0.076: v2(99.52,71.53) 99.6,71.53 100.14,72.07 100.14,72.96 100.6,73.42 100.6,74.76 UH1.AU3
  BOTTOM w0.185: v2(97.14,35.27) 97.55,35.27 98.9,33.91 JDIMM1.114
DDR_A_ALERT#: length 45.2
  IN4 w0.152: v2(99.1,34.58) 98.56,35.13 98.56,57.59 100.58,59.61 100.58,67.24 100.8,67.46 100.8,70.78 101.25,71.24 v2(101.25,76.01)
  BOTTOM w0.076: UH1.AU5 v2(101.25,76.01)
  BOTTOM w0.185: JDIMM1.116 99.4,34.28 v2(99.1,34.58)
DDR_A_BG0: length 49.6
  IN4 w0.152: v2(97.14,37.63) 97.06,37.63 96.56,37.12 96.56,36.09 96.22,35.75 94.93,35.75 94.62,36.06 94.62,39.64 94.87,39.89 94.87,41.42 94.68,41.62 94.68,43.04 94.87,43.24 94.87,44.16 94.44,44.59 94.44,58.03 97.44,61.03 97.44,68.22 98.24,69.02 98.24,70.12 99.03,70.92 v2(99.53,70.92)
  BOTTOM w0.076: UH1.AU1 100.88,73.38 100.39,72.88 100.39,71.38 99.92,70.92 v2(99.53,70.92)
  BOTTOM w0.185: v2(97.14,37.63) 97.37,37.63 97.94,38.21 97.94,38.36 99.15,39.57 JDIMM1.115
DDR_A_BG1: length 50
  IN4 w0.152: v2(99.55,67.05) 99.55,60.04 97.5,58 97.5,57.39 97.29,57.18 96.88,57.18 96.67,56.96 96.67,56.54 96.88,56.32 97.29,56.32 97.5,56.11 97.5,55.68 97.29,55.47 96.88,55.47 96.67,55.26 96.67,54.83 96.88,54.62 97.29,54.62 97.5,54.4 97.5,53.98 97.29,53.76 96.88,53.76 96.67,53.55 96.67,53.12 96.88,52.91 97.29,52.91 97.5,52.7 97.5,52.27 97.29,52.06 96.88,52.06 96.67,51.84 96.67,51.42 96.88,51.2 97.29,51.2 97.5,50.99 97.5,50.56 97.29,50.35 96.88,50.35 96.67,50.14 96.67,49.71 96.88,49.49 97.29,49.49 97.5,49.28 97.5,48.85 97.29,48.64 96.88,48.64 96.67,48.43 96.67,48 96.88,47.79 97.29,47.79 97.5,47.57 97.5,47.15 97.29,46.93 96.88,46.93 96.67,46.72 96.67,46.29 96.88,46.08 97.29,46.08 97.5,45.87 97.5,44.79 97.06,44.35 97.06,39.04 v2(97.15,38.95)
  BOTTOM w0.076: UH1.AU2 101.16,74.11 101.16,73.39 100.63,72.87 100.63,70.82 99.64,69.82 98.96,69.82
  BOTTOM w0.185: v2(97.15,38.95) 97.75,38.95 98.65,39.86 JDIMM1.113 ; v2(99.55,67.05) 99.05,67.05 98.61,67.48 98.61,69.48 98.95,69.82 98.96,69.82
DDR_A_BS0: length 54.3
  IN4 w0.152: v2(107.09,73.45) 107.43,73.45 107.64,73.66 107.64,75.5 107.82,75.68 108.82,75.68 109,75.5 109,71.26 109.64,70.62 109.64,68.66 110.51,67.78 110.51,56.61 111.34,55.78 111.34,48.54 109.68,46.87 109.68,36.55 109.88,36.35 110.61,36.35 v2(110.8,36.55)
  BOTTOM w0.076: UH1.AH5 108.39,76.34 107.93,75.88 107.93,73.72 107.66,73.45 v2(107.09,73.45)
  BOTTOM w0.185: JDIMM1.150 109.9,36.38 110.08,36.55 v2(110.8,36.55)
DDR_A_BS1: length 52
  IN4 w0.152: v2(108.3,38.14) 108.3,39.25 108.67,39.62 108.67,47.27 109.55,48.14 109.55,48.81 109.72,48.99 110.2,48.99 110.38,49.17 110.38,49.52 110.2,49.7 109.72,49.7 109.55,49.88 109.55,50.23 109.72,50.41 110.2,50.41 110.38,50.59 110.38,50.94 110.2,51.12 109.72,51.12 109.55,51.3 109.55,51.66 109.72,51.83 110.2,51.83 110.38,52.01 110.38,52.37 110.2,52.54 109.72,52.54 109.55,52.72 109.55,53.08 109.72,53.26 110.2,53.26 110.38,53.43 110.38,53.79 110.2,53.97 109.72,53.97 109.55,54.14 109.55,54.5 109.72,54.68 110.2,54.68 110.38,54.86 110.38,55.38 109.55,56.21 109.55,67.38 108.67,68.26 108.67,68.72 108.33,69.06 107.87,69.06 107.68,69.25 107.68,69.59 107.88,69.79 108.42,69.79 108.62,69.99 108.62,70.25 108.32,70.55 108.01,70.55 107.84,70.73 107.84,71.42 108.04,71.62 108.04,71.97 107.81,72.2 v2(107.11,72.2)
  BOTTOM w0.076: v2(107.11,72.2) 107.27,72.2 108.43,73.35 UH1.AH1
  BOTTOM w0.185: JDIMM1.145 108.65,39.74 108.48,39.57 107.02,39.57 106.85,39.4 106.85,39.06 107.02,38.89 108.43,38.89 108.6,38.72 108.6,38.31 108.43,38.14 v2(108.3,38.14)
DDR_A_CAS#: length 53
  IN4 w0.152: v2(110.87,34.88) 110.12,34.88 109.94,34.7 109.94,33.62 110.27,33.29 112.02,33.29 112.15,33.42 112.15,34.84 111.29,35.7 111.29,44.96 111.47,45.14 111.76,45.14 111.93,45.32 111.93,45.67 111.76,45.85 111.47,45.85 111.29,46.03 111.29,46.43 112.79,47.94 112.79,56.38 111.99,57.17 111.99,68.35 111.09,69.26 111.09,69.55 v2(111.35,69.81)
  BOTTOM w0.076: UH1.AD1 111.68,70.14 v2(111.35,69.81)
  BOTTOM w0.185: JDIMM1.156 111.4,33.99 112.63,35.21 112.63,35.42 112.28,35.76 112.14,35.76 111.25,34.88 v2(110.87,34.88)
DDR_A_D0: length 58.4
  IN4 w0.094: v2(71.61,35.78) 70.79,36.6 70.79,37.51 70.11,38.18 70.11,60.71 76.3,66.9 76.3,72.77 79.75,76.22 82.74,76.22 83.08,75.87 v2(83.08,75.51)
  BOTTOM w0.076: UH1.BR6 88.15,77.03 87.2,77.03 87.03,77.2 86.33,77.2 85.68,76.56 85.68,76.16 85.66,76.14
  BOTTOM w0.114: v2(83.08,75.51) 85.03,75.51 85.66,76.14 ; v2(71.61,35.78) 72.4,34.99 JDIMM1.8
DDR_A_D1: length 58
  IN4 w0.094: v2(71.56,37.81) 71.56,37.84 70.77,38.62 70.77,60.43 76.96,66.62 76.96,72.5 79.49,75.02 79.76,75.02 79.89,74.89 79.89,74.71 80.01,74.59 80.4,74.59 80.52,74.71 80.52,74.93 80.65,75.05 81.03,75.05 81.16,74.93 81.16,74.71 81.28,74.59 81.75,74.59 82.08,74.26 82.99,74.26 83.14,74.41 83.14,74.77 82.92,75 82.28,75 v2(81.79,75.49)
  BOTTOM w0.076: UH1.BT6 87.54,77.37 86.26,77.37 85.51,76.61 85.51,76.46 85.42,76.38
  BOTTOM w0.114: v2(81.79,75.49) 82.29,75.99 85.03,75.99 85.42,76.38 ; v2(71.56,37.81) 71.99,38.24 71.99,39.31 72.15,39.48 JDIMM1.7
DDR_A_D2: length 59.4
  IN4 w0.094: v2(74.93,34.79) 74.1,34.79 73.84,35.05 73.84,35.34 73.73,35.46 72.98,35.46 72.86,35.58 72.86,35.95 72.98,36.08 73.73,36.08 73.86,36.22 73.86,40.77 73.72,40.91 73.47,40.91 73.35,41.03 73.35,41.38 73.47,41.5 73.72,41.5 73.84,41.61 73.84,41.96 73.72,42.08 73.47,42.08 73.35,42.2 73.35,42.55 73.47,42.66 73.72,42.66 73.84,42.78 73.84,43.13 73.72,43.25 73.47,43.25 73.35,43.37 73.35,43.72 73.47,43.83 73.72,43.83 73.84,43.95 73.84,44.3 73.72,44.42 73.47,44.42 73.35,44.53 73.35,44.88 73.47,45 73.72,45 73.84,45.12 73.84,45.47 73.72,45.59 73.47,45.59 73.35,45.7 73.35,46.05 73.47,46.17 73.72,46.17 73.84,46.29 73.84,57.22 73.99,57.37 74.18,57.37 74.3,57.5 74.3,57.78 74.18,57.9 73.97,57.9 73.84,58.04 73.84,58.39 78.03,62.59 78.03,63.75 79.06,64.78 v2(80.41,64.78)
  BOTTOM w0.076: 87,74.09 87.14,74.09 87.28,73.95 87.7,73.95 87.95,74.2 87.95,74.58 88.16,74.79 88.45,74.79 UH1.BP3
  BOTTOM w0.114: v2(80.41,64.78) 80.86,64.33 82.81,64.33 85.89,67.41 85.89,73.28 86.71,74.09 87,74.09 ; JDIMM1.20 75.4,34.32 74.94,34.79 v2(74.93,34.79)
DDR_A_D3: length 59.7
  IN4 w0.094: v2(74.95,38.77) 74.95,38.62 74.82,38.5 74.63,38.5 74.5,38.62 74.5,39.91 74.62,40.03 75.12,40.03 75.24,40.15 75.24,40.48 75.12,40.61 74.62,40.61 74.5,40.73 74.5,41.08 74.62,41.19 75.12,41.19 75.24,41.32 75.24,41.65 75.12,41.78 74.62,41.78 74.5,41.9 74.5,43.6 74.68,43.77 75.12,43.77 75.24,43.9 75.24,44.34 75.12,44.47 74.61,44.47 74.49,44.59 74.49,44.94 74.61,45.05 75.14,45.05 75.25,45.17 75.25,45.52 75.14,45.64 74.61,45.64 74.49,45.75 74.49,46.11 74.61,46.22 75.14,46.22 75.25,46.34 75.25,46.69 75.14,46.81 74.61,46.81 74.49,46.92 74.49,47.27 74.61,47.39 75.14,47.39 75.25,47.51 75.25,47.86 75.14,47.97 74.61,47.97 74.49,48.09 74.49,48.44 74.61,48.56 75.14,48.56 75.25,48.68 75.25,49.03 75.14,49.14 74.61,49.14 74.49,49.26 74.49,49.61 74.61,49.73 75.14,49.73 75.25,49.84 75.25,50.19 75.14,50.31 74.61,50.31 74.49,50.43 74.49,50.78 74.61,50.9 75.14,50.9 75.25,51.01 75.25,58.9 78.22,61.87 78.22,61.87 79.66,63.31 79.66,63.83 v2(79.57,63.92)
  BOTTOM w0.076: 87,73.77 87.13,73.77 87.14,73.78 87.46,73.78 87.85,73.39 88.31,73.39 88.52,73.61 88.52,73.88 88.61,73.98 88.61,74.68 88.81,74.88 89.35,74.88 UH1.BN3
  BOTTOM w0.114: v2(74.95,38.77) 75.65,39.48 JDIMM1.21 ; v2(79.57,63.92) 82.97,63.92 86.21,67.17 86.21,73.11 86.88,73.77 87,73.77
DDR_A_D4: length 58.9
  IN4 w0.094: v2(71.59,36.44) 71.12,36.91 71.12,37.74 70.44,38.41 70.44,60.57 76.63,66.76 76.63,72.63 79.47,75.47 v2(80.59,75.47)
  BOTTOM w0.076: UH1.BN5 89.42,76.95 89.01,77.36 88.24,77.36 87.96,77.64 87.43,77.64 87.38,77.59 86.22,77.59 85.19,76.56
  BOTTOM w0.114: 85.19,76.56 84.97,76.34 81.46,76.34 v2(80.59,75.47) ; JDIMM1.4 71.4,34.11 70.98,34.54 70.98,35.83 v2(71.59,36.44)
DDR_A_D5: length 58
  IN4 w0.094: v2(71.54,39.11) 71.1,39.54 71.1,60.3 77.29,66.49 77.29,72.36 79.13,74.2 81.54,74.2 81.84,73.9 83.62,73.9 83.75,74.03 83.75,76.34 83.88,76.47 84.26,76.47 84.38,76.34 84.38,74.31 84.51,74.19 84.99,74.19 85.11,74.31 85.11,76.17 85.24,76.3 v2(86.06,76.3)
  BOTTOM w0.076: v2(86.06,76.3) 86.06,76.7 86.4,77.04 86.94,77.04 87.11,76.86 87.86,76.86 88.09,76.63 88.53,76.63 88.92,77.02 UH1.BP6
  BOTTOM w0.114: JDIMM1.3 71.15,40.07 71.05,39.97 71.05,39.59 v2(71.54,39.11)
DDR_A_D6: length 59.7
  IN4 w0.094: v2(74.94,36.31) 74.74,36.11 74.41,36.11 74.17,36.34 74.17,51.11 74.29,51.23 74.79,51.23 74.91,51.34 74.91,51.69 74.79,51.81 74.29,51.81 74.17,51.93 74.17,52.28 74.29,52.39 74.79,52.39 74.91,52.51 74.91,52.86 74.79,52.98 74.29,52.98 74.17,53.09 74.17,53.45 74.29,53.56 74.79,53.56 74.91,53.68 74.91,54.03 74.79,54.15 74.29,54.15 74.17,54.26 74.17,54.61 74.29,54.73 74.79,54.73 74.91,54.85 74.91,55.2 74.79,55.31 74.29,55.31 74.17,55.43 74.17,55.78 74.29,55.9 74.79,55.9 74.91,56.02 74.91,56.37 74.79,56.48 74.29,56.48 74.17,56.6 74.17,56.95 74.29,57.07 74.79,57.07 74.93,57.21 74.93,57.59 74.57,57.96 74.57,58.31 74.93,58.67 74.93,59.04 78.74,62.84 v2(78.74,63.04)
  BOTTOM w0.076: 87,73.43 87.4,73.43 87.66,73.17 88.83,73.17 89.23,73.57 89.23,74.26 UH1.BP2
  BOTTOM w0.114: v2(78.74,63.04) 82.82,63.04 86.53,66.75 86.53,72.98 86.98,73.43 87,73.43 ; v2(74.94,36.31) 74.94,36.21 74.4,35.68 JDIMM1.16
DDR_A_D7: length 59.4
  IN4 w0.094: v2(72.83,37.1) 73.03,36.9 73.28,36.9 73.57,37.19 73.57,39.87 73.03,40.4 73.03,46.5 73.52,46.98 73.52,49.68 73.4,49.8 73.15,49.8 73.03,49.91 73.03,50.26 73.15,50.38 73.4,50.38 73.52,50.5 73.52,50.85 73.4,50.96 73.15,50.96 73.03,51.08 73.03,51.43 73.15,51.55 73.4,51.55 73.52,51.67 73.52,52.02 73.4,52.13 73.15,52.13 73.03,52.25 73.03,52.6 73.15,52.72 73.4,52.72 73.52,52.83 73.52,53.18 73.4,53.3 73.15,53.3 73.03,53.42 73.03,53.77 73.15,53.89 73.4,53.89 73.52,54 73.52,54.35 73.4,54.47 73.15,54.47 73.03,54.59 73.03,54.94 73.15,55.05 73.4,55.05 73.52,55.17 73.52,55.52 73.4,55.64 73.15,55.64 73.03,55.76 73.03,56.32 73.15,56.43 73.27,56.43 73.5,56.66 73.5,57.25 73.38,57.37 73.2,57.37 73.08,57.49 73.08,57.84 73.2,57.95 73.4,57.95 73.52,58.07 73.52,58.53 77.71,62.72 77.71,63.88 79.06,65.23 79.46,65.23 79.61,65.38 79.61,65.73 79.74,65.85 80.15,65.85 80.27,65.73 80.27,65.43 80.48,65.23 v2(80.85,65.23)
  BOTTOM w0.076: UH1.BR3 88.13,75.12 87.7,74.69 87,74.69
  BOTTOM w0.114: v2(80.85,65.23) 81.32,64.76 82.59,64.76 85.56,67.74 85.56,73.48 86.78,74.69 87,74.69 ; JDIMM1.17 74.65,40.1 74.43,39.88 74.43,37.75 73.78,37.1 v2(72.83,37.1)
DDR_A_D8: length 54
  IN4 w0.094: v2(92,76.01) 91.58,76.44 88.27,76.44 83.38,71.54 83.38,66 80.39,63.01 80.39,63.01 78.52,61.14 78.52,61.14 75.98,58.6 75.98,39.84 75.67,39.54 75.67,37.46 v2(76.11,37.02)
  BOTTOM w0.076: UH1.BK5 v2(92,76.01)
  BOTTOM w0.114: JDIMM1.28 77.4,35.73 v2(76.11,37.02)
DDR_A_D9: length 53.7
  IN4 w0.094: v2(76.11,38.22) 76.39,38.22 76.58,38.4 76.58,50.04 77.38,50.84 77.38,51.22 77.28,51.31 76.84,51.31 76.72,51.44 76.72,51.66 76.84,51.78 77.28,51.78 77.38,51.88 77.38,52.16 77.28,52.25 76.72,52.25 76.59,52.38 76.59,52.6 76.72,52.72 77.28,52.72 77.38,52.82 77.38,53.11 77.28,53.2 76.79,53.2 76.67,53.33 76.67,53.55 76.79,53.67 77.28,53.67 77.38,53.77 77.38,54.05 77.28,54.14 77.05,54.14 76.92,54.27 76.92,54.49 77.05,54.61 77.28,54.61 77.38,54.71 77.38,59.11 84.04,65.77 84.04,71.31 84.09,71.37 84.09,71.38 86.43,73.72 86.48,73.72 86.52,73.75 88.28,73.75 89.43,74.91 90.78,74.91 v2(91.23,75.36)
  BOTTOM w0.076: v2(91.23,75.36) 90.91,75.69 UH1.BL4
  BOTTOM w0.114: JDIMM1.29 77.65,39.48 76.39,38.22 v2(76.11,38.22)
DDR_A_D10: length 53.9
  IN4 w0.094: v2(90.07,74.14) 89.6,74.14 88.36,72.9 88.23,72.9 87.54,72.2 87.54,70.45 86.34,69.25 86.34,64.84 81.26,59.76 81.26,53.27 81.14,53.15 79.9,53.15 79.78,53.04 79.78,52.69 79.9,52.57 81.14,52.57 81.26,52.45 81.26,52.1 81.14,51.99 79.9,51.99 79.78,51.87 79.78,51.52 79.9,51.4 81.14,51.4 81.26,51.28 81.26,50.93 81.14,50.82 79.9,50.82 79.78,50.7 79.78,50.35 79.9,50.23 81.14,50.23 81.26,50.12 81.26,49.54 80.9,49.18 80.48,49.18 79.78,48.48 79.78,41.99 79.11,41.32 79.11,38.63 78.92,38.44 v2(78.56,38.44)
  BOTTOM w0.076: v2(90.07,74.14) 90.31,74.38 UH1.BL2
  BOTTOM w0.114: JDIMM1.41 80.65,39.92 79.18,38.45 78.56,38.45 v2(78.56,38.44)
DDR_A_D11: length 53.7
  IN4 w0.094: v2(81.47,34.1) 81.12,34.45 80.29,34.45 79.89,34.84 79.89,41.16 81,42.27 81,42.4 80.53,42.86 80.53,43 80.73,43.2 80.86,43.2 81.33,42.73 81.46,42.73 81.9,43.17 81.9,43.98 81.81,44.08 81.23,44.08 81.14,44.17 81.14,44.45 81.23,44.55 81.81,44.55 81.9,44.64 81.9,55.65 81.99,55.74 82.56,55.74 82.69,55.87 82.69,56.08 82.56,56.21 81.99,56.21 81.9,56.3 81.9,56.59 81.99,56.68 82.53,56.68 82.66,56.81 82.66,57.02 82.53,57.15 81.99,57.15 81.9,57.24 81.9,57.52 81.99,57.62 82.51,57.62 82.64,57.75 82.64,57.96 82.51,58.09 81.99,58.09 81.9,58.18 81.9,59.56 86.94,64.59 86.94,68.88 88.46,70.4 88.46,72.27 89.54,73.35 90.02,73.35 v2(90.02,73.35)
  BOTTOM w0.076: UH1.BM1 90.02,73.36 v2(90.02,73.35)
  BOTTOM w0.114: JDIMM1.42 80.9,33.77 81.24,34.1 v2(81.47,34.1)
DDR_A_D12: length 53.7
  IN4 w0.094: v2(76.09,35.72) 76.09,35.37 76.31,35.14 76.67,35.14 76.87,35.35 76.87,48.56 76.97,48.66 77.12,48.66 77.25,48.79 77.25,49.12 77.12,49.25 76.97,49.25 76.87,49.35 76.87,49.77 77.7,50.6 77.7,58.96 84.39,65.65 84.39,71.25 86.55,73.42 88.41,73.42 89.57,74.58 91.22,74.58 v2(92,75.36)
  BOTTOM w0.076: UH1.BK4 v2(92,75.36)
  BOTTOM w0.114: v2(76.09,35.72) 76.4,35.41 JDIMM1.24
DDR_A_D13: length 53.6
  IN4 w0.094: v2(76.1,39.39) 76.28,39.57 76.28,54.99 76.37,55.08 76.99,55.08 77.08,55.18 77.08,55.46 76.99,55.55 76.37,55.55 76.28,55.65 76.28,55.93 76.37,56.02 76.99,56.02 77.08,56.12 77.08,56.4 76.99,56.49 76.37,56.49 76.28,56.59 76.28,56.87 76.37,56.96 76.69,56.96 76.82,57.09 76.82,57.31 76.69,57.43 76.42,57.43 76.28,57.58 76.28,58.48 78.64,60.84 78.64,60.84 80.69,62.89 80.69,62.89 83.71,65.91 83.71,71.4 83.79,71.49 83.79,71.5 86.31,74.01 86.31,74.01 86.43,74.13 86.7,74.13 86.82,74.26 86.82,74.5 86.95,74.62 87.33,74.62 87.46,74.5 87.46,74.22 87.59,74.09 88.15,74.09 88.41,74.35 88.41,74.5 87.73,75.19 87.73,75.37 88,75.63 88.18,75.63 88.86,74.95 89.01,74.95 89.38,75.32 90.58,75.32 91.23,75.97 v2(91.23,76.01)
  BOTTOM w0.076: v2(91.23,76.01) 90.91,76.34 UH1.BL5
  BOTTOM w0.114: JDIMM1.25 76.65,39.62 76.42,39.39 v2(76.1,39.39)
DDR_A_D14: length 54.4
  IN4 w0.094: v2(87.99,71.24) 87.99,70.45 86.64,69.09 86.64,64.72 81.58,59.66 81.58,47.99 81.46,47.87 80.22,47.87 80.1,47.76 80.1,47.4 80.22,47.29 81.46,47.29 81.58,47.17 81.58,46.82 81.46,46.7 80.22,46.7 80.1,46.59 80.1,46.24 80.22,46.12 81.46,46.12 81.58,46 81.58,45.49 81.19,45.1 81.02,45.1 80.68,45.44 80.52,45.44 80.27,45.2 80.27,45.03 80.61,44.69 80.61,44.52 80.1,44.01 80.1,41.85 79.54,41.29 79.54,38.12 78.57,37.15 v2(78.54,37.15)
  BOTTOM w0.076: UH1.BK1 91.17,73.34 90.47,72.64 89.38,72.64 89,72.25
  BOTTOM w0.114: JDIMM1.38 79.9,33.96 80.15,34.2 80.15,36 78.99,37.15 v2(78.54,37.15) ; 89,72.25 v2(87.99,71.24)
DDR_A_D15: length 54.4
  IN4 w0.094: v2(87.04,70.53) 86.53,70.53 86.04,70.05 86.04,64.96 80.63,59.55 80.63,58.95 80.22,58.54 79.62,58.54 79.46,58.38 79.46,57.8 79.58,57.68 80.74,57.68 80.86,57.56 80.86,57.21 80.74,57.1 79.58,57.1 79.46,56.98 79.46,56.63 79.58,56.51 80.74,56.51 80.86,56.39 80.86,56.04 80.74,55.93 79.58,55.93 79.46,55.81 79.46,55.46 79.58,55.34 80.74,55.34 80.86,55.23 80.86,54.88 80.74,54.76 79.58,54.76 79.46,54.64 79.46,54.29 79.58,54.17 80.74,54.17 80.86,54.06 80.86,53.71 80.74,53.59 79.58,53.59 79.46,53.47 79.46,42.23 79.18,41.95 78.8,41.95 78.67,41.82 78.67,39.78 v2(78.63,39.74)
  BOTTOM w0.076: 89.71,72.25 89.89,72.44 90.93,72.44 91.61,73.12 UH1.BK2
  BOTTOM w0.114: JDIMM1.37 79.65,40.07 79.15,39.56 78.8,39.56 v2(78.63,39.74) ; v2(87.04,70.53) 87.99,70.53 89.71,72.25
DDR_A_D16: length 51.2
  IN4 w0.094: v2(81.51,36.68) 81.04,37.16 81.04,40.77 83,42.73 83,54.55 83.75,55.31 83.75,59.96 88.12,64.32 88.12,68.47 89.57,69.92 89.57,71.54 v2(90.1,72.06)
  BOTTOM w0.076: UH1.BG5 93.62,76.05 93.62,75.57 93.42,75.37 93.26,75.37 93.03,75.14 93.03,74.26 92.82,74.05 92.82,72.73 92.15,72.06 91,72.06
  BOTTOM w0.114: 91,72.06 v2(90.1,72.06) ; JDIMM1.50 82.9,35.64 81.86,36.68 v2(81.51,36.68)
DDR_A_D17: length 50.9
  IN4 w0.094: v2(81.51,38.51) 81.51,38.56 81.92,38.98 81.92,40.75 84.45,43.27 84.45,43.38 84.36,43.48 83.71,43.48 83.61,43.57 83.61,43.85 83.71,43.95 84.36,43.95 84.45,44.04 84.45,44.32 84.36,44.42 83.71,44.42 83.61,44.51 83.61,44.79 83.71,44.89 84.36,44.89 84.45,44.98 84.45,45.26 84.36,45.36 83.71,45.36 83.61,45.45 83.61,45.73 83.71,45.83 84.36,45.83 84.45,45.92 84.45,46.2 84.36,46.3 83.75,46.3 83.63,46.43 83.63,46.64 83.75,46.77 84.36,46.77 84.45,46.86 84.45,47.13 84.32,47.25 83.75,47.25 83.63,47.38 83.63,47.6 83.75,47.72 84.34,47.72 84.46,47.85 84.46,48.07 84.34,48.19 84.21,48.19 84.08,48.32 84.08,48.54 84.21,48.66 84.32,48.66 84.45,48.79 84.45,59.82 88.76,64.12 88.76,67.81 v2(89.5,68.56)
  BOTTOM w0.076: 92.42,70.98 92.7,71.27 92.7,71.8 93.34,72.44 UH1.BG1
  BOTTOM w0.114: v2(81.51,38.51) 82.65,39.66 JDIMM1.49 ; v2(89.5,68.56) 91.16,70.22 91.65,70.22 92.42,70.98
DDR_A_D18: length 50.3
  IN4 w0.094: v2(84.76,36.41) 86.05,37.71 86.05,40.41 86.73,41.09 86.73,50.46 87.82,51.55 87.82,54.43 87.72,54.53 86.84,54.53 86.75,54.62 86.75,54.9 86.84,55 87.72,55 87.82,55.09 87.82,55.37 87.72,55.47 86.84,55.47 86.75,55.56 86.75,55.84 86.84,55.94 86.98,55.94 87.11,56.07 87.11,56.28 86.98,56.41 86.84,56.41 86.75,56.5 86.75,58.93 91.55,63.73 91.55,70.61 93.14,72.2 93.14,72.73 v2(94.47,74.06)
  BOTTOM w0.089: UH1.BF2 v2(94.47,74.06)
  BOTTOM w0.114: v2(84.76,36.41) 85.15,36.41 85.92,35.65 85.92,33.84 85.9,33.83 JDIMM1.62
DDR_A_D19: length 50.2
  IN4 w0.094: v2(84.76,37.68) 84.39,37.68 84.26,37.81 84.26,39.74 86.13,41.61 86.13,59.15 90.89,63.91 90.89,67.96 90.77,68.08 90.22,68.08 90.1,68.2 90.1,68.55 90.22,68.66 90.77,68.66 90.89,68.78 90.89,69.13 90.77,69.25 90.22,69.25 90.1,69.36 90.1,69.56 90.37,69.83 90.77,69.83 90.89,69.95 90.89,70.79 92.54,72.45 92.54,73.07 93.25,73.78 93.25,74.79 v2(94.47,76.01)
  BOTTOM w0.089: UH1.BF5 v2(94.47,76.01)
  BOTTOM w0.114: JDIMM1.63 86.15,39.92 86.16,39.91 86.16,38.66 86.15,38.65 86.15,38.51 85.33,37.68 v2(84.76,37.68)
DDR_A_D20: length 50.4
  IN4 w0.094: v2(81.49,35.4) 80.99,35.4 80.68,35.71 80.68,40.86 82.68,42.86 82.68,54.77 83.42,55.51 83.42,60.05 87.8,64.43 87.8,68.6 89.24,70.05 89.24,71.8 90.06,72.62 v2(92.14,72.62)
  BOTTOM w0.076: v2(92.14,72.62) 92.62,73.1 92.62,74.08 92.81,74.27 92.81,75.23 93.27,75.69 UH1.BG4
  BOTTOM w0.114: v2(81.49,35.4) 82.06,34.84 82.06,34.67 82.17,34.55 82.17,33.84 81.9,33.58 JDIMM1.46
DDR_A_D21: length 50.5
  IN4 w0.094: v2(81.5,39.72) 81.5,40.78 83.32,42.59 83.32,47.96 83.41,48.05 83.63,48.05 83.75,48.18 83.75,48.39 83.63,48.52 83.41,48.52 83.32,48.61 83.32,48.9 83.41,48.99 84.01,48.99 84.13,49.12 84.13,49.33 84.01,49.46 83.41,49.46 83.32,49.55 83.32,49.84 83.41,49.93 84.01,49.93 84.13,50.06 84.13,50.27 84.01,50.4 83.41,50.4 83.32,50.49 83.32,50.78 83.41,50.87 83.98,50.87 84.11,51 84.11,51.21 83.98,51.34 83.41,51.34 83.32,51.43 83.32,51.72 83.41,51.81 84.01,51.81 84.13,51.94 84.13,52.15 84.01,52.28 83.41,52.28 83.32,52.37 83.32,52.66 83.41,52.75 83.98,52.75 84.11,52.88 84.11,53.09 83.98,53.22 83.41,53.22 83.32,53.31 83.32,53.6 83.41,53.69 84.01,53.69 84.11,53.79 84.11,54.05 83.98,54.18 83.53,54.18 83.4,54.31 83.4,54.52 83.53,54.65 83.98,54.65 84.11,54.78 84.11,59.9 88.44,64.22 88.44,68.35 89.9,69.82 89.9,70.64 v2(90.1,70.83)
  BOTTOM w0.076: UH1.BG2 93.34,74.17 93.05,73.88 93.05,72.54 91.79,71.28
  BOTTOM w0.114: v2(90.1,70.83) 91.34,70.83 91.79,71.28 ; JDIMM1.45 81.65,39.87 v2(81.5,39.72)
DDR_A_D22: length 50.3
  IN4 w0.094: v2(94.47,73.41) 93.43,72.38 93.43,72.08 91.85,70.49 91.85,63.61 88.12,59.88 88.12,58.2 88.03,58.1 87.56,58.1 87.44,57.98 87.44,57.76 87.56,57.63 88.03,57.63 88.12,57.54 88.12,57.26 88.03,57.16 87.3,57.16 87.21,57.07 87.21,56.79 87.3,56.69 88.03,56.69 88.12,56.6 88.12,51.32 87.06,50.26 87.06,40.83 86.42,40.2 86.42,36.21 85.35,35.14 v2(84.76,35.14)
  BOTTOM w0.089: UH1.BF1 v2(94.47,73.41)
  BOTTOM w0.114: v2(84.76,35.14) 85.1,35.49 85.25,35.49 85.46,35.28 85.46,35.01 85.18,34.73 85.18,34.53 85.28,34.43 85.5,34.43 85.6,34.33 85.6,33.97 85.5,33.87 85.01,33.87 84.9,33.77 JDIMM1.58
DDR_A_D23: length 50.3
  IN4 w0.094: v2(84.76,38.95) 85.38,39.58 85.38,40.41 86.43,41.46 86.43,51.64 86.52,51.74 87.39,51.74 87.49,51.83 87.49,52.11 87.39,52.21 86.52,52.21 86.43,52.3 86.43,52.58 86.52,52.68 87.39,52.68 87.49,52.77 87.49,53.05 87.39,53.15 86.52,53.15 86.43,53.24 86.43,53.52 86.52,53.62 87.08,53.62 87.21,53.74 87.21,53.96 87.08,54.09 86.52,54.09 86.43,54.18 86.43,59.03 91.22,63.82 91.22,70.7 92.84,72.32 92.84,72.9 93.58,73.64 93.58,74.47 v2(94.47,75.36)
  BOTTOM w0.076: UH1.BF4 94.31,75.69 94.47,75.52 v2(94.47,75.36)
  BOTTOM w0.114: JDIMM1.59 85.15,40.04 85.31,39.89 85.74,39.89 85.85,39.77 85.85,38.79 85.61,38.55 85.21,38.55 85.1,38.65 85.1,38.88 85.03,38.95 v2(84.76,38.95)
DDR_A_D24: length 49.2
  IN4 w0.094: v2(94.5,70.35) 93.98,70.35 93.21,69.59 93.21,62.72 89.52,59.02 89.52,46.29 88.45,45.23 88.45,39.77 88.83,39.39 88.83,39.11 88.95,38.99 89.26,38.99 89.38,38.87 89.38,38.52 89.26,38.41 88.95,38.41 88.83,38.29 88.83,35.7 89.68,34.85 89.68,34.52 89.46,34.29 89.16,34.29 v2(88.28,35.18)
  BOTTOM w0.076: 94.96,70.98 94.96,71.69 95.29,72.02 95.29,72.64 95.57,72.93 95.57,73.87 95.85,74.15 UH1.BD2
  BOTTOM w0.114: v2(88.28,35.18) 87.77,34.66 87.77,33.77 87.9,33.63 JDIMM1.70 ; v2(94.5,70.35) 94.63,70.35 94.96,70.68 94.96,70.98
DDR_A_D25: length 49.2
  IN4 w0.094: v2(90.51,39.11) 89.67,39.11 88.78,39.99 88.78,40.48 88.9,40.59 89.58,40.59 89.7,40.71 89.7,41.06 89.58,41.18 88.9,41.18 88.78,41.3 88.78,41.65 88.9,41.76 89.58,41.76 89.7,41.88 89.7,42.23 89.58,42.35 88.9,42.35 88.78,42.46 88.78,42.81 88.9,42.93 89.58,42.93 89.7,43.05 89.7,43.4 89.58,43.52 88.9,43.52 88.78,43.63 88.78,43.98 88.9,44.1 89.58,44.1 89.7,44.22 89.7,44.57 89.58,44.68 88.9,44.68 88.78,44.8 88.78,45.11 89.81,46.14 89.81,58.9 93.51,62.6 93.51,69.34 93.93,69.75 v2(94.47,69.75)
  BOTTOM w0.076: 95.39,70.98 95.39,71.84 95.46,71.91 95.46,72.58 95.85,72.97 UH1.BD1
  BOTTOM w0.114: v2(94.47,69.75) 94.72,69.75 95.39,70.42 95.39,70.98 ; JDIMM1.71 88.15,39.99 89.03,39.11 v2(90.51,39.11)
DDR_A_D26: length 49.3
  IN4 w0.094: v2(91.79,35.8) 92.73,35.8 92.96,36.04 92.96,43.73 92.79,43.91 92.79,58.62 95.83,61.67 95.83,68.15 v2(96.27,68.59)
  BOTTOM w0.076: 97.65,72.63 97.65,72.81 97.03,73.43 97.03,74.24 96.94,74.34 96.94,75.09 96.59,75.44 UH1.BC4
  BOTTOM w0.114: JDIMM1.83 91.15,39.61 92.27,38.5 92.27,36.28 v2(91.79,35.8) ; 97.65,72.63 97.65,70.49 97.22,70.06 97.22,69.48 96.32,68.59 v2(96.27,68.59)
DDR_A_D27: length 49.5
  IN4 w0.094: v2(91.82,34.39) 93.12,34.39 93.25,34.52 93.25,34.77 93.1,34.92 92.37,34.92 92.24,35.05 92.24,35.3 92.37,35.43 93.1,35.43 93.29,35.62 93.29,43.87 93.12,44.05 93.12,58.5 96.17,61.56 96.17,67.26 v2(96.27,67.36)
  BOTTOM w0.076: 98,72.63 98,72.79 97.2,73.59 97.2,74.33 97.19,74.34 97.19,75.08 96.88,75.39 96.88,76.05 UH1.BC5
  BOTTOM w0.114: JDIMM1.84 91.4,33.98 v2(91.82,34.39) ; 98,72.63 98,70.32 97.57,69.89 97.57,68.66 v2(96.27,67.36)
DDR_A_D28: length 49.3
  IN4 w0.094: v2(88.24,36.79) 87.73,36.29 87.46,36.29 87.27,36.48 87.27,39.72 87.81,40.26 87.81,49.8 88.88,50.86 88.88,59.39 92.58,63.09 92.58,70.1 92.62,70.14 92.62,70.16 94.07,71.61 94.07,71.72 94.49,72.14 v2(94.49,72.15)
  BOTTOM w0.076: UH1.BD5 95.34,75.82 95.34,74.29 95.24,74.2 95.24,73.15 94.91,72.82 94.91,72.53 94.54,72.15 v2(94.49,72.15)
  BOTTOM w0.114: v2(88.24,36.79) 86.9,35.46 JDIMM1.66
DDR_A_D29: length 48.7
  IN4 w0.094: v2(94.47,71.55) 94.43,71.55 92.92,70.04 92.92,62.98 89.2,59.26 89.2,50.72 88.13,49.66 88.13,49.5 88.25,49.38 89,49.38 89.11,49.26 89.11,48.91 89,48.79 88.25,48.79 88.13,48.68 88.13,48.33 88.25,48.21 89,48.21 89.11,48.09 89.11,47.74 89,47.63 88.25,47.63 88.13,47.51 88.13,47.16 88.25,47.04 89,47.04 89.11,46.92 89.11,46.57 89,46.46 88.25,46.46 88.13,46.34 88.13,40.08 87.59,39.54 87.59,39.23 v2(88.2,38.62)
  BOTTOM w0.076: UH1.BD4 95.56,75.39 95.56,74.19 95.41,74.04 95.41,73.03 95.12,72.74 95.12,72.18 94.49,71.55 v2(94.47,71.55)
  BOTTOM w0.114: v2(88.2,38.62) 88.04,38.62 87.15,39.5 JDIMM1.67
DDR_A_D30: length 49.1
  IN4 w0.094: v2(91.79,37.74) 92.26,38.21 92.26,40.79 92.14,40.91 91.69,40.91 91.58,41.02 91.58,41.37 91.69,41.49 92.14,41.49 92.26,41.61 92.26,41.96 92.14,42.07 91.69,42.07 91.58,42.19 91.58,42.54 91.69,42.66 92.14,42.66 92.26,42.78 92.26,43.49 91.57,44.18 91.57,50.73 91.68,50.85 92.02,50.85 92.14,50.97 92.14,51.32 92.02,51.43 91.68,51.43 91.57,51.55 91.57,51.9 91.68,52.02 92.02,52.02 92.14,52.14 92.14,52.49 92.02,52.6 91.68,52.6 91.57,52.72 91.57,53.07 91.68,53.19 92.02,53.19 92.14,53.3 92.14,53.65 92.02,53.77 91.68,53.77 91.57,53.89 91.57,54.24 91.68,54.36 92.02,54.36 92.14,54.47 92.14,54.82 92.02,54.94 91.68,54.94 91.57,55.06 91.57,55.41 91.68,55.52 92.02,55.52 92.14,55.64 92.14,55.99 92.02,56.11 91.68,56.11 91.57,56.22 91.57,58.31 95.17,61.91 95.17,68.6 95.8,69.23 95.8,69.98 v2(96.31,70.49)
  BOTTOM w0.076: UH1.BC1 96.59,73.08 96.78,72.89 96.78,72.63
  BOTTOM w0.114: v2(91.79,37.74) 91.32,38.21 91.32,38.91 90.15,40.07 JDIMM1.79 ; v2(96.31,70.49) 96.78,70.96 96.78,72.63
