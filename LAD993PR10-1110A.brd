# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
EDP_TXN2_C: length 1.7
  BOTTOM w0.114: RV543.1 55.24,40.78 55.07,40.61 54.78,40.61 54.63,40.46 54.15,40.46 CV588.2
EDP_TXN2_R: length 7.8
  BOTTOM w0.114: JEDP1.35 61.97,41.01 61.82,40.86 61.53,40.86 60.8,41.59 57.58,41.59 v1(57.27,41.28) 57.1,41.11 57.1,40.61 56.97,40.48 56.72,40.48 56.6,40.61 56.32,40.61 56.16,40.78 RV543.2
EDP_TXN3: length 134.8
  IN4 w0.094: v2(127.9,93.41) 127.9,93.43 128.08,93.61 128.77,93.61 129.25,94.09 129.25,94.24 129.25,94.24 129.25,95.15 129.25,95.15 129.25,95.3 127.33,97.23 127.17,97.23 127.17,97.23 125.97,97.23 124.9,98.3 124.9,102.03 121.33,105.61 107.01,105.61 106.1,104.7 105.57,104.7 87.54,104.7 81.82,98.97 81.82,93.05 81.32,92.56 80.07,92.56 78.77,91.25 78.77,88.03 74.12,83.38 74.12,82.29 73.62,81.79 72.42,81.79 68.76,78.12 68.76,75.63 66.38,73.25 64.58,73.25 62.23,70.91 62.23,69.05 61.11,67.94 61.11,53.81 60.2,52.9 60.2,48.3 54.27,42.37 51.77,42.37 v2(51.6,42.55)
  BOTTOM w0.102: v2(127.9,93.41) 127.8,93.41 127.56,93.65 UH1.B28
  BOTTOM w0.114: CV590.1 52.55,42.37 51.78,42.37 v2(51.6,42.55)
EDP_TXN3_C: length 1.7
  BOTTOM w0.114: RV546.1 55.24,42.68 55.07,42.52 54.8,42.52 54.66,42.37 54.15,42.37 CV590.2
EDP_TXN3_R: length 7
  BOTTOM w0.114: RV546.2 56.16,42.68 56.32,42.52 56.6,42.52 56.74,42.37 56.89,42.37 57.24,42.71 58.29,42.71 58.64,42.37 61.83,42.37 61.98,42.51 JEDP1.38
EDP_TXP0: length 132.8
  IN4 w0.094: v2(51.6,36.34) 51.38,36.56 51.21,36.56 50.92,36.85 50.92,37.49 51.27,37.84 52.57,37.84 63,48.28 63,67.33 64.02,68.34 64.02,69.74 65.08,70.81 66.71,70.81 70.98,75.07 70.98,77.13 72.68,78.83 75.22,78.83 77.78,81.4 77.78,83.12 85.18,90.52 85.18,99.46 88.47,102.75 119.09,102.75 120.66,101.18 120.66,95.19 121.02,94.83 121.55,94.83 122.29,95.57 124.28,95.57 124.9,94.95 124.9,94.81 125.11,94.59 125.54,94.59 125.94,94.19 v2(125.95,94.19)
  BOTTOM w0.076: UH1.D29 126.26,94.58 125.95,94.27 v2(125.95,94.19)
  BOTTOM w0.114: CV580.1 52.6,36.65 51.9,36.65 v2(51.6,36.34)
EDP_TXP0_C: length 1.7
  BOTTOM w0.114: RV540.1 55.24,36.39 55.07,36.55 54.81,36.55 54.68,36.68 54.13,36.68 CV580.2
EDP_TXP0_R: length 7.2
  BOTTOM w0.114: RV540.2 56.16,36.39 56.32,36.55 56.83,36.55 56.98,36.7 60.06,36.7 61.02,37.66 61.83,37.66 61.98,37.51 JEDP1.28
EDP_TXP1: length 130.5
  IN4 w0.094: v2(125.35,93.41) 125.35,93.4 125.71,93.77 126.11,93.77 126.34,94 126.34,94.34 126.01,94.68 126.01,95.04 123.27,97.78 123.27,99.35 122.63,99.99 122.63,101.92 121.34,103.21 88.28,103.21 84.35,99.28 84.35,90.31 76.98,82.95 76.98,81.65 74.74,79.41 72.56,79.41 70.4,77.26 70.4,75.17 66.56,71.33 64.7,71.33 63.59,70.21 63.59,69.13 63.59,68.49 62.48,67.39 62.48,48.51 52.45,38.47 51.78,38.47 51.73,38.43 51.72,38.43 v2(51.6,38.3)
  BOTTOM w0.076: v2(125.35,93.41) 125.35,93.41 UH1.F28
  BOTTOM w0.114: v2(51.6,38.3) 51.8,38.5 52.53,38.5 CV585.1
EDP_TXP1_C: length 1.7
  BOTTOM w0.114: RV542.1 55.24,38.16 55.07,38.33 54.81,38.33 54.68,38.46 54.13,38.46 CV585.2
EDP_TXP1_R: length 8
  BOTTOM w0.114: RV542.2 56.16,38.16 56.32,38.33 56.59,38.33 56.72,38.46 56.96,38.46 57.16,38.25 57.16,38.05 57.71,37.51 59.7,37.51 61.35,39.16 61.83,39.16 61.97,39.01 JEDP1.31
EDP_TXP2: length 130.5
  IN4 w0.094: v2(127.9,94.17) 127.9,94.32 127.67,94.55 127.49,94.55 127.26,94.78 127.26,95.59 126.89,95.95 126.06,95.95 125.58,96.43 125.44,96.58 125.44,96.58 125.38,96.63 123.99,98.02 123.99,101.58 121.75,103.82 87.95,103.82 83,98.87 83,93 81.25,91.25 81.25,88.48 78.22,85.45 77.43,85.45 75.3,83.33 75.3,82.21 74,80.91 72.83,80.91 69.53,77.6 69.53,75.31 66.7,72.48 64.98,72.48 63,70.5 63,68.97 63,68.73 61.88,67.62 61.88,48.81 53.33,40.26 51.76,40.26 v2(51.6,40.1)
  BOTTOM w0.076: UH1.A29 128.21,94.51 127.9,94.2 v2(127.9,94.17)
  BOTTOM w0.114: CV587.1 52.55,40.25 51.75,40.25 v2(51.6,40.1)
EDP_TXP2_C: length 1.7
  BOTTOM w0.114: CV587.2 54.13,40.24 54.68,40.24 54.81,40.11 55.07,40.11 55.24,39.94 RV544.1
EDP_TXP2_R: length 7.8
  BOTTOM w0.114: RV544.2 56.16,39.94 56.32,40.11 56.59,40.11 56.74,40.26 57.07,40.26 57.32,40.51 57.32,40.99 57.63,41.3 57.63,41.32 57.68,41.37 60.71,41.37 61.44,40.64 61.85,40.64 61.98,40.51 JEDP1.34
EDP_TXP3: length 134.9
  IN4 w0.094: v2(127.26,93.41) 127.64,93.79 128.7,93.79 129.07,94.16 129.07,95.23 127.25,97.04 125.89,97.04 124.72,98.22 124.72,101.95 121.25,105.42 107.09,105.42 106.18,104.51 105.65,104.51 105.64,104.51 105.01,104.51 105.01,104.51 87.61,104.51 82,98.9 82,92.97 81.4,92.37 80.15,92.37 78.95,91.18 78.95,87.95 74.3,83.3 74.3,82.21 73.7,81.6 72.5,81.6 68.95,78.04 68.95,75.56 66.46,73.07 64.65,73.07 62.42,70.83 62.42,68.98 61.3,67.86 61.3,53.74 60.39,52.82 60.39,48.22 54.35,42.19 51.82,42.19 v2(51.6,41.96)
  BOTTOM w0.102: v2(127.26,93.41) 127.26,93.45 UH1.C28
  BOTTOM w0.114: v2(51.6,41.96) 51.78,42.15 52.57,42.15 CV589.1
EDP_TXP3_C: length 1.7
  BOTTOM w0.114: CV589.2 54.13,42.15 54.68,42.15 54.81,42.02 55.07,42.02 55.24,41.85 RV548.1
EDP_TXP3_R: length 7
  BOTTOM w0.114: RV548.2 56.16,41.85 56.32,42.02 56.59,42.02 56.72,42.14 56.98,42.14 57.33,42.49 58.2,42.49 58.54,42.14 61.84,42.14 61.98,42.01 JEDP1.37
EDPVDD:
  vias: v4(67.78,40.91)
EN_0.6V: length 6.8
  BOTTOM w0.254: PU500.2 99.8,13.26 PC518.1 97.52,14.32 PR510.1 97.52,14.34 98.1,14.93 98.1,15.69 98.71,16.3 PR509.2 PR511.2
EN_1.2V: length 6.2
  BOTTOM w0.114: v3(93.71,13.93) PR507.2
  BOTTOM w0.254: PU500.1 99.35,13.08 98.85,13.58 97.32,13.58 96.96,13.93 PC517.1 PR508.1 PR507.2
EN_1VALWP: length 5.2
  BOTTOM w0.114: v3(254.39,12.03) 254.16,12.26 PR604.1
  BOTTOM w0.254: PU600.11 251.35,13.48 252.49,12.35 PC612.1 PR604.1 253.43,12.31 PR603.2
EN_+1.0VSP: length 8.6
  BOTTOM w0.114: v3(225.35,36.24) 225.4,36.19 PR806.2
  BOTTOM w0.203: PU800.11 224.06,41.79 224.26,41.58 225.41,41.58 225.71,41.28 225.71,39.58 226.37,38.92 PC812.1 PR807.1 PR804.2 PR806.2
EN_+1.8VSP: length 5.2
  BOTTOM w0.114: PR1011.2 210.96,115.74 210.84,115.85 v3(210.84,116.19)
  BOTTOM w0.254: PR1011.2 PR1007.1 PC1012.1 209.08,115.79 209.08,115.79 209.08,116.29 208.52,116.85 PU1000.11
EN_+1.35VS_VGAP: length 5.9
  BOTTOM w0.114: PR913.2 142.78,107.53 v3(143.14,107.18)
  BOTTOM w0.254: PU900.3 140.81,110.74 141.03,110.52 PC906.1 PR903.2 141.03,108.88 141.49,108.42 142.5,108.42 PR913.2
ENVDD: length 4.6
  TOP w0.114: RZ40.1 65.35,35.03 DV3.1 ; RZ40.1 66.81,35.68 v3(66.93,35.79) ; RZ40.1 66,35.91 65.61,36.3 UZ8.4
ENVDD_PCH: length 104.9
  TOP w0.114: v2(68.36,29.78) 68.67,30.09 68.67,31.11 v3(68.51,31.26) 68.3,31.47 68.3,31.94 68.66,32.3 68.66,33.04 67.25,34.45 DV3.3
  IN3 w0.127: v2(68.36,29.78) 68.56,29.99 71.99,29.99 73.22,28.76 108.81,28.76 109.5,28.07 141.06,28.07 142.71,29.72 146.29,29.72 147.46,30.89 152.72,30.89 154.9,33.06 154.9,35.55 156.42,37.07 157.31,37.07 158.26,36.12 v2(158.26,34.05)
  BOTTOM w0.089: v2(158.26,34.05) 158.6,34.38 UH2.W42
FAN1_PWM: length 196.4
  TOP w0.114: v2(59.78,27.49) 60.2,27.9 60.2,28.73 Q12.3 58.89,28.01 RE121.2 ; UE1.47 v2(227.45,17.41)
  IN3 w0.127: v2(227.45,17.41) 226.96,16.93 224.07,16.93 223.57,17.43 219.92,17.43 218.22,15.73 216.01,15.73 215.39,15.1 211.31,15.1 209.78,16.64 199.42,16.64 194.14,11.36 185.05,11.36 183.08,9.39 180.03,9.39 179.28,8.64 171.84,8.64 167.97,12.51 162.27,12.51 160.77,11 153.24,11 152.52,11.72 152.52,13.79 150.67,15.64 150.67,16.71 149.99,17.39 146.31,17.39 145.02,18.68 136.23,18.68 134.85,17.3 116.23,17.3 115.36,16.42 110.35,16.42 109.79,16.98 94.91,16.98 93.68,18.21 93.68,18.79 93.08,19.4 62.65,19.4 58.53,23.52 58.53,24.52 59.78,25.76 v2(59.78,27.49)
  BOTTOM w0.114: v4(227.66,18.2) 227.45,18 v2(227.45,17.41)
FAN1_TACH: length 191.1
  TOP w0.203: v2(224.52,17.35) 224.65,17.22 UE1.40
  TOP w0.254: v2(58.4,25.11) 58.47,25.11 58.68,25.33 58.68,25.85 v3(58.62,25.91) 57.93,26.6 56.32,26.6 53.98,28.93 DE7.2 53.62,31.03 CE99.1 RE81.2
  IN1 w0.254: v2(58.4,25.11) 58.63,24.88 58.63,23.48 59.29,22.82 59.29,22.39 65.54,16.14 74.55,16.14 75.1,16.7 98.7,16.7 99.07,16.32 105.16,16.32 105.33,16.49 109.87,16.49 110.31,16.05 114.85,16.05 116.14,17.34 132.09,17.34 132.52,16.91 145.02,16.91 147.19,14.73 153.4,14.73 153.79,15.13 158.09,15.13 159.69,13.53 167.49,13.53 170.36,10.66 174.86,10.66 175.6,11.39 179.58,11.39 179.76,11.58 179.76,11.58 179.97,11.79 184.02,15.83 188.44,15.83 188.9,16.29 198.2,16.29 199.9,17.99 205.7,17.99 205.71,17.98 211.36,17.98 212.13,18.76 220.68,18.76 221.52,17.92 223.47,17.92 224.04,17.35 v2(224.52,17.35)
FAN2_PWM: length 36.5
  TOP w0.114: v2(244.69,20.89) 244.74,20.89 244.97,21.13 244.97,23.15 244.21,23.91 244.21,26.63 v3(244.46,26.88) 244.46,27.41 244.69,27.64 RE122.2 244.61,28.13 244.61,29.23 Q13.3 ; v2(222.6,14.77) 222.25,15.12 UE1.34
  IN1 w0.094: v2(244.69,20.89) 244.69,20.87 244.45,20.63 240.68,20.63 240.52,20.63 239.55,19.66 235.84,19.66 234.22,18.05 233.66,18.05 231.36,15.75 222.94,15.75 222.6,15.41 v2(222.6,14.77)
FAN2_TACH: length 233.1
  TOP w0.203: v2(225.1,17.36) 225.05,17.31 UE1.41
  TOP w0.254: v2(245.59,26.17) 244.98,26.78 244.98,27.43 246.14,28.59 246.14,30.52 245.68,30.98 243.98,30.98 242.58,32.38 242.58,35.05 242.22,35.4 242.22,38.04 CE100.1 DE9.2 ; RE83.2 51.19,30.47 51.7,29.96 52.42,29.96 v3(53.28,29.1) 56.23,26.15 57.54,26.15 v2(58.05,25.64)
  IN1 w0.254: v2(225.1,17.36) 225.1,17.44 224.67,17.88 224.08,17.88 223.68,18.28 221.7,18.28 220.87,19.11 211.99,19.11 211.22,18.35 199.72,18.35 198.02,16.65 188.75,16.65 188.3,16.19 183.87,16.19 179.49,11.8 175.3,11.8 174.58,11.09 170.43,11.09 167.63,13.88 159.84,13.88 158.24,15.48 153.64,15.48 153.25,15.09 147.34,15.09 145.16,17.26 132.67,17.26 132.24,17.69 116,17.69 114.71,16.41 110.49,16.41 110.05,16.85 105.08,16.85 104.92,16.68 99.25,16.68 98.88,17.05 74.96,17.05 74.41,16.51 65.69,16.51 59.64,22.55 59.64,22.97 58.99,23.63 58.99,25.21 58.55,25.64 v2(58.05,25.64)
  IN3 w0.254: v2(245.59,26.17) 245.22,26.55 242.57,26.55 238.57,22.55 235.01,22.55 234.78,22.77 233.33,22.77 232.18,21.62 227.2,21.62 226.67,21.08 226.67,19.66 225.1,18.1 v2(225.1,17.36)
FB_1VALWP: length 4.4
  TOP w0.254: PR602.2 PC606.2 250.28,12.18 v3(250.01,12.45) 249.82,12.64 v2(249.82,12.94)
  BOTTOM w0.254: PU600.14 250,14.06 250,13.13 v2(249.82,12.94) 249.74,12.87 PR605.1
FB_3V: length 6.4
  BOTTOM w0.102: v3(59.48,19.45) 58.93,20.01 PR403.2
  BOTTOM w0.203: PC401.2 55.5,20.01 54.35,21.16 PU400.4
  BOTTOM w0.254: PR403.2 PR401.2 PC401.2
FB_5V: length 4.6
  BOTTOM w0.203: PU400.2 54.33,21.95 54.67,22.3
  BOTTOM w0.254: PR402.1 PC402.1 PR404.1 55.09,23.36 v2(54.67,22.94) 54.67,22.3
FB_+0.95VSP: length 7.1
  TOP w0.254: PR708.1 PR706.2 PC712.2 v2(68.67,64.77) 68.5,64.77 67.95,65.33 PU700.14
  BOTTOM w0.114: v2(68.67,64.77) 67.14,63.25 v4(66.22,63.25)
FB_+1.0VSP: length 5.2
  BOTTOM w0.114: PC806.2 220.3,40 v3(220.7,39.6)
  BOTTOM w0.254: PC806.2 220.71,40.53 220.91,40.33 PR805.2 PR808.1 222.49,40.74 222.71,40.97 PU800.14
FB_+1.8VSP: length 4.5
  BOTTOM w0.114: v3(205.29,113.43) PR1004.2
  BOTTOM w0.203: PR1008.1 206.21,115.82 206.57,116.18 PU1000.14
  BOTTOM w0.254: PR1004.2 PC1006.2 PR1008.1
FB_+1.35VS_VGAP: length 6.6
  TOP w0.254: v2(140.4,109.54) v3(141.18,109.54) 141.56,109.54 142.17,110.15 142.61,110.15 PR910.1
  BOTTOM w0.254: PR906.1 PR907.1 140.28,110.1 140.31,110.07 ; 140.31,110.07 PU900.4 ; 140.31,110.07 140.31,109.76 140.4,109.67 v2(140.4,109.54)
FBA_ABI#_H: length 33.2
  IN1 w0.102: 168.26,124.77 166.88,124.77 166.61,124.51 165.08,124.51 v2(164.7,124.89)
  IN1 w0.152: v2(165.89,99.03) 166.28,99.43 166.28,99.7 166.3,99.71 166.3,100.05 166.28,100.06 166.28,100.53 166.3,100.54 166.3,100.88 166.28,100.89 166.28,105.49 166.41,105.61 166.41,112.41 170.06,116.07 170.06,122.97 168.26,124.77
  BOTTOM w0.185: v2(165.89,99.03) 165.89,99.06 UV1.Y29 ; UV7.J4 v2(164.7,124.89)
FBA_ABI#_L: length 36.5
  TOP w0.102: 178.82,118.23 178.82,122.65 179.08,122.91 179.36,122.91 179.78,123.33 179.78,124.45 179.56,124.67 179.22,124.67 179,124.89 v2(178.4,124.89) ; v2(168.39,98.21) UV1.V28 167.99,99.15 167.67,99.47 167.44,99.47 167.18,99.72 167.18,101.5 167.44,101.76 167.44,102.56 167.96,103.08 167.96,108.68 169.01,109.72
  TOP w0.185: 169.01,109.72 169.01,110.01 172.27,113.26 174.93,113.26 v4(177.22,115.54) 178.47,116.8 178.47,117.88 178.82,118.23
  BOTTOM w0.185: UV6.J4 v2(178.4,124.89) ; UV1.V28 v2(168.39,98.21)
FBA_CAS#_H: length 31.4
  TOP w0.102: v2(165.34,108.01) 165.18,108.01
  TOP w0.185: v2(164.7,126.49) 164.67,126.51 162.72,126.51 161.76,125.55 161.76,121.53 162.38,120.9 v4(162.38,115.26) 162.38,114.93 161.93,114.48 161.93,113.76 163.33,112.37 163.33,109.85 165.18,108.01
  BOTTOM w0.185: UV1.V31 167.99,101.36 167.59,101.76 167.59,105.76 v2(165.34,108.01) ; v2(164.7,126.49) 165.1,126.89 UV7.G3
FBA_CAS#_L: length 35.1
  IN1 w0.102: v2(177.6,126.49) 177.19,126.08 176.49,126.08 176.18,125.77 174.18,125.77 173.92,125.51
  IN1 w0.152: 173.92,125.51 171.78,123.37 171.18,122.77 171.18,115.47 167.75,112.04 167.75,104.05 168.06,103.75 168.06,101.98 167.98,101.91 167.98,101.11 v2(168.39,100.71)
  BOTTOM w0.185: v2(168.39,100.71) 167.84,100.71 167.54,101.01 167.54,101.31 167.34,101.51 166.69,101.51 UV1.Y32 ; UV6.L3 v2(177.6,126.49)
FBA_CKE_H: length 31
  TOP w0.102: 168.49,126.36 168.36,126.48 166.74,126.48 166.33,126.08 165.87,126.08 165.5,125.71 v2(165.5,125.69) ; 167.62,109.72 167.22,109.32 167.22,104.41 v2(166.71,103.91)
  TOP w0.185: 168.49,126.36 RV98.2 168.81,126.03 169.34,126.03 171.16,124.22 v4(171.16,121.4) 171.16,114.86 167.62,111.33 167.62,109.72
  BOTTOM w0.185: v2(165.5,125.69) 165.1,125.29 UV7.J3 ; UV1.Y33 166.71,103.13 v2(166.71,103.91)
FBA_CKE_L: length 34
  TOP w0.102: 174.76,125.74 175.35,125.74 175.4,125.69 v2(176.8,125.69)
  TOP w0.185: 174.76,125.74 174.23,125.74 173.49,126.48 RV95.2 172.91,126.53 171.85,125.47 171.85,117.08 v4(172.31,116.61) 173.05,115.88 174.32,115.88 v2(174.63,115.56)
  BOTTOM w0.185: UV6.J3 v2(176.8,125.69) ; UV1.V33 167.99,102.96 168.39,103.36 168.39,109.76 174.19,115.56 v2(174.63,115.56)
FBA_CLK0: length 40.3
  TOP w0.102: v2(170.06,100.71) 170.33,100.98 170.33,101.15 170.45,101.26 170.45,101.81 170.24,102.01 170.24,103.2 170.84,103.8 170.84,105.47 171.03,105.66 171.31,105.93 171.37,105.99 171.37,106.41 171.93,106.97 172.25,106.97
  TOP w0.124: v2(184.34,112.89) 184.58,112.89 184.69,112.78 184.69,112.6 180.72,108.63 173.9,108.63 172.25,106.97
  IN1 w0.117: v2(184.34,112.89) 184.34,113.15 182.56,114.92 182.56,123.98 182.7,124.12 182.7,124.49 182.56,124.62 182.56,125.15 182.94,125.53 183.37,125.53 183.53,125.69 v2(184,125.69)
  BOTTOM w0.124: v2(184,125.69) 184.4,125.29 UV6.J12 ; v2(184.34,112.89) 184.34,112.99 184.13,113.19 183.91,113.41 183.77,113.41 RV595.1 ; v2(170.06,100.71) 170.46,100.31 UV1.R30
FBA_CLK0#: length 39.8
  TOP w0.102: 172.25,106.69 171.93,106.69 171.57,106.32 171.57,105.91 171.04,105.38 171.04,103.71 170.44,103.11 170.44,102.1 170.65,101.89 170.65,101.18 170.54,101.07 170.54,100.98 170.81,100.71 v2(170.89,100.71)
  TOP w0.124: v2(184.75,113.31) 184.75,113.03 184.91,112.87 184.91,112.51 180.81,108.41 174,108.41 172.63,107.04 172.63,107.03 172.56,106.96 172.56,106.96 172.35,106.75 172.35,106.75 172.34,106.75 172.31,106.75 172.25,106.69
  IN1 w0.117: v2(184.75,113.31) 184.49,113.31 182.79,115.02 182.79,123.89 182.92,124.03 182.92,124.58 182.79,124.72 182.79,125.06 183.03,125.3 183.37,125.3 183.4,125.28 183.41,125.28 183.41,125.27 183.62,125.27 v2(184,124.89)
  BOTTOM w0.124: v2(184.75,113.31) 184.71,113.35 184.29,113.35 184.07,113.57 184.07,113.69 RV594.1 ; UV6.J11 184,124.89 v2(184,124.89) ; UV1.R31 v2(170.89,100.71)
FBA_CLK1: length 35.1
  TOP w0.102: 160.07,105.98 160.64,105.98 160.89,106.24 162.24,106.24 163.15,105.32 163.15,102.42 163.2,102.37 163.2,102.36 163.42,102.15 163.64,102.15 163.91,101.89 163.91,101.72 164.12,101.51 v2(164.22,101.51)
  TOP w0.124: 160.07,105.98 159.99,106.06 159.98,106.06 159.44,106.61 159.44,107.89 158.87,108.45 156.63,110.7 156.63,112.72 v2(156.83,112.92)
  IN1 w0.102: 159.59,124.01 159.57,124.02 159.57,124.48 159.7,124.6 159.7,125.19 159.29,125.59 158.94,125.59 158.74,125.4 158.52,125.4 158.3,125.63 v2(158.3,125.69)
  IN1 w0.117: v2(156.83,112.92) 156.63,113.12 156.63,114.28 160.16,117.81 160.16,123.43 159.59,124.01
  BOTTOM w0.124: UV1.AB31 164.62,101.11 v2(164.22,101.51) ; RV597.1 156.52,113.71 156.52,113.22 v2(156.83,112.92) ; v2(158.3,125.69) 158.3,125.69 UV7.J12
FBA_CLK1#: length 34.7
  TOP w0.102: 159.98,105.76 160.7,105.76 160.98,106.04 162.16,106.04 162.95,105.24 162.95,102.33 163,102.28 163,102.28 163.33,101.95 163.56,101.95 163.7,101.8 163.7,101.72 163.49,101.51 v2(163.39,101.51)
  TOP w0.124: v2(156.19,112.92) 156.41,112.71 156.41,110.61 158.72,108.3 159.22,107.8 159.22,106.52 159.98,105.76
  IN1 w0.102: 159.43,123.85 159.37,123.91 159.37,124.56 159.5,124.69 159.5,125.1 159.21,125.39 159.04,125.39 158.84,125.19 158.67,125.19 158.36,124.89 v2(158.3,124.89)
  IN1 w0.117: 159.43,123.85 159.93,123.34 159.93,117.9 156.4,114.37 156.4,113.13 v2(156.19,112.92)
  BOTTOM w0.124: RV596.1 156.3,113.7 156.3,113.03 v2(156.19,112.92) ; UV7.J11 v2(158.3,124.89) ; v2(163.39,101.51) 163.41,101.51 163.79,101.13 UV1.AC31
FBA_CS#_H: length 30.9
  TOP w0.102: 163.42,106.25 164.6,105.07 164.6,101.09 v2(164.22,100.71) ; v2(158.3,124.09) UV7.L12 156.4,123.69
  TOP w0.185: 156.4,123.69 156.27,123.56 156.27,116.62 157.62,115.28 157.62,111.69 v3(158.94,110.37) 161.38,107.93 161.74,107.93 163.42,106.25
  BOTTOM w0.185: v2(164.22,100.71) 165.09,100.71 UV1.AA31 ; UV7.L12 v2(158.3,124.09)
FBA_CS#_L: length 36.7
  TOP w0.102: v2(184,124.09) 184.14,124.09 184.54,123.69 185.05,123.69 185.2,123.54 185.2,123.03 185.33,122.9 185.8,122.9 186.05,122.65 ; v2(169.22,100.71) 169.6,101.09 169.6,101.76 169.94,102.1 169.94,106.13 171.4,107.6
  TOP w0.185: 186.05,122.65 v4(186.05,116.5) 186.05,115.94 179.77,109.66 173.57,109.66 171.5,107.6 171.4,107.6
  BOTTOM w0.185: UV6.G12 184.4,123.69 v2(184,124.09) ; UV1.U30 168.82,100.31 v2(169.22,100.71)
FBA_D0: length 23.7
  IN1 w0.102: 173.8,106.64 173.63,106.47 173.63,98.79 v2(174.22,98.21)
  IN1 w0.152: v2(178.4,118.49) 177.9,117.99 177.9,112.27 173.78,108.15 173.78,106.93 173.8,106.91 173.8,106.64
  BOTTOM w0.185: UV1.L28 173.81,98.61 v2(174.22,98.21) ; v2(178.4,118.49) 178,118.89 UV6.A4
FBA_D1: length 22.5
  IN1 w0.102: 176.29,117.85 176,118.13 v2(176,118.49) ; v2(172.57,99.03) 172.95,99.41 172.95,106.33 172.63,106.64
  IN1 w0.152: 172.63,106.64 172.63,109.67 176.29,113.33 176.29,117.85
  BOTTOM w0.185: UV1.M29 v2(172.57,99.03) ; v2(176,118.49) 176.4,118.89 UV6.A2
FBA_D2: length 24
  IN1 w0.102: 174.63,106.64 174.63,105.78 174.37,105.52 174.09,105.52 173.83,105.27 173.83,99.41 v2(174.22,99.03)
  IN1 w0.152: v2(178.4,119.29) 178.83,118.86 178.83,117.8 178.52,117.49 178.52,112.1 174.65,108.23 174.65,106.93 174.63,106.91 174.63,106.64
  BOTTOM w0.185: v2(178.4,119.29) 178,119.69 UV6.B4 ; UV1.L29 v2(174.22,99.03)
FBA_D3: length 24.4
  IN1 w0.102: v2(172.57,98.21) 173.25,98.89 173.25,106.64 ; 176.91,117.85 176.9,117.85 176.38,118.37 176.38,118.91 v2(176,119.29)
  IN1 w0.152: 176.91,117.85 176.91,113.16 173.22,109.48 173.22,106.67 173.25,106.64
  BOTTOM w0.185: v2(176,119.29) 176.4,119.69 UV6.B2 ; v2(172.57,98.21) 172.97,98.61 UV1.M28
FBA_D4: length 27.2
  IN1 w0.102: v2(171.71,100.71) 171.69,100.71 170.84,101.56 170.84,101.75 170.46,102.13 170.46,102.48 ; v2(177.6,121.69) 177.22,121.31 175.72,121.31 175.3,120.89 174.13,120.89
  IN1 w0.152: 174.13,120.89 173.97,120.74 173.97,114.32 170.7,111.04 170.7,102.72 170.46,102.48
  BOTTOM w0.185: UV6.E4 178,122.09 v2(177.6,121.69) ; UV1.N31 171.74,100.71 v2(171.71,100.71)
FBA_D5: length 28.3
  IN1 w0.102: 174.13,121.69 v2(176,121.69) ; 169.98,103.07 169.98,102.22 170.49,101.71 170.49,100.57 170.74,100.32 170.99,100.32 171.31,100 171.31,99.44 v2(171.71,99.03)
  IN1 w0.152: 169.98,103.07 170.14,103.24 170.14,111.27 173.42,114.55 173.42,120.98 174.13,121.69
  BOTTOM w0.185: UV1.P29 v2(171.71,99.03) ; v2(176,121.69) 176.4,122.09 UV6.E2
FBA_D6: length 31
  IN1 w0.102: v2(170.06,99.03) 170.45,99.41 170.45,100.04 170.18,100.31 169.93,100.31 169.68,100.55 169.68,102.61 ; 173.92,122.31 174.08,122.47 175.16,122.47 175.52,122.11 177.22,122.11 v2(177.6,122.49)
  IN1 w0.152: 173.92,122.31 172.86,121.25 172.86,114.78 169.58,111.5 169.58,102.72 169.68,102.61
  BOTTOM w0.185: UV6.F4 v2(177.6,122.49) ; v2(170.06,99.03) UV1.R29
FBA_D7: length 32.3
  IN1 w0.102: v2(170.89,99.03) 170.51,98.65 169.06,98.65 168.83,98.88 168.83,102.52 169.02,102.71 ; v2(176,122.49) 175.22,123.27 174.08,123.27 173.92,123.11
  IN1 w0.152: 173.92,123.11 172.3,121.49 172.3,115.01 169.02,111.73 169.02,102.71
  BOTTOM w0.185: v2(170.89,99.03) 170.89,99.01 UV1.P28 ; UV6.F2 v2(176,122.49)
FBA_D8: length 27.4
  IN1 w0.102: v2(175.06,99.03) 175.45,99.41 175.45,101.63 175.1,101.97 175.1,104.32 177.56,106.77 177.56,107.15 178.14,107.74
  IN1 w0.152: v2(183.2,118.49) 183.51,118.18 183.51,117.58 185.63,115.45 185.63,113.35 182.7,110.41 180.82,110.41 178.14,107.74
  BOTTOM w0.185: v2(175.06,99.03) UV1.J28 ; v2(183.2,118.49) 183.6,118.89 UV6.A11
FBA_D9: length 27.5
  IN1 w0.102: v2(176.71,99.88) 176.71,100.03 176.33,100.41 176.33,103.77 178.43,105.86 179.16,105.86 179.91,106.61
  IN1 w0.152: 179.91,106.61 182.04,108.74 183.39,108.74 188.09,113.44 188.09,116.1 187.69,116.5 186.99,116.5 185.6,117.89 v2(185.6,118.49)
  BOTTOM w0.185: UV1.H29 v2(176.71,99.88) ; UV6.A13 v2(185.6,118.49)
FBA_D10: length 27.4
  IN1 w0.102: 184.4,117.73 184.4,118.89 v2(184,119.29) ; v2(175.89,99.88) 175.74,100.03 175.74,101.62 175.31,102.05 175.31,104.21 178.53,107.43 178.7,107.43 179,107.74
  IN1 w0.152: 184.4,117.73 184.4,117.48 186.19,115.68 186.19,113.12 182.93,109.85 181.57,109.85 179.66,107.94 179.21,107.94 179,107.74
  BOTTOM w0.185: UV1.J29 175.89,99.86 v2(175.89,99.88) ; UV6.B11 v2(184,119.29)
FBA_D11: length 28.5
  IN1 w0.102: v2(176.71,99.03) 176.29,99.46 176.29,100.11 176.04,100.36 176.04,101.61 175.51,102.14 175.51,103.27 178.41,106.16 178.67,106.16 179.51,107 ; 185.07,117.59 185.04,117.63 185.04,118.19 185.18,118.33 185.18,118.87 v2(185.6,119.29)
  IN1 w0.152: 185.07,117.59 186.75,115.92 186.75,112.89 183.16,109.29 181.81,109.29 179.51,107
  BOTTOM w0.185: UV6.B13 v2(185.6,119.29) ; UV1.H28 v2(176.71,99.03)
FBA_D12: length 33.9
  IN1 w0.102: 187.65,120.89 186.3,120.89 185.89,121.3 184.39,121.3 v2(184,121.69) ; 181.11,105.4 181.04,105.32 180.97,105.32 180.76,105.12 179.06,105.12 178.79,104.85 178.79,102.97 178.29,102.47 178.29,102.06 177.99,101.76 177.99,100.31 v2(177.57,99.88)
  IN1 w0.152: 187.65,120.89 189.77,118.77 189.77,112.74 184.09,107.06 182.77,107.06 181.27,105.56 181.11,105.4
  BOTTOM w0.185: UV6.E11 v2(184,121.69) ; UV1.G29 v2(177.57,99.88)
FBA_D13: length 34.2
  IN1 w0.102: 182.55,104.47 182.25,104.17 182.25,103.88 181.91,103.53 180.74,103.53 179.64,102.42 179.64,102.15 179.35,101.87 179.35,101.65 v2(179.22,101.51) ; v2(184.8,122.49) 185.19,122.88 185.89,122.88 186.28,123.27 187.65,123.27
  IN1 w0.152: 187.65,123.27 187.66,123.27 191.44,119.49 191.44,112.36 191.44,112.05 184.7,105.3 183.38,105.3 182.55,104.47
  BOTTOM w0.185: UV6.E13 v2(184.8,122.49) ; v2(179.22,101.51) 178.81,101.11 UV1.E31
FBA_D14: length 32.6
  IN1 w0.102: v2(178.39,101.51) 178.54,101.66 178.54,102.42 179.14,103.02 179.14,103.4 179.6,103.86 179.79,103.86 180.95,105.02 181.52,105.02 181.65,105.15 ; v2(184,122.49) 184.4,122.09 185.9,122.09 186.3,121.69 187.65,121.69
  IN1 w0.152: 187.65,121.69 190.33,119.02 190.33,112.51 184.23,106.42 182.92,106.42 181.65,105.15
  BOTTOM w0.185: UV1.E32 v2(178.39,101.51) ; UV6.F11 v2(184,122.49)
FBA_D15: length 33.1
  IN1 w0.102: 182.16,104.86 182.08,104.79 181.11,104.79 180.19,103.87 180.19,103.37 179.75,102.93 179.34,102.93 178.79,102.38 178.79,101.11 v2(178.39,100.71) ; v2(185.6,122.49) 187.65,122.49
  IN1 w0.152: 182.16,104.86 183.15,105.86 184.46,105.86 190.88,112.28 190.88,119.26 187.65,122.49
  BOTTOM w0.185: UV6.F13 v2(185.6,122.49) ; UV1.F30 v2(178.39,100.71)
FBA_D16: length 39.5
  IN4 w0.102: 181.77,104.89 181.67,104.79 181.11,104.79 180.89,104.57 v2(180.89,103.91) ; v2(184,131.29) 184.78,132.07 187.61,132.07
  IN4 w0.152: 181.77,104.89 191.41,114.53 191.41,126.52 190.2,127.73 190.2,129.49 187.62,132.07 187.61,132.07
  BOTTOM w0.185: v2(184,131.29) 184,131.29 UV6.U11 ; UV1.C34 v2(180.89,103.91)
FBA_D17: length 38
  IN4 w0.102: 180.86,104.89 180.33,104.37 180.33,102.58 v2(180.06,102.31) ; v2(185.6,131.29) 187.61,131.29
  IN4 w0.152: 180.86,104.89 180.98,105.02 181.11,105.02 190.85,114.77 190.85,126.29 189.64,127.5 189.64,129.26 187.61,131.29
  BOTTOM w0.185: v2(180.06,102.31) 180.04,102.31 UV1.D32 ; v2(185.6,131.29) 185.6,131.29 UV6.U13
FBA_D18: length 42
  IN4 w0.152: v2(181.7,103.92) 181.7,104.03 191.97,114.3 191.97,126.75 190.76,127.96 190.76,129.73 187.59,132.9 184.81,132.9 v2(183.2,131.29)
  BOTTOM w0.185: UV6.T11 183.2,131.29 v2(183.2,131.29) ; v2(181.7,103.92) 181.7,103.12 UV1.B33
FBA_D19: length 35.8
  IN4 w0.102: v2(185.6,130.49) 187.44,130.49 187.61,130.32
  IN4 w0.152: v2(180.06,104.71) 180.22,104.87 180.22,104.93 190.29,114.99 190.29,126.06 189.08,127.27 189.08,128.85 187.61,130.32
  BOTTOM w0.185: UV1.C33 180.06,103.13 v2(180.06,104.71) ; UV6.T13 v2(185.6,130.49)
FBA_D20: length 31.1
  IN4 w0.102: v2(183.2,128.89) 182.82,128.51 182.82,126.96
  IN4 w0.152: v2(177.57,102.31) 176.3,103.58 176.3,106.78 179.71,110.19 179.71,115.33 182.79,118.4 182.79,126.93 182.82,126.96
  BOTTOM w0.185: v2(177.57,102.31) 177.97,102.71 UV1.F33 ; UV6.N11 v2(183.2,128.89)
FBA_D21: length 34.4
  IN4 w0.102: v2(184.8,128.09) 185.18,128.47 185.76,128.47 186.22,128.01 186.22,126.73 186.48,126.47 187.43,126.47 187.61,126.29 ; 178.01,104.3 178.01,103.68 178.39,103.3 v2(178.39,103.11)
  IN4 w0.152: 187.61,126.29 188.17,125.73 188.17,115.33 177.96,105.13 177.96,104.35 178.01,104.3
  BOTTOM w0.185: UV1.F32 178.39,102.31 v2(178.39,103.11) ; UV6.N13 185.2,128.49 v2(184.8,128.09)
FBA_D22: length 33.3
  IN4 w0.102: 186.02,125.9 186.02,127.41 185.73,127.7 184.39,127.7 v2(184,128.09) ; v2(177.57,103.91) 177.47,104
  IN4 w0.152: 177.47,104 177.4,104.07 177.4,105.36 178.06,106.02 178.06,106.93 182.92,111.79 182.92,112.32 187.61,117 187.61,124.66 187.31,124.96 186.95,124.96 186.02,125.9
  BOTTOM w0.185: v2(177.57,103.91) 177.39,103.73 177.32,103.73 UV1.H33 ; v2(184,128.09) 183.6,127.69 UV6.M11
FBA_D23: length 32.8
  IN4 w0.102: v2(185.6,127.29) 185.22,126.91 185.22,126.28 185.3,126.2 ; 177.17,103.51 177.7,103.51 177.95,103.27 177.95,102.15 177.69,101.89 177.1,101.89 v2(176.71,101.51)
  IN4 w0.152: 185.3,126.2 185.3,125.17 186.01,124.46 186.01,116.42 182.17,112.58 182.17,111.86 176.86,106.55 176.86,103.83 177.17,103.51
  BOTTOM w0.185: UV1.H32 176.69,101.51 v2(176.71,101.51) ; UV6.M13 185.6,127.29 v2(185.6,127.29)
FBA_D24: length 35
  IN4 w0.102: v2(178.4,132.09) 177.98,131.67 177.98,131.13 177.73,130.88 175.69,130.88 175.31,130.5 173.97,130.5 173.62,130.14
  IN4 w0.152: 173.62,130.14 173.39,129.91 173.39,114.82 170.86,112.29 170.86,105.53 171.29,105.11 v2(171.71,105.11)
  BOTTOM w0.185: v2(178.4,132.09) 178,131.69 UV6.U4 ; v2(171.71,105.11) 171.29,104.68 UV1.P34
FBA_D25: length 37.8
  IN4 w0.102: v2(176.8,132.09) 175.99,132.9 173.62,132.9
  IN4 w0.152: 173.62,132.9 171.69,130.97 171.69,115.61 169.19,113.11 169.19,104.01 v2(170.89,102.31)
  BOTTOM w0.185: UV6.U2 v2(176.8,132.09) ; v2(170.89,102.31) UV1.P32
FBA_D26: length 38.5
  IN4 w0.102: v2(177.6,131.29) 177.2,131.69 175.7,131.69 175.3,132.09 173.62,132.09 ; 171.29,102.78 171.29,101.93 v2(171.71,101.51)
  IN4 w0.152: 173.62,132.09 172.25,130.72 172.25,115.27 169.74,112.77 169.74,104.32 171.29,102.78
  BOTTOM w0.185: UV6.T4 v2(177.6,131.29) ; v2(171.71,101.51) 171.69,101.51 UV1.P31
FBA_D27: length 34
  IN4 w0.102: v2(176,131.29) 173.62,131.29
  IN4 w0.152: 173.62,131.29 172.83,130.5 172.83,115.05 170.3,112.53 170.3,104.78 171.17,103.91 v2(171.71,103.91)
  BOTTOM w0.185: UV1.P33 171.71,103.13 v2(171.71,103.91) ; UV6.T2 v2(176,131.29)
FBA_D28: length 33.6
  IN4 w0.102: v2(174.22,105.9) 173.8,106.32 173.8,106.67 ; v2(177.6,128.09) 177.99,127.7 177.99,127.12 178.22,126.89 179.54,126.89
  IN4 w0.152: 179.54,126.89 180.71,125.72 180.71,124.93 181.06,124.58 181.06,118.41 178.59,115.94 178.59,112.27 173.66,107.34 173.66,106.88 173.78,106.75 173.78,106.68 173.8,106.67
  BOTTOM w0.185: UV6.N4 v2(177.6,128.09) ; v2(174.22,105.9) 173.98,105.67 173.39,105.07 173.39,101.51 UV1.L31
FBA_D29: length 32.2
  IN4 w0.102: v2(174.22,104.51) 173.74,104.98 173.74,106.03 173.1,106.67 ; v2(176,128.09) 176.03,128.09 176.44,127.68 177.1,127.68 177.2,127.57 177.2,126.28 177.38,126.1 178.78,126.1 178.8,126.08
  IN4 w0.152: 178.8,126.08 179.23,125.64 179.74,125.64 179.94,125.44 179.94,124.91 180.4,124.45 180.4,118.74 177.2,115.53 177.2,114.54 176.77,114.11 176.77,111.24 173.1,107.57 173.1,106.67
  BOTTOM w0.185: UV6.N2 v2(176,128.09) ; v2(174.22,104.51) 173.86,104.15 173.85,104.15 173.79,104.08 UV1.L34
FBA_D30: length 33.5
  IN4 w0.102: 179.87,127.65 179.84,127.68 178.57,127.68 178.4,127.5 v2(178.4,127.29)
  IN4 w0.152: v2(174.22,107.11) 179.15,112.04 179.15,115.69 181.7,118.23 181.7,124.83 181.36,125.17 181.36,126.16 179.87,127.65
  BOTTOM w0.185: v2(174.22,107.11) 174.66,107.11 174.83,106.94 174.83,106.49 175.09,106.23 v3(175.09,105.78) 175.09,102.54 174.85,102.31 174.19,102.31 UV1.L32 ; UV6.M4 v2(178.4,127.29)
FBA_D31: length 31.8
  IN4 w0.102: 178.65,125.29 176.64,125.29 176.39,125.54 176.39,126.88 v2(176.8,127.29) ; 172.72,106.54 172.95,106.32 173.39,105.88 173.39,103.93 v2(174.22,103.11)
  IN4 w0.152: 178.65,125.29 178.88,125.06 178.88,124.07 179.13,123.82 179.25,123.82 179.74,123.32 179.74,119.22 176.39,115.86 176.39,114.65 175.96,114.21 175.96,111.22 172.54,107.8 172.54,106.73 172.72,106.54
  BOTTOM w0.185: UV1.L33 173.81,102.71 v2(174.22,103.11) ; UV6.M2 v2(176.8,127.29)
FBA_D32: length 23.5
  IN1 w0.102: v2(160.06,98.3) 160.72,98.95 160.72,102.1
  IN1 w0.152: v2(163.9,118.48) 163.88,118.48 160.06,114.65 160.06,109.9 160.06,108.97 160.13,108.9 160.13,106.19 160.72,105.6 160.72,102.1
  BOTTOM w0.185: v2(163.9,118.48) 164.3,118.88 UV7.U4 ; UV1.AG28 160.18,98.3 v2(160.06,98.3)
FBA_D33: length 24.4
  IN1 w0.102: 162.04,106.04 162.32,105.75 162.32,104.94 162.16,104.78 162.16,103.82 161.84,103.5 161.56,103.5 161.33,103.27 161.33,99.41 v2(161.71,99.03) ; 164.91,117.16 164.97,117.16 v2(166.3,118.49)
  IN1 w0.152: 164.91,117.16 164.83,117.09 164.07,117.09 161.17,114.19 161.17,109.44 161.68,108.93 161.68,106.39 162.04,106.04
  BOTTOM w0.185: UV7.U2 165.9,118.88 v2(166.3,118.49) ; UV1.AF29 v2(161.71,99.03)
FBA_D34: length 23.8
  IN1 w0.102: 160.21,102.02 160.21,101.95 160.45,101.71 160.45,99.41 v2(160.06,99.03)
  IN1 w0.152: v2(163.9,119.29) 162.32,117.71 162.32,117.71 159.5,114.89 159.5,110.59 159.5,109.2 159.5,108.74 159.55,108.69 159.55,105.68 160.03,105.2 160.03,102.2 160.21,102.02
  BOTTOM w0.185: UV7.T4 164.29,119.69 v2(163.9,119.29) ; UV1.AG29 v2(160.06,99.03)
FBA_D35: length 26.2
  IN1 w0.102: 164.47,118.08 164.88,118.08 165.11,118.31 165.11,118.9 v2(165.5,119.29) ; v2(161.71,98.21) 161.13,98.79 161.13,104.56 161.59,105.02 161.87,105.02 162.1,105.25 162.1,105.57 161.87,105.79
  IN1 w0.152: 164.47,118.08 164.29,118.08 164.13,117.93 164.12,117.93 160.61,114.42 160.61,109.67 160.61,109.67 160.61,109.2 161.07,108.75 161.07,106.34 161.57,105.85 161.82,105.85 161.87,105.79
  BOTTOM w0.185: v2(165.5,119.29) 165.89,119.69 UV7.T2 ; UV1.AF28 161.69,98.21 v2(161.71,98.21)
FBA_D36: length 29.1
  IN1 w0.102: 163.84,103.75 163.83,103.74 163.83,100.61 163.52,100.29 162.98,100.29 v2(162.56,99.88) ; 167.59,117.16 167.8,117.37 167.8,117.64 168.28,118.12 168.28,120.65 168.05,120.87 167.01,120.87 166.58,121.3 165.08,121.3 v2(164.7,121.69)
  IN1 w0.152: 167.59,117.16 167.59,116.85 163.43,112.69 163.43,106.87 164,106.31 164,103.91 163.84,103.75
  BOTTOM w0.185: UV1.AD30 v2(162.56,99.88) ; UV7.N4 v2(164.7,121.69)
FBA_D37: length 29.7
  IN1 w0.102: 168.41,121.31 168.02,121.71 166.98,121.71 166.6,122.09 UV7.N2 v2(165.5,122.49) ; v2(163.39,99.03) 163.39,99.31 163.78,99.7 163.78,99.99 164.1,100.31 164.35,100.31 164.6,100.55 164.6,101.72 164.58,101.74
  IN1 w0.152: 168.41,121.31 168.51,121.22 168.51,117.69 168.23,117.41 168.23,116.7 164.02,112.49 164.02,107.13 164.61,106.54 164.61,103.29 164.62,103.28 164.62,101.78 164.58,101.74
  BOTTOM w0.185: v2(163.39,99.03) 163.39,99.06 UV1.AD29 ; UV7.N2 v2(165.5,122.49)
FBA_D38: length 32.2
  IN1 w0.102: 165.57,101 165.46,100.89 165.46,99.74 165.18,99.46 164.89,99.46 164.46,99.03 v2(164.22,99.03) ; v2(164.7,122.49) 165.11,122.9 166.61,122.9 166.98,123.27 168.13,123.27 168.26,123.14
  IN1 w0.152: 165.57,101 165.73,101.15 165.73,103.5 165.72,103.5 165.72,105.72 165.82,105.82 165.82,112.71 169.45,116.33 169.45,121.95 168.26,123.14
  BOTTOM w0.185: UV1.AC29 v2(164.22,99.03) ; UV7.M4 v2(164.7,122.49)
FBA_D39: length 30.6
  IN1 w0.102: v2(163.39,98.21) 163.79,98.61 163.79,99.15 164.09,99.45 164.32,99.45 164.64,99.77 164.64,100.09 165.14,100.59 165.14,100.97 165.37,101.2 ; v2(166.3,122.49) 168.04,122.49 168.41,122.12
  IN1 w0.152: 168.41,122.12 168.89,121.65 168.89,116.57 164.6,112.28 164.6,107.38 165.17,106.82 165.17,101.98 165.47,101.68 165.47,101.3 165.37,101.2
  BOTTOM w0.185: UV1.AD28 v2(163.39,98.21) ; UV7.M2 v2(166.3,122.49)
FBA_D40: length 23.3
  IN1 w0.102: v2(159.19,99.88) 159.62,100.31 159.62,102.47 159.36,102.73 159.06,102.73 158.83,102.95 158.83,103.41 158.04,104.21 158.04,106.33 157.95,106.42
  IN1 w0.152: v2(159.1,118.49) 159.1,118.03 155.53,114.47 155.53,108.99 157.94,106.58 157.94,106.42 157.95,106.42
  BOTTOM w0.185: UV7.U11 158.7,118.89 v2(159.1,118.49) ; v2(159.19,99.88) 159.16,99.88 UV1.AJ29
FBA_D41: length 23.6
  IN1 w0.102: 156.69,106.25 157.44,105.51 157.44,103.91 157.77,103.58 157.77,101.41 158.06,101.12 158.06,100.55 158.34,100.27 158.47,100.27 158.7,100.04 158.7,99.36 v2(158.31,98.98)
  IN1 w0.152: 156.69,106.25 154.42,108.53 154.42,115.05 156.7,117.33 v2(156.7,118.49)
  BOTTOM w0.185: v2(156.7,118.49) 157.09,118.89 UV7.U13 ; UV1.AK29 v2(158.31,98.98)
FBA_D42: length 22.9
  IN1 w0.102: 157.32,106.42 157.74,106 157.74,104.01 157.99,103.76 157.99,102.17 158.26,101.89 158.54,101.89 158.77,101.67 158.77,101.04 v2(158.44,100.71) ; 157.87,118.1 157.88,118.11 157.88,118.87 v2(158.3,119.29)
  IN1 w0.152: 157.32,106.42 154.98,108.76 154.98,114.8 157.87,117.69 157.87,118.1
  BOTTOM w0.185: UV1.AJ30 158.44,100.66 v2(158.44,100.71) ; UV7.T11 158.69,119.69 v2(158.3,119.29)
FBA_D43: length 24.7
  IN1 w0.102: v2(157.49,98.98) 157.87,99.36 157.87,100.45 157.86,100.47 157.86,101 157.54,101.31 157.54,103.41 157.14,103.81 157.14,105.42 156.87,105.69 156.47,105.69 156.3,105.86
  IN1 w0.152: 156.3,105.86 153.86,108.3 153.86,115.28 156.14,117.56 156.14,118.73 v2(156.7,119.29)
  BOTTOM w0.185: UV7.T13 157.09,119.69 v2(156.7,119.29) ; UV1.AK28 157.49,98.96 v2(157.49,98.98)
FBA_D44: length 30.9
  IN1 w0.102: v2(158.3,121.69) 157.92,122.07 156.38,122.07 156.01,121.71 154.92,121.71 ; 153.93,102.93 154.13,102.73 154.42,102.73 154.68,102.47 154.68,102.18 154.96,101.89 155.22,101.89 155.51,101.6 155.51,101.33 155.78,101.06 156,101.06 156.27,100.79 156.27,100.19 v2(155.89,99.81)
  IN1 w0.152: 153.93,102.93 153.86,103 153.86,104.79 151.62,107.03 151.62,118.82 154.51,121.71 154.92,121.71
  BOTTOM w0.185: UV1.AM29 v2(155.89,99.81) ; UV7.N11 158.69,122.09 v2(158.3,121.69)
FBA_D45: length 26.2
  IN1 w0.102: v2(157.5,121.69) 157.11,121.3 156.41,121.3 156,120.89 154.82,120.89 ; 154.69,104.89 154.69,103.41 155.51,102.59 155.51,102.07 155.89,101.69 v2(155.89,101.48)
  IN1 w0.152: 154.69,104.89 152.18,107.4 152.18,118.25 154.82,120.89
  BOTTOM w0.185: v2(157.5,121.69) 157.1,122.09 UV7.N13 ; v2(155.89,101.48) 155.89,101.46 UV1.AM31
FBA_D46: length 33.3
  IN1 w0.102: v2(155.09,98.98) 154.69,99.38 154.69,100.77 154.41,101.05 154.19,101.05 154.18,101.05 154.11,101.05 153.93,101.23 ; 154.82,123.27 156.01,123.27 156.4,122.89 157.9,122.89 v2(158.3,122.49)
  IN1 w0.152: 154.82,123.27 154.4,123.27 150.5,119.37 150.5,106.47 152.41,104.56 152.41,102.82 153.86,101.38 153.86,101.3 153.93,101.23
  BOTTOM w0.185: v2(155.09,98.98) 155.09,99.01 UV1.AN29 ; UV7.M11 v2(158.3,122.49)
FBA_D47: length 29.1
  IN1 w0.102: v2(155.89,100.63) 155.67,100.63 155.22,101.08 154.95,101.08 154.7,101.34 154.7,101.62 154.39,101.92 154.11,101.92 153.93,102.1 ; v2(156.7,122.49) 154.82,122.49
  IN1 w0.152: 154.82,122.49 154.5,122.49 151.06,119.05 151.06,106.8 153.02,104.84 153.02,103.01 153.93,102.1
  BOTTOM w0.185: UV7.M13 v2(156.7,122.49) ; v2(155.89,100.63) 155.89,100.61 UV1.AM30
FBA_D48: length 40.1
  IN4 w0.113: 154.67,132.1 156.12,132.1 156.5,132.48 157.11,132.48 157.89,131.69 v2(158.3,131.29)
  IN4 w0.152: 154.67,132.1 151.95,129.38 151.95,110.1 153.12,108.93 153.12,106.24 153.12,102.09 153.69,101.52 v2(153.69,100.63)
  BOTTOM w0.185: UV1.AN31 154.11,101.06 v2(153.69,100.63) ; UV7.A11 v2(158.3,131.29)
FBA_D49: length 35.5
  IN4 w0.102: 153.88,130.21 154.98,131.31 155.92,131.31 v2(156.7,132.09) ; v2(155.09,101.48) 154.66,101.91 154.09,101.91 154.01,101.99
  IN4 w0.152: 153.88,130.21 152.51,128.84 152.51,110.34 153.68,109.17 153.68,106.47 153.68,102.32 153.85,102.15 154.01,101.99
  BOTTOM w0.185: UV7.A13 v2(156.7,132.09) ; v2(155.09,101.48) 155.09,101.51 UV1.AN32
FBA_D50: length 42.4
  IN4 w0.152: v2(159.1,131.29) 157.43,132.96 154.59,132.96 151.34,129.71 151.34,109.54 152.56,108.32 152.56,101.06 153.79,99.83 v2(154.29,99.83)
  BOTTOM w0.185: UV7.B11 158.7,130.89 v2(159.1,131.29) ; UV1.AP30 154.58,100.21 154.29,99.91 v2(154.29,99.83)
FBA_D51: length 33.5
  IN4 w0.102: 154.43,129.96 154.98,130.51 155.91,130.51 v2(156.7,131.29)
  IN4 w0.152: 154.43,129.96 153.11,128.65 153.11,110.53 154.24,109.41 154.24,106.7 154.24,106.7 154.24,105.31 154.24,105.31 154.24,104.66 v2(154.29,104.61)
  BOTTOM w0.102: UV1.AP32 153.99,101.91
  BOTTOM w0.185: 153.99,101.91 153.74,102.16 153.74,104.06 v2(154.29,104.61) ; UV7.B13 v2(156.7,131.29)
FBA_D52: length 30.2
  IN4 w0.102: v2(158.3,128.89) 157.92,129.27 157.26,129.27 157.08,129.1 157.08,128.72 156.85,128.49 156.32,128.49 156.14,128.31
  IN4 w0.152: v2(155.89,104.61) 155.89,105.37 156.02,105.5 156.02,110.61 154.98,111.65 154.98,116.58 156.14,117.74 156.14,128.31
  BOTTOM w0.185: v2(155.89,104.61) 155.89,103.11 UV1.AM33 ; UV7.E11 v2(158.3,128.89)
FBA_D53: length 31.2
  IN4 w0.102: 158.58,126.89 158.1,126.89 157.9,127.09 157.9,127.65 157.5,128.05 v2(157.5,128.09) ; v2(156.69,101.51) 156.33,101.86 156.33,104.93
  IN4 w0.152: 158.58,126.89 159.5,125.97 159.5,117.81 155.53,113.84 155.53,111.98 156.58,110.94 156.58,105.74 156.31,105.48 156.31,104.96 156.33,104.93
  BOTTOM w0.185: UV1.AL31 156.92,101.28 v2(156.69,101.51) ; UV7.E13 v2(157.5,128.09)
FBA_D54: length 28.8
  IN4 w0.152: v2(156.71,105.31) 156.98,105.31 157.59,105.91 157.59,115 160.42,117.83 160.42,124.15 160.97,124.7 160.97,126.08 160.33,126.71 159.67,126.71 v2(159.1,127.29)
  BOTTOM w0.185: v2(156.71,105.31) 157.54,104.48 157.54,103.41 157.99,102.96 UV1.AK33 ; UV7.F11 v2(159.1,127.29)
FBA_D55: length 34.6
  IN4 w0.102: 160.33,128.26 160.11,128.49 157.34,128.49 157.08,128.23 157.08,127.68 v2(156.7,127.29)
  IN4 w0.152: 160.33,128.26 161.66,126.94 161.66,123.05 161.25,122.65 161.25,117.59 158.23,114.57 158.23,105.42 v2(156.71,103.91)
  BOTTOM w0.185: UV7.F13 v2(156.7,127.29) ; UV1.AK32 157.54,102.36 157.54,102.91 157.14,103.31 157.14,103.48 v2(156.71,103.91)
FBA_D56: length 35.9
  IN4 w0.102: 168.3,130.5 166.99,130.5 166.58,130.9 165.34,130.9 165.11,131.14 165.11,131.68 v2(164.7,132.09)
  IN4 w0.152: v2(162.56,104.61) 163.03,104.61 164.61,106.18 164.61,109.08 166.33,110.8 166.33,113.66 169.45,116.78 169.45,129.35 168.3,130.5
  BOTTOM w0.185: v2(164.7,132.09) 164.3,131.69 UV7.A4 ; UV1.AD34 162.99,104.18 v2(162.56,104.61)
FBA_D57: length 38.3
  IN4 w0.102: v2(162.56,101.51) 162.56,101.76 163.8,102.99 163.8,103.53 ; v2(166.3,132.09) 168.77,132.09 168.92,131.94
  IN4 w0.152: 163.8,103.53 165.72,105.46 165.72,105.72 167.88,107.88 167.88,113.48 170.57,116.17 170.57,130.29 168.92,131.94
  BOTTOM w0.185: v2(162.56,101.51) 162.96,101.91 UV1.AD32 ; v2(166.3,132.09) 165.9,131.69 UV7.A2
FBA_D58: length 45.3
  IN4 w0.102: 168.92,132.71 168.79,132.71 168.6,132.9 164.97,132.9 164.3,132.23 164.3,131.69 v2(163.9,131.29) ; 164.86,102.23 164.56,101.93 163.27,101.93 163.01,101.67 163.01,100.29 v2(163.39,99.91)
  IN4 w0.152: 168.92,132.71 169.11,132.71 171.13,130.69 171.13,115.94 168.48,113.29 168.48,107.69 166.28,105.49 166.28,103.65 164.86,102.23
  BOTTOM w0.185: UV1.AC30 v2(163.39,99.91) ; UV7.B4 164.3,130.89 v2(163.9,131.29)
FBA_D59: length 36.4
  IN4 w0.102: 168.92,130.88 168.52,131.28 166.95,131.28 166.57,131.67 165.88,131.67 v2(165.5,131.29)
  IN4 w0.152: 168.92,130.88 170.01,129.79 170.01,116.48 167.18,113.65 167.18,107.97 165.17,105.95 165.17,105.71 v2(162.56,103.11)
  BOTTOM w0.185: v2(162.56,103.11) 162.59,103.11 UV1.AD33 ; v2(165.5,131.29) 165.9,130.89 UV7.B2
FBA_D60: length 35.2
  IN4 w0.102: v2(164.7,128.89) 165.11,128.47 165.65,128.47 165.88,128.25 165.88,118.18 165.59,117.9
  IN4 w0.152: 165.59,117.9 161.69,113.99 161.69,106.55 161.17,106.04 160.94,106.04 160.72,105.81 160.72,104.13 161.28,103.56 161.28,100.31 v2(161.71,99.88)
  BOTTOM w0.185: v2(164.7,128.89) 164.3,128.49 UV7.E4 ; v2(161.71,99.88) 161.06,99.88 160.89,100.05 160.89,100.71 UV1.AF31
FBA_D61: length 27.4
  IN4 w0.102: v2(165.5,128.09) 165.1,127.69 165.1,118.23
  IN4 w0.152: v2(160.57,106.46) 160.8,106.46 161.13,106.79 161.13,114.26 165.1,118.23
  BOTTOM w0.185: v2(165.5,128.09) 165.9,128.49 UV7.E2 ; UV1.AG34 160.49,106.39 v2(160.57,106.46)
FBA_D62: length 28.4
  IN4 w0.102: 164.27,118.23 164.28,118.24 164.28,125.84 163.9,126.23 v2(163.9,127.29)
  IN4 w0.152: v2(160.56,107.69) 160.54,107.71 160.54,114.5 164.27,118.23
  BOTTOM w0.185: v2(163.9,127.29) 164.3,127.69 UV7.F4 ; UV1.AG32 160.04,102.36 160.04,105.64 159.78,105.91 159.78,107.03 v4(159.89,107.14) 160.44,107.69 v2(160.56,107.69)
FBA_D63: length 28
  IN4 w0.102: 162,105.78 162,105.69 v2(161.71,105.41)
  IN4 w0.152: 162,105.78 162,105.95 162.85,106.8 162.85,112.69 166.81,116.65 166.81,126.77 v2(166.3,127.29)
  BOTTOM w0.185: v2(161.71,105.41) 160.89,104.58 160.89,103.11 UV1.AG33 ; UV7.F2 v2(166.3,127.29)
FBA_DBI0#: length 24.8
  IN1 w0.102: v2(176,120.89) 175.4,120.29 175.4,118.15 175.1,117.85 175.09,117.85 ; 171.29,102.48 171.29,101.39 171.58,101.11 171.85,101.11 172.1,100.87 172.1,100.26 v2(171.71,99.88)
  IN1 w0.152: 171.29,102.48 171.28,102.49 171.28,105.6 171.49,105.81 171.49,110.51 175.09,114.11 175.09,117.85
  BOTTOM w0.185: UV1.P30 v2(171.71,99.88) ; v2(176,120.89) 176.4,121.29 UV6.D2
FBA_DBI1#: length 29.2
  IN1 w0.102: 180.7,105.82 180.42,105.54 180.24,105.36 178.5,105.36 177.96,104.82 177.96,102.16 177.7,101.91 177.7,101.65 v2(177.57,101.51) ; v2(185.6,120.89) 186.4,120.09 187.34,120.09 187.65,119.78
  IN1 w0.152: 180.7,105.82 182.5,107.62 183.85,107.62 189.21,112.97 189.21,118.22 187.65,119.78
  BOTTOM w0.185: UV6.D13 v2(185.6,120.89) ; v2(177.57,101.51) 177.97,101.11 UV1.F31
FBA_DBI2#: length 32.2
  IN4 w0.102: v2(185.6,128.89) 185.66,128.89 186.44,128.11 187.32,128.11 187.61,127.81 187.61,127.08
  IN4 w0.152: v2(178.39,104.71) 179.06,105.38 179.06,105.44 188.72,115.1 188.72,125.97 187.61,127.08
  BOTTOM w0.102: v2(178.39,104.71) 177.99,104.31 177.99,103.51 UV1.F34
  BOTTOM w0.185: UV6.P13 185.6,128.89 v2(185.6,128.89)
FBA_DBI3#: length 30.8
  IN4 w0.102: v2(172.57,102.31) 172.95,102.69 172.95,105.1 172.11,105.94
  IN4 w0.152: v2(176,129.69) 175.52,129.21 175.52,116.42 175.19,116.09 175.19,111.47 171.98,108.26 171.98,106.07 172.11,105.94
  BOTTOM w0.185: UV1.M32 172.96,101.91 v2(172.57,102.31) ; UV6.P2 v2(176,129.69)
FBA_DBI4#: length 24.5
  IN1 w0.102: v2(162.56,100.71) 162.99,101.13 162.99,101.81 163.2,102.02 163.2,103.75 ; v2(165.5,120.89) 165.92,120.47 166.45,120.47 166.88,120.04 166.88,117.24 166.8,117.16
  IN1 w0.152: 163.2,103.75 163.2,103.89 163.28,103.97 163.28,103.98 163.44,104.14 163.44,106.03 162.87,106.59 162.87,112.93 166.8,116.85 166.8,117.16
  BOTTOM w0.185: UV7.P2 165.89,121.29 v2(165.5,120.89) ; v2(162.56,100.71) 162.59,100.71 UV1.AD31
FBA_DBI5#: length 26.5
  IN1 w0.102: 155.48,104.89 155.48,103.56 156.3,102.75 156.3,101.36 156.55,101.11 156.75,101.11 157.07,100.79 157.07,100.19 v2(156.69,99.81) ; v2(156.7,120.89) 155.89,120.08 154.82,120.08
  IN1 w0.152: 155.48,104.89 152.74,107.64 152.74,118 154.82,120.08
  BOTTOM w0.185: UV7.P13 157.09,121.29 v2(156.7,120.89) ; UV1.AL29 v2(156.69,99.81)
FBA_DBI6#: length 30.6
  IN4 w0.102: v2(155.89,102.31) 155.89,103.32 155.47,103.74 155.47,105.13 155.46,105.15 ; v2(156.7,129.69) 156.63,129.69 155.85,128.91 154.98,128.91 154.51,128.44
  IN4 w0.152: 155.46,105.15 155.46,110.29 154.42,111.33 154.42,128.35 154.51,128.44
  BOTTOM w0.185: UV1.AM32 v2(155.89,102.31) ; UV7.D13 v2(156.7,129.69)
FBA_DBI7#: length 31.3
  IN4 w0.102: 162.57,105.73 162.57,105.72 161.83,104.99 161.56,104.99 161.33,104.77 161.33,104.29 v2(161.71,103.91) ; v2(166.3,128.89) 168.09,128.89 168.34,128.64
  IN4 w0.152: 162.57,105.73 163.41,106.56 163.41,112.33 168.34,117.26 168.34,128.64
  BOTTOM w0.185: UV1.AF34 161.47,103.68 161.49,103.68 v2(161.71,103.91) ; UV7.D2 v2(166.3,128.89)
FBA_EDC0: length 23
  IN1 w0.102: 175.64,117.85 175.62,117.87 175.62,119.45 175.85,119.68 176.39,119.68 v2(176.8,120.09) ; 172.15,102.78 172.15,101.13 v2(172.57,100.71)
  IN1 w0.152: 172.15,102.78 172.15,105.5 172.07,105.58 172.07,110.1 175.64,113.67 175.64,117.85
  BOTTOM w0.185: v2(176.8,120.09) 176.4,120.49 UV6.C2 ; v2(172.57,100.71) 172.97,101.11 UV1.M31
FBA_EDC1: length 29.4
  IN1 w0.102: 185.81,119.71 185.18,119.71 v2(184.8,120.09) ; 180.3,106.21 179.7,105.61 178.46,105.61 177.17,104.32 177.17,101.17 v2(176.71,100.71)
  IN1 w0.152: 185.81,119.71 186.17,119.35 186.17,118.11 187.22,117.06 187.92,117.06 188.65,116.33 188.65,113.2 183.62,108.18 182.27,108.18 180.3,106.21
  BOTTOM w0.185: v2(176.71,100.71) 176.74,100.71 UV1.G31 ; UV6.C13 184.8,120.09 v2(184.8,120.09)
FBA_EDC2: length 35.3
  IN4 w0.102: v2(184.8,129.69) 185.18,129.31 185.87,129.31 186.31,128.87 187.61,128.87
  IN4 w0.152: 187.61,128.87 188.36,128.12 188.36,127.12 189.73,125.75 189.73,115.32 179.62,105.21 179.62,104.49 v2(179.19,104.06)
  BOTTOM w0.185: UV1.E33 179.19,103.11 v2(179.19,104.06) ; v2(184.8,129.69) 185.2,130.09 UV6.R13
FBA_EDC3: length 32.3
  IN4 w0.102: v2(176.8,130.49) 176.38,130.07 175.68,130.07 175.29,129.68 174.23,129.68 173.95,129.4 173.95,128.39 ; v2(172.57,103.11) 172.14,103.53 172.14,105.22 171.82,105.54 171.72,105.54
  IN4 w0.152: 171.72,105.54 171.42,105.84 171.42,112 173.95,114.53 173.95,128.39
  BOTTOM w0.185: v2(176.8,130.49) 176.4,130.09 UV6.R2 ; v2(172.57,103.11) 172.97,102.71 UV1.M33
FBA_EDC4: length 23.7
  IN1 w0.102: v2(161.71,101.51) 162.12,101.91 162.12,102.4 162.43,102.71 162.7,102.71 162.95,102.95 162.95,105.61 ; v2(166.3,120.09) 166.68,119.71 166.68,117.83 166.01,117.16
  IN1 w0.152: 166.01,117.16 165.25,116.4 164.17,116.4 161.73,113.96 161.73,109.67 162.24,109.16 162.24,106.31 162.95,105.61
  BOTTOM w0.185: UV1.AE31 162.11,101.11 v2(161.71,101.51) ; UV7.R2 v2(166.3,120.09)
FBA_EDC5: length 25.2
  IN1 w0.102: 154.82,119.23 154.9,119.31 155.91,119.31 156.31,119.7 157.11,119.7 v2(157.5,120.09) ; v2(157.47,100.7) 157.49,100.71 157.49,100.86 157.14,101.21 157.14,103.22 156.84,103.52 156.57,103.52 156.28,103.8 156.28,104.96
  IN1 w0.152: 156.28,104.96 153.3,107.94 153.3,117.7 154.82,119.23
  BOTTOM w0.185: v2(157.47,100.7) 157.87,100.31 UV1.AK30 ; v2(157.5,120.09) 157.1,120.49 UV7.R13
FBA_EDC6: length 32.6
  IN4 w0.102: v2(154.29,103.16) 154.71,103.58 154.71,104.77 154.8,104.85 154.8,105.08 154.8,105.08 154.8,105.37 ; v2(157.5,130.49) 157.11,130.11 156.4,130.11 155.96,129.67 154.94,129.67 154.31,129.04
  IN4 w0.152: 154.31,129.04 153.67,128.41 153.67,111.02 154.8,109.9 154.8,109.64 154.8,106.94 154.8,105.37
  BOTTOM w0.185: UV7.C13 157.1,130.09 v2(157.5,130.49) ; v2(154.29,103.16) 155.04,103.16 UV1.AN33
FBA_EDC7: length 34.2
  IN4 w0.102: v2(166.3,130.49) 167.08,129.71 168.02,129.71 168.89,128.83 ; 162.37,105.17 162.14,104.94 162.14,102.73 v2(161.71,102.31)
  IN4 w0.152: 168.89,128.83 168.89,117.02 164.01,112.13 164.01,106.38 162.8,105.17 162.37,105.17
  BOTTOM w0.185: UV1.AF33 161.69,102.31 v2(161.71,102.31) ; UV7.C2 165.9,130.09 v2(166.3,130.49)
FBA_MA0_MA10_H: length 30.8
  TOP w0.102: v2(165.89,99.88) 166.33,100.33 166.33,105.47 166.63,105.77 166.63,106.44 ; v2(163.9,124.89) 163.88,124.87 162.84,124.87 162.52,124.55 162.52,122.53 162.94,122.11 164.82,122.11 165.08,121.84 165.08,118.23
  TOP w0.185: 166.63,106.44 166.63,109.03 165.81,109.85 165.66,109.85 164.79,110.72 v4(164.79,114.43) 164.79,117.68 165.08,117.97 165.08,118.23
  BOTTOM w0.185: UV1.Y30 166.29,100.28 v2(165.89,99.88) ; UV7.K4 164.3,124.49 v2(163.9,124.89)
FBA_MA0_MA10_L: length 35.2
  TOP w0.102: 168.31,109.72 167.52,108.93 167.52,103.04 167.14,102.66 167.14,101.96 166.98,101.8 166.98,99.62 v2(167.56,99.03) ; v2(178.4,124.09) 178.3,124.09 177.89,123.67 177.44,123.67 177.18,123.41 177.18,117.82 177.08,117.72
  TOP w0.185: 168.31,109.72 168.31,110.29 173.07,115.05 v4(173.47,115.05) 174.76,115.05 177.08,117.37 177.08,117.72
  BOTTOM w0.185: UV6.H4 v2(178.4,124.09) ; UV1.V30 167.7,100.31 167.53,100.47 167.3,100.7 167.14,100.7 167.14,100.71 166.99,100.71 166.99,100.7 166.98,100.7 166.75,100.47 166.75,100.46 166.69,100.41 166.69,99.91 v2(167.56,99.03)
FBA_MA1_MA9_H: length 24.9
  TOP w0.102: v2(162.9,124.39) 163.33,124.39 164.31,123.41 164.31,123.13 164.58,122.87 165.65,122.87 165.88,122.65 165.88,118.27 165.83,118.23
  TOP w0.185: 165.83,118.23 165.83,117.7 165.49,117.36 v4(165.49,116.49) 165.49,112.56 v2(165.24,112.31)
  BOTTOM w0.185: v2(165.24,112.31) 164.17,111.24 164.17,106.91 164.66,106.42 165.49,105.59 UV1.AA34 ; UV7.K5 163,124.49 v2(162.9,124.39)
FBA_MA1_MA9_L: length 26.4
  TOP w0.102: v2(179.4,124.29) 178.78,123.67 178.24,123.67 178.02,123.45 178.02,118.41 177.98,118.37 177.98,118.33 177.78,118.13 177.78,117.72
  TOP w0.185: v2(174.32,113.96) 174.65,113.96 177.78,117.09 177.78,117.72
  BOTTOM w0.185: UV1.U34 168.79,105.86 169.14,106.21 169.14,108.77 v4(169.93,109.56) v2(174.32,113.96) ; v2(179.4,124.29) 179.2,124.49 UV6.H5
FBA_MA2_BA0_H: length 32.6
  TOP w0.102: 160.17,123.7 160.39,123.92 160.39,124.45 160.17,124.67 159.87,124.67 159.72,124.81 159.65,124.89 v2(159.1,124.89) ; 164.4,107.23 165.65,105.98 165.65,101.07 165.48,100.9 165.48,98.62 v2(165.06,98.21)
  TOP w0.185: 164.4,107.23 162.31,109.31 161.95,109.31 159.03,112.23 159.03,115.86 v4(159.51,116.33) 159.61,116.44 159.61,123.14 160.17,123.7
  BOTTOM w0.185: v2(159.1,124.89) 158.7,124.49 UV7.K11 ; v2(165.06,98.21) 165.09,98.21 UV1.AA28
