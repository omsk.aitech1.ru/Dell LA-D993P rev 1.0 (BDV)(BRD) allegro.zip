# Allegro board LAD993PR10-1110A.brd (continued)
## Library data of the parts (continued)
CL47 CL48 = C_0402: signal model: C_0402_0.1U_0402_10V6K
CLRP1 = SHORTPADS: User Part Number: PART#; room: PCH
CM24 CV598-CV601 = C_0402: room: HDMI
CN1 = C_0603: room: NGFF WLAN
CN2 CN8 CN9 CN20 CN21 = C_0402: room: NGFF WLAN
CS12-CS14 = C_0402: room: HDD
CS15 = C_0603: room: HDD
CT80 CT82-CT85 = C_0402: room: THERMAL
CT81 = C_0201: room: THERMAL
CV50 = C_0805: room: VGA
CV52 CV53 CV70-CV72 CV87-CV90 CV100-CV103 CV112-CV114 CV117-CV119 CV202 CV206-CV212 CV214 CV573 CZ95 LV7 LV13 = C_0402: room: VGA
CV79 CV80 CV83-CV86 CV91-CV97 CV120 CV156 CV213 = C_0603: room: VGA
CV158 CV165-CV167 CV374-CV380 = C_0402: room: VRAM1
CV160-CV164 CV373 = C_0603: room: VRAM1
CV168-CV172 CV381 = C_0603: room: VRAM2
CV173-CV175 CV382-CV388 = C_0402: room: VRAM2
CV177 CV184-CV186 CV390-CV396 = C_0402: room: VRAM3
CV179-CV183 CV389 = C_0603: room: VRAM3
CV187-CV191 CV397 = C_0603: room: VRAM4
CV192-CV194 CV398-CV404 = C_0402: room: VRAM4
CV531-CV548 CV550-CV552 CV557-CV567 = C_0201: room: VGA
CV576 CV579-CV581 CV585-CV592 = C_0402: room: EDP
CV577 CV578 = C_0603: room: EDP
CV582 CV583 CZ43 CZ44 EC5205 EC5206 = C_0402: room: CAMERA
CV584 = C_0603: room: CAMERA
CV597 = C_0603: room: HDMI
CZ4 CZ6 = C_0402: room: 3V_5V_DC_DC
CZ8 CZ9 CZ11 CZ12 = C_0603: room: 3V_5V_DC_DC
CZ28 CZ96 CZ97 = C_0402: room: CPU_DC_DC
CZ41 = C_0402: room: EDP_DC_DC
CZ107 PC1601 PC1602 PC1654 PC1662 = C_0805
D1 = BAT54C-7-F_SOT23-3: room: AUDIO
D2 = BAT54A-7-F_SOT23-3
DA1 = TVNST52302AB0_SOT523-3: room: AUDIO
DA2 DA3 = AZ5125-02SPR7G_SOT23-3: room: AUDIO
DA4 DA5 = AZ5125-02SPR7G_SOT23-3
DA6 = AZ5123-01F-R7GR_DFN1006P2X2
DC2 = BAT54CW-7-F_SOT323-3: room: RTC
DE4 = IP4223CZ6_SO6-6: room: TOUCH PAD
DE7 DE9 DV1 DV9 DV11 DZ1 DZ2 = RB751S40T1G_SOD523-2
DE8 = AZ5125-01HPR7G_SOD523-2: room: EC
DH1 = RB751S40T1G_SOD523-2: room: PCH
DI1 = RB751S40T1G_SOD523-2: room: EDP
DI3 = AZ5125-02SPR7G_SOT23-3: room: EDP
DI7 = AZ1045-04F_DFN2510P10E-10-9: room: USB2
DI8 = AZ5125-02SPR7G_SOT23-3: room: USB2
DI9 = AZ1045-04F_DFN2510P10E-10-9: room: USB1
DI10 = AZ5125-02SPR7G_SOT23-3: room: USB1
DN1 DN2 = RB751S40T1G_SOD523-2: room: NGFF WLAN
DV2 = BAT54CW-7-F_SOT323-3: room: EDP
DV3 = BAT54CW-7-F_SOT323-3: room: EDP_DC_DC
DV4 DV5 = AZ1045-04F_DFN2510P10E-10-9: room: HDMI
DV12 = PESD5V0U2BT_SOT23-3: room: CAMERA
DV13 DV14 = BAT54CW-7-F_SOT323-3
F1 = F_NANOSMDC050F-13P2-2: room: KB
FD1-FD4 = FIDUCIAL_C40M80
H1-H4 = H_3P7
H5 H6 = H_3P2: room: ETY-ROOM
H10-H12 H17 = H_2P8: room: ETY-ROOM
H13 H23 = H_2P5: room: ETY-ROOM
H19 = H_2P8
H20 = H_3P3: room: ETY-ROOM
H40 = H_2P1N: room: ETY-ROOM
H55 = H_2P4X2P1N: room: ETY-ROOM
H56 = H_2P5
H57 = H_3P0
HDA1 = ALC3246-CG_MQFN48_6X6-S: room: AUDIO
HT1 RT1 RT3-RT7 = R_0402: room: THERMAL
JADP10 = ACES_50290-00701-001_7P
JAPS = ACES_50506-01841-P01_18P: room: CPU
JBAT10 = ACES_50288-01171-001_11P-T
JBL1 = E-T_6913K-Y04N-00L_4P: room: KB
JCAM1 = ACES_87212-14G0_14P: room: CAMERA
JDEG1 JLPDE1 = ACES_50506-01041-P01_10P: room: EC
JDIMM1 = DEREN_40-42271-26001RHF_260P-T: room: DIMMA
JDIMM2 = LOTES_ADDR0070-P009A_260P-T: room: DIMMB
JEDP1 = ACES_59003-04006-001_40P: room: EDP
JFAN1 JFAN2 = E-T_3806K-F04N-03R_4P: room: FAN
JHDD1 = ACES_50554-01201-001_12P-T: room: HDD
JHDMI1 = ACON_HMR2E-AK120D_19P: room: HDMI
JHP1 = SINGA_2SJ3108-007111F_6P: room: AUDIO
JIO1 = ACES_88194-3041_30P: room: ETY-ROOM
JKB1 = ACES_50699-03041-P01_30P: room: KB
JLAN = SANTA_130452-0E1_8P: room: LAN
JLED = E-T_6915K-Q04N-00L_4P: room: ETY-ROOM
JNGFF1 = CONCR_213AAAA32FA_67P: room: NGFF WLAN
JNGFF2 = LOTES_APCI0096-P002A_75P: room: NGFF SSD
JPW = ACES_51601-0040M-P01_4P: room: ETY-ROOM
JRTC = ACES_50273-0020N-001_2P-T: room: RTC
JSPK1 = ACES_50224-00601-001_6P: room: AUDIO
JTP = ACES_51524-0080N-001_8P: room: TOUCH PAD
JUART = CVILU_CI1804M1VRA-NH_4P: room: ETY-ROOM
JUSB1 = LOTES_AUSB0015-P002A_9P: room: USB1
JUSB2 = LOTES_AUSB0015-P002A_9P: room: USB2
LA1 = TOKO_DFE252012R-H-1R0M_2P: room: AUDIO
LA2 = TOKO_DFE252012R-H-1R0M_2P
LA19-LA22 = MURAT_BLM15AX700SN1D_2P
LA23-LA26 = MURAT_BLM15PX181SN1D_2P
LED3 LED4 = LED_HT-F196BP5_2P
LH1 LH2 = MURAT_BLM15PX221SN1D_2P: room: PCH
LI1 = INPAQ_MCM1012B900F06BP_4P: room: EDP
LI2 = INPAQ_MCM1012B900F06BP_4P: room: USB1
LI5 = INPAQ_MCM1012B900F06BP_4P: room: USB2
LN1 = INPAQ_MCM1012B900F06BP_4P: room: NGFF WLAN
LV22 = INPAQ_MCM1012B900F06BP_4P: room: CAMERA
LV24-LV27 = INPAQ_HCM1012GH900BP_4P: room: HDMI
PC100-PC108 = C_0402: room: DC_CON
PC109-PC112 = C_0402: room: BAT_CON
PC200 PC202-PC204 = C_0402: room: PROCHOT#
PC301 PC303-PC306 PC310 PC311 PC315 PC318-PC323 = C_0402: room: CHARGER
PC302 PC309 PC312 PC313 = C_0603: room: CHARGER
PC307 PC308 PC314 PC316 PC317 = C_0805: room: CHARGER
PC400 PC418 PC419 PC421 = C_0603: room: 3V_5VP
PC401-PC406 PC408 PC411 PC412 PC416 PC417 PC420 PC422 = C_0402: room: 3V_5VP
PC407 PC409 = C_0805: room: 3V_5VP
PC410 = C_ECST250ADA101MF611: room: 3V_5VP
PC413-PC415 = C_B2: room: 3V_5VP
PC423 = C_B2
PC500 PC501 PC509-PC513 PC515 PC516 = C_0603: room: +1.2V_DDR
PC502-PC508 PC514 PC517 PC518 = C_0402: room: +1.2V_DDR
PC600 PC607-PC610 = C_0603: room: +1VALWP
PC601 PC602 PC606 PC611-PC613 = C_0402: room: +1VALWP
PC603 PC604 = C_0805: room: +1VALWP
PC605 = C_0201: room: +1VALWP
PC700 PC706-PC709 = C_0603: room: VCCIO
PC701 = C_0201: room: VCCIO
PC702 PC705 PC710 PC712 PC713 = C_0402: room: VCCIO
PC703 PC704 = C_0805: room: VCCIO
PC800 PC807-PC810 = C_0603: room: +1.05VSDGPU
PC801 PC802 PC806 PC811-PC813 = C_0402: room: +1.05VSDGPU
PC803 = C_0201: room: +1.05VSDGPU
PC804 PC805 = C_0805: room: +1.05VSDGPU
PC900 PC901 PC906 PC907 PC909 = C_0402: room: +1.35VSDGPU
PC902 PC903 = C_0805: room: +1.35VSDGPU
PC904 PC905 = C_0603: room: +1.35VSDGPU
PC908 = C_D2: room: +1.35VSDGPU
PC910 PC1627-PC1629 PC1708 = C_D2
PC1000 PC1007-PC1010 = C_0603: room: GPU_CORE
PC1001 = C_0201: room: GPU_CORE
PC1002 PC1005 = C_0805: room: GPU_CORE
PC1003 PC1004 PC1006 PC1011-PC1013 = C_0402: room: GPU_CORE
PC1100-PC1102 PC1104-PC1139 = C_0402: room: CPU_CONTROLLER
PC1103 = C_0603: room: CPU_CONTROLLER
PC1200-PC1205 PC1220 PC1261 PC1263-PC1265 PC1269 PC1271 PC1274 PC1276 PC1314 PC1348-PC1354 PC1359-PC1363 PC1366-PC1370 PC1372-PC1380 PC1385 PC1386 PC1389-PC1391 PC1394-PC1396 = C_0603: room: CPU_CAP
PC1207 PC1208 PC1301 PC1307 = C_D2: room: CPU_CAP
PC1221-PC1226 PC1229-PC1233 PC1239-PC1248 PC1320-PC1335 PC1338-PC1342 PC1383 PC1384 = C_0402: room: CPU_CAP
PC1300 PC1303-PC1306 PC1309-PC1312 PC1382 PC1388 PC1393 = C_0805: room: CPU_CAP
PC1397 = C_EEFSS0D221R: room: CPU_CAP
PC1400 PC1401 PC1406-PC1408 PC1410 PC1411 PC1415 PC1416 PC1418 PC1420 PC1423 PC1424 = C_0402: room: CPU_VCORE
PC1402 PC1409 PC1412-PC1414 PC1417 PC1419 PC1425 = C_0603: room: CPU_VCORE
PC1403 = C_ECST250ADA101MF611: room: CPU_VCORE
PC1404 PC1405 PC1421 PC1422 = C_0805: room: CPU_VCORE
PC1500 PC1501 PC1505 PC1506 PC1508 PC1509 PC1513 PC1514 = C_0402: room: CPU_GT
PC1502-PC1504 PC1507 PC1510 PC1515 = C_0603: room: CPU_GT
PC1511 PC1512 = C_0805: room: CPU_GT
PC1516 PC1517 PC1520 = C_0402: room: CPU_SA
PC1518 PC1519 = C_0805: room: CPU_SA
PC1521 PC1522 = C_0603: room: CPU_SA
PC1606 = C_ECST250ADA101MF611
PD100 = AZ5125-01HPR7G_SOD523-2: room: DC_CON
PD101 PD102 = TVNST52302AB0_SOT523-3: room: BAT_CON
PD300 = BAT54CW_SOT323-3: room: CHARGER
PD401 = TVNST52302AB0_SOT523-3: room: 3V_5VP
PH1100-PH1104 PR1100 PR1101 PR1103-PR1106 PR1108-PR1116 PR1118 PR1119 PR1121-PR1147 = R_0402: room: CPU_CONTROLLER
PJ600 = JUMP_43X79: room: +1VALWP
PJ601 = JUMP_43X118: room: +1VALWP
PJ700 = JUMP_43X79-NPM: room: VCCIO
PJ701 = JUMP_43X118: room: VCCIO
PJ800 = JUMP_43X79: room: +1.05VSDGPU
PJ801 = JUMP_43X118: room: +1.05VSDGPU
PJ1000 PJ1001 = JUMP_43X79
PJP15 = JUMP_43X39
PJP35 PJP36 PJP70 = JUMP_43X39-NPM
PJP300 = JUMP_43X79: room: CHARGER
PJP400-PJP402 = JUMP_43X118: room: 3V_5VP
PJP500 = JUMP_43X118: room: +1.2V_DDR
PJP501 = JUMP_43X39: room: +1.2V_DDR
PJP900 = JUMP_43X79: room: +1.35VSDGPU
PJP901 PJP902 = JUMP_43X118: room: +1.35VSDGPU
PJP1302 PJP1303 = JUMP_43X39: room: PCH
PJP1304 = JUMP_43X39: room: RTC
PJP1400 = JUMP_43X118: room: CPU_VCORE
PJP1500 = JUMP_43X118: room: CPU_GT
PJP1501 = JUMP_43X118: room: CPU_SA
PL100-PL105 = TAI-T_HCB2012KF-121T50_2P: room: DC_CON
PL106 = MURAT_BLM15AG102SN1D_2P: room: DC_CON
PL107 PL108 = TAI-T_HCB2012KF-121T50_2P: room: BAT_CON
PL300 PL301 = TAI-T_HCB2012KF-121T50_2P: room: CHARGER
PL302 = CYNTE_PCMB104T-5R6MS_2P: room: CHARGER
PL400 PL401 = TAI-T_HCB2012KF-121T50_2P: room: 3V_5VP
PL402 = CYNTE_PCMB063T-3R3MS_2P: room: 3V_5VP
PL403 = CYNTE_PCMC063T-1R5MN_2P: room: 3V_5VP
PL500 = TAI-T_HCB2012KF-121T50_2P: room: +1.2V_DDR
PL501 = CYNTE_PCMB053T-1R0MS_2P: room: +1.2V_DDR
PL600 = TAI-T_HCB2012KF-121T50_2P: room: +1VALWP
PL601 = CYNTE_PCMB063T-1R0MS_2P: room: +1VALWP
PL700 = TAI-T_HCB2012KF-121T50_2P: room: VCCIO
PL701 = CYNTE_PCMB053T-1R0MS_2P: room: VCCIO
PL800 = TAI-T_HCB2012KF-121T50_2P: room: +1.05VSDGPU
PL801 = CYNTE_PCMB053T-1R0MS_2P: room: +1.05VSDGPU
PL900 = TAI-T_HCB2012KF-121T50_2P: room: +1.35VSDGPU
PL901 = MAG_MMD-06CZ-R82M-V1L_2P: room: +1.35VSDGPU
PL1000 = TAI-T_HCB2012KF-121T50_2P: room: GPU_CORE
PL1001 = CYNTE_PCMB053T-1R0MS_2P: room: GPU_CORE
PL1400 PL1401 = TAI-T_HCB2012KF-121T50_2P: room: CPU_VCORE
PL1402-PL1404 = CYNTE_PCME064T-R22MS0R985_2P: room: CPU_VCORE
PL1500 PL1501 = TAI-T_HCB2012KF-121T50_2P: room: CPU_GT
PL1502 PL1503 = CYNTE_PCME064T-R22MS0R985_2P: room: CPU_GT
PL1504 = TAI-T_HCB2012KF-121T50_2P: room: CPU_SA
PL1505 = MAG_MMD05CZR47M_4P: room: CPU_SA
PL1600 PL1601 PL1700 PL1701 = TAI-T_HCB2012KF-121T50_2P
PL1602 PL1603 PL1702 = MAG_MMD-10DZ-R22MEX2L_2P
PQ100 = FDV301N-G_SOT23-3: room: DC_CON
PQ101 = MMBT3904WH_SOT323-3: room: DC_CON
PQ102 = AON7409_DFN8-5: room: AUDIO
PQ103 = 2N7002DW-7-F_SOT363-6: room: AUDIO
PQ200 PQ203 = 2N7002DW-7-F_SOT363-6: room: PROCHOT#
PQ201 PQ202 = SSM3K7002FU_SC70-3: room: PROCHOT#
PQ300 = SSM3K7002FU_SC70-3: room: CHARGER
PQ301-PQ303 = AON6426_DFN5X6-8-5: room: CHARGER
PQ304 = AON6428L_DFN8-5: room: CHARGER
PQ305 = AON7518_DFN8-5: room: CHARGER
PQ306 = AON6426_DFN5X6-8-5
PQ400 = AON7408L_DFN8-5: room: 3V_5VP
PQ401 PQ1600-PQ1603 PQ1700 PQ1701 = AON6992_DFN5X6D-8-7
PQ402 = AON7506_DFN33-8-5
PQ403 = L2N7002WT1G_SC70-3
PQ900 = AON6992_DFN5X6D-8-7: room: +1.35VSDGPU
PQ901 = RJU003N03_UMT3: room: +1.35VSDGPU
PR100 PR101 PR103-PR105 = R_0402: room: DC_CON
PR102 = R0402_0OHM: room: DC_CON
PR106 PR107 PR110 RA11 RA17 RA22-RA24 RA28 RA30 RA32 RA33 RA35 RA42-RA44 RA46 RA48 RA49 RA51 RA53-RA55 RA57 RA58 RA60-RA67 = R_0402: room: AUDIO
PR108 PR109 PR111 PR112 = R_0402: room: BAT_CON
PR113 RA9 RA12-RA15 RA18 RA19 RA27 RA29 RA31 RA56 = R0402_0OHM: room: AUDIO
PR114 PR115 PR325 PR811 PR909-PR911 PR913 PR1525 PR1526 PR1531 PR1533 PR1600 PR1602 PR1606-PR1609 PR1612 PR1614 PR1615 PR1617 PR1621 PR1623 PR1624 PR1700 PR1701 PR1706-PR1709 PR1712 PR1714-PR1716 PR1719 PR1721 PR1800 PR1803 PR1804 R1 R3-R5 RA70 RA71 RA73 RA74 RA79 RA80 RD62 RE10 RE81-RE84 RE100 RE101 RE108 RE113 RE114 RE118-RE129 RH1 RH90 RH125 RH494-RH497 RH499 RH500 RH504-RH510 RH515-RH517 RI51 RL1 RL42 RM2 RM3 RM517 RM578 RM581-RM595 RM600 RN2-RN4 RV27 RV34 RV37 RV41 RV42 RV55-RV57 RV191 RV192 RV209 RV512-RV515 RV526 RV567 RV570 RV571 RV573-RV582 RV587-RV589 RV591 RV593-RV605 RV607 RV609-RV613 RV615 RV621-RV628 RW3 RW4 RZ33 RZ41 RZ42 RZ73 RZ100 RZ102-RZ105 RZ107-RZ109 = R_0402
PR200-PR203 PR205-PR210 PR212-PR214 = R_0402: room: PROCHOT#
PR204 PR211 PR316 PR900 = R_0402: room: ETY-ROOM
PR215-PR217 PR712 PR908 PR912 PR1530 PR1532 PR1601 PR1603 PR1618-PR1620 PR1702 PR1703 PR1717 PR1720 PR1801 RE106 RE109-RE112 RE116 RH492 RH502 RH503 RH513 RH514 RL2 RL43 RN5 RV399 RV566 RV572 RV583-RV586 RV590 RV592 RV606 RV608 RV614 RV616 RZ106 = R0402_0OHM
PR300 PR301 PR303 PR306 PR307 PR312 PR313 PR317 PR318 PR320 PR322-PR324 PR326 PR329 = R_0402: room: CHARGER
PR302 PR314 = R_1206_4P-D: room: CHARGER
PR304 PR305 PR319 PR321 PR327 PR328 = R0402_0OHM: room: CHARGER
PR308 PR309 PR311 = R_0603: room: CHARGER
PR310 PR315 = R_1206: room: CHARGER
PR400 PR407-PR409 PR416 PR419 = R0402_0OHM: room: 3V_5VP
PR401-PR406 PR410 PR411 PR418 = R_0402: room: 3V_5VP
PR412 PR413 = R_0603: room: 3V_5VP
PR414 PR415 = R_1206: room: 3V_5VP
PR500 PR501 PR503-PR505 PR508 PR510 PR511 = R_0402: room: +1.2V_DDR
PR502 = R_0805: room: +1.2V_DDR
PR506 PR507 PR509 = R0402_0OHM: room: +1.2V_DDR
PR600 = R_1206: room: +1VALWP
PR601 PR603 = R0402_0OHM: room: +1VALWP
PR602 PR604-PR607 = R_0402: room: +1VALWP
PR700 = R_1206: room: VCCIO
PR701 PR705 PR709 PR710 = R0402_0OHM: room: VCCIO
PR703 PR704 PR706-PR708 PR711 = R_0402: room: VCCIO
PR801 PR803 PR806 PR810 = R0402_0OHM: room: +1.05VSDGPU
PR802 = R_1206: room: +1.05VSDGPU
PR804 PR805 PR807-PR809 = R_0402: room: +1.05VSDGPU
PR901 = R_0603: room: +1.35VSDGPU
PR902 PR905-PR907 = R_0402: room: +1.35VSDGPU
PR903 = R0402_0OHM: room: +1.35VSDGPU
PR904 = R_1206: room: +1.35VSDGPU
PR1000 PR1004 PR1007-PR1009 = R_0402: room: GPU_CORE
PR1002 = R_1206: room: GPU_CORE
PR1003 PR1010 PR1011 = R0402_0OHM: room: GPU_CORE
PR1102 PR1107 PR1117 PR1120 = R0402_0OHM: room: CPU_CONTROLLER
PR1400 PR1402 PR1403 PR1409 PR1411-PR1414 PR1416 PR1418 PR1423 PR1425-PR1428 PR1430 PR1432 PR1437 PR1439-PR1441 = R_0402: room: CPU_VCORE
PR1401 PR1404 PR1415 PR1417 PR1429 PR1431 = R0402_0OHM: room: CPU_VCORE
PR1405 PR1410 PR1419 PR1424 PR1433 PR1438 = R_0603: room: CPU_VCORE
PR1406 PR1420 PR1434 = R_1206: room: CPU_VCORE
PR1407 PR1408 PR1421 PR1422 PR1435 PR1436 = R0402_0OHM-NPM: room: CPU_VCORE
PR1500 PR1502 PR1504 PR1510-PR1512 PR1514 PR1516 PR1522 PR1523 = R_0402: room: CPU_GT
PR1501 PR1503 PR1513 PR1515 = R0402_0OHM: room: CPU_GT
PR1505 PR1509 PR1517 PR1521 = R_0603: room: CPU_GT
PR1506 PR1507 PR1519 PR1520 = R0402_0OHM-NPM: room: CPU_GT
PR1508 PR1518 = R_1206: room: CPU_GT
PR1524 = R_1206: room: CPU_SA
PR1527 PR1528 = R_0603: room: CPU_SA
PR1529 = R0402_0OHM: room: CPU_SA
PR1610 PR1613 PR1616 PR1711 PR1713 PR1805 RV199 RV200 = R_0603
PR1611 PR1622 PR1710 = R_1206
PT1400-PT1402 = TPC12: room: CPU_VCORE
PT1500 PT1501 = TPC12: room: CPU_GT
PT1503 T1 T3 T97 TV106 TV107 = TPC12
PU300 = BQ24780RUYR_WQFN28_4X4-S: room: CHARGER
PU400 = TPS51285BRUKR_QFN20_3X3: room: 3V_5VP
PU500 = SY8210AQVC_QFN19_4X3-S: room: +1.2V_DDR
PU600 = SY8286RAC_QFN20_3X3: room: +1VALWP
PU700 = SY8286RAC_QFN20_3X3: room: VCCIO
PU800 = SY8286RAC_QFN20_3X3: room: +1.05VSDGPU
PU900 = TPS51212DSCR_SON10_3X3-S: room: +1.35VSDGPU
PU1000 = SY8286RAC_QFN20_3X3: room: GPU_CORE
PU1100 = ISL95855HRTZTS27_TQFN48_6X6-S: room: CPU_CONTROLLER
PU1400-PU1402 = SIC632CDT1GE3_POWERPAK31_5X5: room: CPU_VCORE
PU1500 PU1501 = SIC632CDT1GE3_POWERPAK31_5X5: room: CPU_GT
PU1503 = SIC531CDT1GE3_POWERPAK22_4X3-S
PU1600 PU1700 = RT8816AGQW_WQFN20_3X3
PU1800 = RT9059GSP_SO8
Q12 Q13 = 2N7002K_SOT23-3
QA1 QV2 QV89 QZ11 = L2N7002WT1G_SC-70-3
QA2 QV11 = SI3457BDV-T1-E3_TSOP6
QE3 QE5 = L2N7002WT1G_SC-70-3: room: KB
QE4 = DMG2301U-7_SOT23-3: room: KB
QE13 = L2N7002WT1G_SC-70-3: room: TOUCH PAD
QE19 = DMN65D8LDW-7_SOT363-6: room: TOUCH PAD
QE20 QE21 QE23 QE24 QH5 QV88 QV90 QV92 QZ10 QZ12 QZ13 = DMN65D8LDW-7_SOT363-6
QH4 = DMN65D8LDW-7_SOT363-6: room: PCH
QT1 QT3 = MMST3904-7-F_SOT323-3: room: THERMAL
QT2 = DMN65D8LDW-7_SOT363-6: room: THERMAL
QV1 QZ6-QZ8 = DMN65D8LDW-7_SOT363-6: room: VGA
QV3 QV10 = 2N7002W-T-R7_SOT323-3
QV20 = 2N7002W-T-R7_SOT323-3: room: VRAM1
QV21 = 2N7002W-T-R7_SOT323-3: room: VRAM3
QV93 = MMST3904-7-F_SOT323-3
QZ9 = DMG2301U-7_SOT23-3: room: CAMERA
R2 RA75 = R_0805
RA1 RA5 = R0402_0OHM: room: AUDIO_DC_DC
RA2 = R_0402: room: AUDIO_DC_DC
RA3 = R0603_0OHM: room: AUDIO_DC_DC
RA7 RA10 = R0805_0OHM: room: AUDIO_DC_DC
RA8 = R0603_0OHM: room: AUDIO
RA16 = R0805_0OHM: room: AUDIO
RA36 RA37 = R_0201: room: AUDIO
RA72 = R_0201
RA76 = R0805_0OHM
RC11 = R_0402: room: RTC
RD7-RD10 = R_0402: room: NGFF SSD
RD31 = R0402_0OHM: room: DIMMA
RD35 RH45 RH206 RH209 RH211 = R_0402: room: DIMMA
RD58 RD59 = R0402_0OHM: room: NGFF SSD
RE1-RE4 = R_0402: room: KB
RE7 RE9 RE87 RZ32 = R_0402: room: TOUCH PAD
RE12 RE15 RE16 RE67 = R0603_0OHM: room: EC
RE13 RE14 RE17 RE20-RE25 RE27-RE31 RE33-RE36 RE38-RE47 RE52 RE53 RE55 RE60 RE63-RE66 = R_0402: room: EC
RE57-RE59 RE61 RE62 RE68 RE73 = R0402_0OHM: room: EC
RE71 RH20 RH24 RH29 RH30 RH33 RH41 RH56-RH61 RH89 RH93 RH95 RH97 RH98 RH100 RH107 RH144 RH145 RH148-RH156 RH158 RH163-RH167 RH183-RH188 RH192 RH197 RH201 RH203 RZ71 = R_0402: room: CPU
RE93 = R0603_0OHM: room: TOUCH PAD
RE104 RE105 RH493 RM22 RM598 RM599 = R0603_0OHM
RH9 RH11 RH47 RH96 RH101 RH103 RH105 RH106 RH114 = R0402_0OHM: room: PCH
RH10 RH13-RH18 RH21-RH23 RH25-RH27 RH62-RH72 RH74 RH77 RH79-RH88 RH91 RH92 RH94 RH102 RH104 RH108-RH113 RH119 RH120 RH126-RH132 RH134 RH135 RH138 RH141-RH143 RH146 RH147 RH159 RH160 RH168 RH179-RH181 RH189 RH191 RH193 RH196 = R_0402: room: PCH
RH28 RH31 RH32 RH34 RH38 RH115 RH118 RH190 RH198 RH202 RH204 = R0402_0OHM: room: CPU
RH46 RH207 RH210 RH212 = R_0402: room: DIMMB
RH121-RH124 RH137 = R0603_0OHM: room: PCH
RI9 RI10 RI30 RI45 RI49 = R_0402: room: USB1
RI37-RI40 = R0402_0OHM: room: USB1
RI41-RI44 = R0402_0OHM: room: USB2
RL19 RL20 RL27 RL30 RL31 RL33 RL39-RL41 = R_0402: room: LAN
RM1 RV554 RV557 RV562 RV565 = R_0402: room: HDMI
RN1 = R_0402: room: NGFF WLAN
RP2 RP3 = RP_0804_8P4R
RP8 RP15 RP22 RP23 = RP_0804_8P4R: room: PCH
RPE2-RPE7 = RP_0804_8P4R: room: EC
RV39 RV49-RV52 RV58 RV60 RV62 RV63 RV66 RV77-RV79 RV95 RV96 RV98 RV99 RV107 RV108 RV110 RV111 RV146-RV150 RV152-RV162 RV532 RV534 RZ8-RZ12 = R_0402: room: VGA
RV40 RV208 = R0402_0OHM: room: VGA
RV116 RV120 RV125-RV127 = R_0402: room: VRAM1
RV117 RV121 = R_0402: room: VRAM2
RV131 RV135 = R_0402: room: VRAM4
RV132 RV136 RV140-RV142 = R_0402: room: VRAM3
RV535-RV537 RV551 = R_0402: room: EDP
RV538-RV544 RV546 RV548 RV549 RV552 = R0402_0OHM: room: EDP
RZ13 = R1206_0OHM: room: 3V_5V_DC_DC
RZ26 = R0603_0OHM: room: EDP
RZ34 = R0805_0OHM: room: HDD
RZ37 = R0603_0OHM: room: CAMERA
RZ38 RZ96 = R_0402: room: CAMERA
RZ40 = R_0402: room: EDP_DC_DC
RZ48 RZ67 = R0603_0OHM: room: CPU
RZ66 = R0603_0OHM: room: CPU_DC_DC
RZ69 = R0805_0OHM: room: VGA
SW5 = SW_SKRBAAE010_4P
T2 T4 T8 T17 T20 T91 T92 T94 T120 T182 T4934 = TPC12: room: PCH
T95 T944 = TPC12: room: LAN
T98-T101 = TPC12: room: VGA
T4931 = TPC12: room: EC
TL2 = MHPC_NS892407_24P: room: LAN
UA1 = G9090-180T11U_SOT23-5: room: AUDIO_DC_DC
UA2 = ALC1302_QFN32_5X5: room: AUDIO
UC1 = 74AUP1G07GW_TSSOP5: room: CPU
UC16 = 74AUP1G07GW_TSSOP5: room: PCH
UE1 = MEC1404-NU-TR_VTQFP128_14X14: room: EC
UE4 = SY6288D20AAC_SOT23-5: room: TOUCH PAD
UE6 = SN74LVC1G06DCKR_SC70-5: room: EC
UH1 = SKL-H_BGA_1440P-T: room: CPU
UH2 = SKY-S-PCH_BGA_837P-T: room: PCH
UH7 UH14 = MC74VHC1G08DFT2G_SC70-5: room: PCH
UH8 = W25Q128FVSIQ_SO8: room: PCH
UL1 = RTL8111H-CG_QFN32_4X4-S: room: LAN
UL2 = SY6288C20AAC_SOT23-5: room: LAN
UM1 = PS8409QFN48GTR2-A0_QFN48_6X6-S: room: HDMI
US1 = TPS2544RTER_WQFN16_3X3-S: room: USB1
US2 = SY6288D20AAC_SOT23-5
UT1 = F75303M_MSOP10
UV1 = N15P-GT_BGA_908P: signal model: AUTOGENERATE_DML_MODEL_G1_G1; room: VGA
UV6 = H5GQ1H24AFR-T2L_BGA_170P: signal model: AUTOGENERATE_DML_MODEL_G1_G1; room: VRAM1
UV7 = H5GQ1H24AFR-T2L_BGA_170P: signal model: AUTOGENERATE_DML_MODEL_G1_G1; room: VRAM2
UV8 = H5GQ1H24AFR-T2L_BGA_170P: signal model: AUTOGENERATE_DML_MODEL_G1_G1; room: VRAM3
UV9 = H5GQ1H24AFR-T2L_BGA_170P: signal model: AUTOGENERATE_DML_MODEL_G1_G1; room: VRAM4
UV14 = MC74VHC1G08DFT2G_SC70-5: room: VGA
UV17 = AP2330W-7_SC59-3: room: HDMI
UV18 UV19 UV21-UV23 = TC7SH08FU_SSOP5
UZ1 = EM5209VF_DFN14_3X2: room: 3V_5V_DC_DC
UZ8 = SY6288C20AAC_SOT23-5: room: EDP_DC_DC
UZ9 = TPS22961DNYR_WSON8: room: CPU
UZ15 = TPS22961DNYR_WSON8: room: CPU_DC_DC
UZ16 = APE8937GN2_DFN8_2X2: room: CPU
UZ17 = APE8937GN2_DFN8_2X2: room: VGA
UZ21 = MC74VHC1G08DFT2G_SC70-5: room: CPU
UZ23 = MC74VHC1G08DFT2G_SC70-5
Y1 = Y_X1A000141000200_2P: room: EC
YH1 = Y_CM31532768DZFT_2P: room: PCH
YH2 = Y_X3G024000DC1H_4P: room: PCH
YL2 = Y_7V25000014_4P: room: LAN
YV1 = Y_7V27000011_4P: room: VGA

## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated)
2N7002DW-7-F_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
2N7002K_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
2N7002W-T-R7_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
74AUP1G07GW_TSSOP5
  oval 0.381x1.346 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.79) 5(0,1.79)
ACES_50224-00601-001_6P
  oval 0.61x1.549 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0)
  rect 1.194x1.803 smd: 7(-1.3,-3.875) 8(6.3,-3.875)
ACES_50273-0020N-001_2P-T
  oval 0.787x1.6 smd: 1(0,0) 2(1.25,0)
  rect 2.108x2.997 smd: 3(-2.55,-2.9) 4(3.8,-2.9)
ACES_50288-01171-001_11P-T
  oval 0.711x3.505 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0) 8(10.5,0) 9(12,0) 10(13.5,0) 11(15,0)
  rect 1.499x2.311 smd: 12(-2.05,-2) 13(17.05,-2)
ACES_50290-00701-001_7P
  rect 0.838x7.01 smd: 1(0,0) 2(1.5,0) 3(3,0) 4(4.5,0) 5(6,0) 6(7.5,0) 7(9,0)
ACES_50506-01041-P01_10P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0)
  rect 0.991x2.007 smd: 11(-2.1,-3.05) 12(6.6,-3.05)
ACES_50506-01841-P01_18P
  oval 0.305x0.889 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0)
  rect 0.991x2.007 smd: 19(-2.1,-3.05) 20(10.6,-3.05)
ACES_50554-01201-001_12P-T
  oval 0.61x1.499 smd: 1(0,0) 2(0.5,3) 3(1,0) 4(1.5,3) 5(2,0) 6(2.5,3) 7(3,0) 8(3.5,3) 9(4,0) 10(4.5,3) 11(5,0) 12(5.5,3)
  rect 0.787x1.499 smd: 13(-1,0) 14(-1,3) 15(6.5,0) 16(6.5,3)
ACES_50699-03041-P01_30P
  oval 0.229x0.787 smd: 1(0,0) 2(0.8,0) 3(1.6,0) 4(2.4,0) 5(3.2,0) 6(4,0) 7(4.8,0) 8(5.6,0) 9(6.4,0) 10(7.2,0) 11(8,0) 12(8.8,0) 13(9.6,0) 14(10.4,0) 15(11.2,0) 16(12,0) 17(12.8,0) 18(13.6,0) 19(14.4,0) 20(15.2,0) 21(16,0) 22(16.8,0) 23(17.6,0) 24(18.4,0) 25(19.2,0) 26(20,0) 27(20.8,0) 28(21.6,0) 29(22.4,0) 30(23.2,0)
  rect 0.559x1.295 smd: 31(-1.475,-3.3) 32(24.675,-3.3)
ACES_51524-0080N-001_8P
  oval 0.61x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0) 5(4,0) 6(5,0) 7(6,0) 8(7,0)
  rect 2.489x2.21 smd: 9(10,-3.05) 10(-3,-3.05)
ACES_51601-0040M-P01_4P
  oval 0.305x0.787 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0)
  rect 0.406x0.787 smd: 5(1.5,-2.5) 6(-4.5,-2.5)
ACES_59003-04006-001_40P
  round 0.889 hole 0.889 unplated: (-20.25,2.125) (0.75,2.125)
  oval 0.254x1.143 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0) 31(-15,0) 32(-15.5,0) 33(-16,0) 34(-16.5,0) 35(-17,0) 36(-17.5,0) 37(-18,0) 38(-18.5,0) 39(-19,0) 40(-19.5,0)
  rect 1.499x2.997 smd: 41(-22,2.125) 42(2.5,2.125)
  rect 2.794x1.499 smd: 43(-15.45,4.175) 44(-4.05,4.175)
ACES_87212-14G0_14P
  oval 0.61x1.549 smd: 1(0,0) 2(-1,0) 3(-2,0) 4(-3,0) 5(-4,0) 6(-5,0) 7(-6,0) 8(-7,0) 9(-8,0) 10(-9,0) 11(-10,0) 12(-11,0) 13(-12,0) 14(-13,0)
  rect 1.194x1.803 smd: 15(1.3,2.525) 16(-14.3,2.525)
ACES_88194-3041_30P
  oval 0.305x0.889 smd: 1(0,0) 2(-0.5,0) 3(-1,0) 4(-1.5,0) 5(-2,0) 6(-2.5,0) 7(-3,0) 8(-3.5,0) 9(-4,0) 10(-4.5,0) 11(-5,0) 12(-5.5,0) 13(-6,0) 14(-6.5,0) 15(-7,0) 16(-7.5,0) 17(-8,0) 18(-8.5,0) 19(-9,0) 20(-9.5,0) 21(-10,0) 22(-10.5,0) 23(-11,0) 24(-11.5,0) 25(-12,0) 26(-12.5,0) 27(-13,0) 28(-13.5,0) 29(-14,0) 30(-14.5,0)
  rect 0.991x1.499 smd: 31(2.1,-3.3) 32(-16.6,-3.3)
ACON_HMR2E-AK120D_19P
  round 0.762 hole 0.508: 1(0,0) 2(0.5,1.2) 3(1,0) 4(1.5,1.2) 5(2,0) 6(2.5,1.2) 7(3,0) 8(3.5,1.2) 9(4,0) 10(4.5,1.2) 11(5,0) 12(5.5,1.2) 13(6,0) 14(6.5,1.2) 15(7,0) 16(7.5,1.2) 17(8,0) 18(8.5,1.2) 19(9,0)
  oval 1.397x2.946 hole 0.787x2.362: 20(-2.75,0.77) 21(11.75,0.77)
  rect 1.549x2.388 smd: 22(-4.125,-6.08) 23(13.125,-6.08)
ALC1302_QFN32_5X5
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(0,-2) 6(0,-2.5) 7(0,-3) 8(0,-3.5) 17(5.1,-3.5) 18(5.1,-3) 19(5.1,-2.5) 20(5.1,-2) 21(5.1,-1.5) 22(5.1,-1) 23(5.1,-0.5) 24(5.1,0)
  oval 0.254x0.889 smd: 9(0.8,-4.3) 10(1.3,-4.3) 11(1.8,-4.3) 12(2.3,-4.3) 13(2.8,-4.3) 14(3.3,-4.3) 15(3.8,-4.3) 16(4.3,-4.3) 25(4.3,0.8) 26(3.8,0.8) 27(3.3,0.8) 28(2.8,0.8) 29(2.3,0.8) 30(1.8,0.8) 31(1.3,0.8) 32(0.8,0.8)
  rect 3.353x3.353 smd: 33(2.55,-1.75)
ALC3246-CG_MQFN48_6X6-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.1,-4.4) 26(6.1,-4) 27(6.1,-3.6) 28(6.1,-3.2) 29(6.1,-2.8) 30(6.1,-2.4) 31(6.1,-2) 32(6.1,-1.6) 33(6.1,-1.2) 34(6.1,-0.8) 35(6.1,-0.4) 36(6.1,0)
  oval 0.203x0.889 smd: 13(0.85,-5.25) 14(1.25,-5.25) 15(1.65,-5.25) 16(2.05,-5.25) 17(2.45,-5.25) 18(2.85,-5.25) 19(3.25,-5.25) 20(3.65,-5.25) 21(4.05,-5.25) 22(4.45,-5.25) 23(4.85,-5.25) 24(5.25,-5.25) 37(5.25,0.85) 38(4.85,0.85) 39(4.45,0.85) 40(4.05,0.85) 41(3.65,0.85) 42(3.25,0.85) 43(2.85,0.85) 44(2.45,0.85) 45(2.05,0.85) 46(1.65,0.85) 47(1.25,0.85) 48(0.85,0.85)
  rect 4.394x4.394 smd: 49(3.05,-2.2)
AON6426_DFN5X6-8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.715)
AON6428L_DFN8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
AON6992_DFN5X6D-8-7
  oval 0.66x0.635 smd: 1(0,0) 3(3.81,5.67) 4(2.54,5.67) 5(1.27,5.67) 6(0,5.67)
  custom 0.485x0.485 smd: 2(1.905,0.655)
  rect 3.988x2.667 smd: 7(1.905,3.62)
AON7408L_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7409_DFN8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7506_DFN33-8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
AON7518_DFN8-5
  oval 0.356x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0)
  custom 0.57x0.57 smd: 5(0.975,1.4)
AP2330W-7_SC59-3
  oval 0.787x0.991 smd: 1(0,0) 2(-0.95,-2.4) 3(0.95,-2.4)
APE8937GN2_DFN8_2X2
  oval 0.254x0.787 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(1.5,2.2) 6(1,2.2) 7(0.5,2.2) 8(0,2.2)
  rect 1.6x0.889 smd: 9(0.75,1.1)
AZ1045-04F_DFN2510P10E-10-9
  oval 0.254x0.686 smd: 1(0,0) 2(0.5,0) 4(1.5,0) 5(2,0) 6(2,0.875) 7(1.5,0.875) 8(0.5,0.875) 9(0,0.875)
  oval 0.381x1.549 smd: 3(1,0.437)
AZ5123-01F-R7GR_DFN1006P2X2
  rect 0.559x0.61 smd: 1(0,0) 2(0.85,0)
AZ5125-01HPR7G_SOD523-2
  rect 0.61x0.787 smd: 1(0,0) 2(1.5,0)
AZ5125-02SPR7G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54A-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54C-7-F_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
BAT54CW-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BAT54CW_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
BQ24780RUYR_WQFN28_4X4-S
  oval 0.889x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 15(4.1,-2.4) 16(4.1,-2) 17(4.1,-1.6) 18(4.1,-1.2) 19(4.1,-0.8) 20(4.1,-0.4) 21(4.1,0)
  oval 0.203x0.889 smd: 8(0.85,-3.25) 9(1.25,-3.25) 10(1.65,-3.25) 11(2.05,-3.25) 12(2.45,-3.25) 13(2.85,-3.25) 14(3.25,-3.25) 22(3.25,0.85) 23(2.85,0.85) 24(2.45,0.85) 25(2.05,0.85) 26(1.65,0.85) 27(1.25,0.85) 28(0.85,0.85)
  rect 2.591x2.591 smd: 29(2.05,-1.2)
C_0201
  rect 0.381x0.356 smd: 1(0,0) 2(0.584,0)
C_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
C_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
C_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
C_1206
  rect 1.016x1.778 smd: 1(0,0) 2(2.667,0)
C_APXK2R5ARA331MF451
  oval 3.15x1.6 smd: 1(0,0) 2(-5.05,0)
C_B2
  rect 1.346x2.692 smd: 1(0,0) 2(-2.75,0)
C_D2
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_ECST250ADA101MF611
  oval 3.505x1.6 smd: 1(0,0) 2(-5.4,0)
C_EEFSS0D221R
  rect 2.388x2.794 smd: 1(0,0) 2(6.4,0)
C_X
  rect 1.803x2.896 smd: 1(0,0) 2(6,0)
CONCR_213AAAA32FA_67P
  round 1.092 hole 1.092 unplated: (-0.75,-5.275)
  round 1.6 hole 1.6 unplated: (19.25,-5.275)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-7.55) 3(0.5,0) 4(0.75,-7.55) 5(1,0) 6(1.25,-7.55) 7(1.5,0) 8(3.75,-7.55) 9(4,0) 10(4.25,-7.55) 11(4.5,0) 12(4.75,-7.55) 13(5,0) 14(5.25,-7.55) 15(5.5,0) 16(5.75,-7.55) 17(6,0) 18(6.25,-7.55) 19(6.5,0) 20(6.75,-7.55) 21(7,0) 22(7.25,-7.55) 23(7.5,0) 24(7.75,-7.55) 25(8,0) 26(8.25,-7.55) 27(8.5,0) 28(8.75,-7.55) 29(9,0) 30(9.25,-7.55) 31(9.5,0) 32(9.75,-7.55) 33(10,0) 34(10.25,-7.55) 35(10.5,0) 36(10.75,-7.55) 37(11,0) 38(11.25,-7.55) 39(11.5,0) 40(11.75,-7.55) 41(12,0) 42(12.25,-7.55) 43(12.5,0) 44(12.75,-7.55) 45(13,0) 46(13.25,-7.55) 47(13.5,0) 48(13.75,-7.55) 49(14,0) 50(14.25,-7.55) 51(14.5,0) 52(14.75,-7.55) 53(15,0) 54(15.25,-7.55) 55(15.5,0) 56(15.75,-7.55) 57(16,0) 58(16.25,-7.55) 59(16.5,0) 60(16.75,-7.55) 61(17,0) 62(17.25,-7.55) 63(17.5,0) 64(17.75,-7.55) 65(18,0) 66(18.25,-7.55) 67(18.5,0)
  rect 1.194x2.743 smd: 68(-1.1,-0.775) 69(19.6,-0.775)
CVILU_CI1804M1VRA-NH_4P
  oval 0.508x0.991 smd: 1(0,-0.05) 2(-0.8,-0.05) 3(-1.6,-0.05) 4(-2.4,-0.05)
  rect 1.194x1.702 smd: 5(-3.7,1.4) 6(1.3,1.4)
CYNTE_PCMB053T-1R0MS_2P
  rect 2.007x2.489 smd: 1(0,0) 2(5,0)
CYNTE_PCMB063T-1R0MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMB063T-3R3MS_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
CYNTE_PCMB104T-5R6MS_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
CYNTE_PCMC063T-1R5MN_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
CYNTE_PCME064T-R22MS0R985_2P
  rect 2.362x3.505 smd: 1(0,0) 2(6.05,0)
DEREN_40-42271-26001RHF_260P-T
  round 1.6 hole 1.6 unplated: (-1.025,4.1)
  round 1.092 hole 1.092 unplated: (67.775,4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(0.25,8.2) 3(0.5,0) 4(0.75,8.2) 5(1,0) 6(1.25,8.2) 7(1.5,0) 8(1.75,8.2) 9(2,0) 10(2.25,8.2) 11(2.5,0) 12(2.75,8.2) 13(3,0) 14(3.25,8.2) 15(3.5,0) 16(3.75,8.2) 17(4,0) 18(4.25,8.2) 19(4.5,0) 20(4.75,8.2) 21(5,0) 22(5.25,8.2) 23(5.5,0) 24(5.75,8.2) 25(6,0) 26(6.25,8.2) 27(6.5,0) 28(6.75,8.2) 29(7,0) 30(7.25,8.2) 31(7.5,0) 32(7.75,8.2) 33(8,0) 34(8.25,8.2) 35(8.5,0) 36(8.75,8.2) 37(9,0) 38(9.25,8.2) 39(9.5,0) 40(9.75,8.2) 41(10,0) 42(10.25,8.2) 43(10.5,0) 44(10.75,8.2) 45(11,0) 46(11.25,8.2) 47(11.5,0) 48(11.75,8.2) 49(12,0) 50(12.25,8.2) 51(12.5,0) 52(12.75,8.2) 53(13,0) 54(13.25,8.2) 55(13.5,0) 56(13.75,8.2) 57(14,0) 58(14.25,8.2) 59(14.5,0) 60(14.75,8.2) 61(15,0) 62(15.25,8.2) 63(15.5,0) 64(15.75,8.2) 65(16,0) 66(16.25,8.2) 67(16.5,0) 68(16.75,8.2) 69(17,0) 70(17.25,8.2) 71(17.5,0) 72(17.75,8.2) 73(18,0) 74(18.25,8.2) 75(18.5,0) 76(18.75,8.2) 77(19,0) 78(19.25,8.2) 79(19.5,0) 80(19.75,8.2) 81(20,0) 82(20.25,8.2) 83(20.5,0) 84(20.75,8.2) 85(21,0) 86(21.25,8.2) 87(21.5,0) 88(21.75,8.2) 89(22,0) 90(22.25,8.2) 91(22.5,0) 92(22.75,8.2) 93(23,0) 94(23.25,8.2) 95(23.5,0) 96(23.75,8.2) 97(24,0) 98(24.25,8.2) 99(24.5,0) 100(24.75,8.2) 101(25,0) 102(25.25,8.2) 103(25.5,0) 104(25.75,8.2) 105(26,0) 106(26.25,8.2) 107(26.5,0) 108(26.75,8.2) 109(27,0) 110(27.25,8.2) 111(27.5,0) 112(27.75,8.2) 113(28,0) 114(28.25,8.2) 115(28.5,0) 116(28.75,8.2) 117(29,0) 118(29.25,8.2) 119(29.5,0) 120(29.75,8.2) 121(30,0) 122(30.25,8.2) 123(30.5,0) 124(30.75,8.2) 125(31,0) 126(31.25,8.2) 127(31.5,0) 128(31.75,8.2) 129(32,0) 130(32.25,8.2) 131(32.5,0) 132(32.75,8.2) 133(33,0) 134(33.25,8.2) 135(33.5,0) 136(33.75,8.2) 137(34,0) 138(34.25,8.2) 139(34.5,0) 140(34.75,8.2) 141(35,0) 142(35.25,8.2) 143(35.5,0) 144(35.75,8.2) 145(38,0) 146(38.25,8.2) 147(38.5,0) 148(38.75,8.2) 149(39,0) 150(39.25,8.2) 151(39.5,0) 152(39.75,8.2) 153(40,0) 154(40.25,8.2) 155(40.5,0) 156(40.75,8.2) 157(41,0) 158(41.25,8.2) 159(41.5,0) 160(41.75,8.2) 161(42,0) 162(42.25,8.2) 163(42.5,0) 164(42.75,8.2) 165(43,0) 166(43.25,8.2) 167(43.5,0) 168(43.75,8.2) 169(44,0) 170(44.25,8.2) 171(44.5,0) 172(44.75,8.2) 173(45,0) 174(45.25,8.2) 175(45.5,0) 176(45.75,8.2) 177(46,0) 178(46.25,8.2) 179(46.5,0) 180(46.75,8.2) 181(47,0) 182(47.25,8.2) 183(47.5,0) 184(47.75,8.2) 185(48,0) 186(48.25,8.2) 187(48.5,0) 188(48.75,8.2) 189(49,0) 190(49.25,8.2) 191(49.5,0) 192(49.75,8.2) 193(50,0) 194(50.25,8.2) 195(50.5,0) 196(50.75,8.2) 197(51,0) 198(51.25,8.2) 199(51.5,0) 200(51.75,8.2) 201(52,0) 202(52.25,8.2) 203(52.5,0) 204(52.75,8.2) 205(53,0) 206(53.25,8.2) 207(53.5,0) 208(53.75,8.2) 209(54,0) 210(54.25,8.2) 211(54.5,0) 212(54.75,8.2) 213(55,0) 214(55.25,8.2) 215(55.5,0) 216(55.75,8.2) 217(56,0) 218(56.25,8.2) 219(56.5,0) 220(56.75,8.2) 221(57,0) 222(57.25,8.2) 223(57.5,0) 224(57.75,8.2) 225(58,0) 226(58.25,8.2) 227(58.5,0) 228(58.75,8.2) 229(59,0) 230(59.25,8.2) 231(59.5,0) 232(59.75,8.2) 233(60,0) 234(60.25,8.2) 235(60.5,0) 236(60.75,8.2) 237(61,0) 238(61.25,8.2) 239(61.5,0) 240(61.75,8.2) 241(62,0) 242(62.25,8.2) 243(62.5,0) 244(62.75,8.2) 245(63,0) 246(63.25,8.2) 247(63.5,0) 248(63.75,8.2) 249(64,0) 250(64.25,8.2) 251(64.5,0) 252(64.75,8.2) 253(65,0) 254(65.25,8.2) 255(65.5,0) 256(65.75,8.2) 257(66,0) 258(66.25,8.2) 259(66.5,0) 260(66.75,8.2)
  rect 3.505x4.597 smd: 261(-0.425,-7.9) 262(67.175,-7.9)
DMG2301U-7_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
DMN65D8LDW-7_SOT363-6
  oval 0.432x0.61 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0.65,1.9) 6(0,1.9)
E-T_3806K-F04N-03R_4P
  oval 0.787x1.905 smd: 1(0,0) 2(1.25,0) 3(2.5,0) 4(3.75,0)
  rect 1.295x3.353 smd: 5(-2.85,-4.875) 6(6.6,-4.875)
E-T_6913K-Y04N-00L_4P
  oval 0.305x1.295 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 1.803x2.21 smd: 5(-2.65,-5.65) 6(5.65,-5.65)
E-T_6915K-Q04N-00L_4P
  oval 0.305x0.889 smd: 1(0,0) 2(1,0) 3(2,0) 4(3,0)
  rect 0.991x2.007 smd: 5(-2.6,-3.05) 6(5.6,-3.05)
EM5209VF_DFN14_3X2
  oval 0.203x0.711 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2) 9(2,2) 10(1.6,2) 11(1.2,2) 12(0.8,2) 13(0.4,2) 14(0,2)
  rect 2.591x0.991 smd: 15(1.2,1)
F75303M_MSOP10
  oval 0.254x1.626 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2,4.3) 7(1.5,4.3) 8(1,4.3) 9(0.5,4.3) 10(0,4.3)
F_NANOSMDC050F-13P2-2
  rect 0.991x1.6 smd: 1(0,0) 2(3,0)
FDV301N-G_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
FIDUCIAL_C40M80
  round 1.016 smd: 1(0,0)
G9090-180T11U_SOT23-5
  oval 0.533x1.194 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,3) 5(0,3)
H5GQ1H24AFR-T2L_BGA_170P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A4(2.4,0) A5(3.2,0) A10(7.201,0) A11(8.001,0) A12(8.801,0) A13(9.601,0) A14(10.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.2,-0.8) B10(7.201,-0.8) B11(8.001,-0.8) B12(8.801,-0.8) B13(9.601,-0.8) B14(10.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.2,-1.6) C10(7.201,-1.6) C11(8.001,-1.6) C12(8.801,-1.6) C13(9.601,-1.6) C14(10.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.2,-2.4) D10(7.201,-2.4) D11(8.001,-2.4) D12(8.801,-2.4) D13(9.601,-2.4) D14(10.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E4(2.4,-3.2) E5(3.2,-3.2) E10(7.201,-3.2) E11(8.001,-3.2) E12(8.801,-3.2) E13(9.601,-3.2) E14(10.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F4(2.4,-4) F5(3.2,-4) F10(7.201,-4) F11(8.001,-4) F12(8.801,-4) F13(9.601,-4) F14(10.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G4(2.4,-4.801) G5(3.2,-4.801) G10(7.201,-4.801) G11(8.001,-4.801) G12(8.801,-4.801) G13(9.601,-4.801) G14(10.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H4(2.4,-5.601) H5(3.2,-5.601) H10(7.201,-5.601) H11(8.001,-5.601) H12(8.801,-5.601) H13(9.601,-5.601) H14(10.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J4(2.4,-6.401) J5(3.2,-6.401) J10(7.201,-6.401) J11(8.001,-6.401) J12(8.801,-6.401) J13(9.601,-6.401) J14(10.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K4(2.4,-7.201) K5(3.2,-7.201) K10(7.201,-7.201) K11(8.001,-7.201) K12(8.801,-7.201) K13(9.601,-7.201) K14(10.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L4(2.4,-8.001) L5(3.2,-8.001) L10(7.201,-8.001) L11(8.001,-8.001) L12(8.801,-8.001) L13(9.601,-8.001) L14(10.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M4(2.4,-8.801) M5(3.2,-8.801) M10(7.201,-8.801) M11(8.001,-8.801) M12(8.801,-8.801) M13(9.601,-8.801) M14(10.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N4(2.4,-9.601) N5(3.2,-9.601) N10(7.201,-9.601) N11(8.001,-9.601) N12(8.801,-9.601) N13(9.601,-9.601) N14(10.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P4(2.4,-10.401) P5(3.2,-10.401) P10(7.201,-10.401) P11(8.001,-10.401) P12(8.801,-10.401) P13(9.601,-10.401) P14(10.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R4(2.4,-11.201) R5(3.2,-11.201) R10(7.201,-11.201) R11(8.001,-11.201) R12(8.801,-11.201) R13(9.601,-11.201) R14(10.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T4(2.4,-12.002) T5(3.2,-12.002) T10(7.201,-12.002) T11(8.001,-12.002) T12(8.801,-12.002) T13(9.601,-12.002) T14(10.401,-12.002) U1(0,-12.802) U2(0.8,-12.802) U3(1.6,-12.802) U4(2.4,-12.802) U5(3.2,-12.802) U10(7.201,-12.802) U11(8.001,-12.802) U12(8.801,-12.802) U13(9.601,-12.802) U14(10.401,-12.802)
H_2P1N
  round 2.108 hole 2.108 unplated: (0,0)
H_2P4X2P1N
  oval 2.388x2.108 hole 2.388x2.108 unplated: (0,0)
H_2P5
  round 2.997 hole 2.489: 1(0,0)
H_2P8
  round 3.302 hole 2.794: 1(0,0)
H_3P0
  round 3.505 hole 2.997: 1(0,0)
H_3P2
  round 3.708 hole 3.2: 1(0,0)
H_3P3
  round 3.81 hole 3.302: 1(0,0)
H_3P7
  round 4.216 hole 3.708: 1(0,0)
INPAQ_HCM1012GH900BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
INPAQ_MCM1012B900F06BP_4P
  rect 0.711x0.305 smd: 1(0,0) 2(1.25,0) 3(1.25,-0.5) 4(0,-0.5)
IP4223CZ6_SO6-6
  oval 0.508x1.422 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.35) 5(0.95,2.35) 6(0,2.35)
ISL95855HRTZTS27_TQFN48_6X6-S
  oval 0.94x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 25(6.05,-4.4) 26(6.05,-4) 27(6.05,-3.6) 28(6.05,-3.2) 29(6.05,-2.8) 30(6.05,-2.4) 31(6.05,-2) 32(6.05,-1.6) 33(6.05,-1.2) 34(6.05,-0.8) 35(6.05,-0.4) 36(6.05,0)
  oval 0.203x0.94 smd: 13(0.825,-5.225) 14(1.225,-5.225) 15(1.625,-5.225) 16(2.025,-5.225) 17(2.425,-5.225) 18(2.825,-5.225) 19(3.225,-5.225) 20(3.625,-5.225) 21(4.025,-5.225) 22(4.425,-5.225) 23(4.825,-5.225) 24(5.225,-5.225) 37(5.225,0.825) 38(4.825,0.825) 39(4.425,0.825) 40(4.025,0.825) 41(3.625,0.825) 42(3.225,0.825) 43(2.825,0.825) 44(2.425,0.825) 45(2.025,0.825) 46(1.625,0.825) 47(1.225,0.825) 48(0.825,0.825)
  rect 4.394x4.394 smd: 49(3.025,-2.2)
JUMP_43X39
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X39-NPM
  custom 0.191x0.191 smd: 1(0,0) 2(0.914,0)
JUMP_43X79
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X79-NPM
  custom 0.188x0.188 smd: 1(0,0) 2(1.1,0)
JUMP_43X118
  custom 0.187x0.187 smd: 1(0,0) 2(1.1,0)
L2N7002WT1G_SC70-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
L2N7002WT1G_SC-70-3
  oval 0.711x0.889 smd: 1(0,0) 2(-0.65,-1.9) 3(0.65,-1.9)
LED_HT-F196BP5_2P
  rect 0.787x0.787 smd: 1(0,0) 2(1.5,0)
LOTES_ADDR0070-P009A_260P-T
  round 1.092 hole 1.092 unplated: (-67.775,-4.1)
  round 1.6 hole 1.6 unplated: (1.025,-4.1)
  oval 0.305x1.753 smd: 1(0,0) 2(-0.25,-8.2) 3(-0.5,0) 4(-0.75,-8.2) 5(-1,0) 6(-1.25,-8.2) 7(-1.5,0) 8(-1.75,-8.2) 9(-2,0) 10(-2.25,-8.2) 11(-2.5,0) 12(-2.75,-8.2) 13(-3,0) 14(-3.25,-8.2) 15(-3.5,0) 16(-3.75,-8.2) 17(-4,0) 18(-4.25,-8.2) 19(-4.5,0) 20(-4.75,-8.2) 21(-5,0) 22(-5.25,-8.2) 23(-5.5,0) 24(-5.75,-8.2) 25(-6,0) 26(-6.25,-8.2) 27(-6.5,0) 28(-6.75,-8.2) 29(-7,0) 30(-7.25,-8.2) 31(-7.5,0) 32(-7.75,-8.2) 33(-8,0) 34(-8.25,-8.2) 35(-8.5,0) 36(-8.75,-8.2) 37(-9,0) 38(-9.25,-8.2) 39(-9.5,0) 40(-9.75,-8.2) 41(-10,0) 42(-10.25,-8.2) 43(-10.5,0) 44(-10.75,-8.2) 45(-11,0) 46(-11.25,-8.2) 47(-11.5,0) 48(-11.75,-8.2) 49(-12,0) 50(-12.25,-8.2) 51(-12.5,0) 52(-12.75,-8.2) 53(-13,0) 54(-13.25,-8.2) 55(-13.5,0) 56(-13.75,-8.2) 57(-14,0) 58(-14.25,-8.2) 59(-14.5,0) 60(-14.75,-8.2) 61(-15,0) 62(-15.25,-8.2) 63(-15.5,0) 64(-15.75,-8.2) 65(-16,0) 66(-16.25,-8.2) 67(-16.5,0) 68(-16.75,-8.2) 69(-17,0) 70(-17.25,-8.2) 71(-17.5,0) 72(-17.75,-8.2) 73(-18,0) 74(-18.25,-8.2) 75(-18.5,0) 76(-18.75,-8.2) 77(-19,0) 78(-19.25,-8.2) 79(-19.5,0) 80(-19.75,-8.2) 81(-20,0) 82(-20.25,-8.2) 83(-20.5,0) 84(-20.75,-8.2) 85(-21,0) 86(-21.25,-8.2) 87(-21.5,0) 88(-21.75,-8.2) 89(-22,0) 90(-22.25,-8.2) 91(-22.5,0) 92(-22.75,-8.2) 93(-23,0) 94(-23.25,-8.2) 95(-23.5,0) 96(-23.75,-8.2) 97(-24,0) 98(-24.25,-8.2) 99(-24.5,0) 100(-24.75,-8.2) 101(-25,0) 102(-25.25,-8.2) 103(-25.5,0) 104(-25.75,-8.2) 105(-26,0) 106(-26.25,-8.2) 107(-26.5,0) 108(-26.75,-8.2) 109(-27,0) 110(-27.25,-8.2) 111(-27.5,0) 112(-27.75,-8.2) 113(-28,0) 114(-28.25,-8.2) 115(-28.5,0) 116(-28.75,-8.2) 117(-29,0) 118(-29.25,-8.2) 119(-29.5,0) 120(-29.75,-8.2) 121(-30,0) 122(-30.25,-8.2) 123(-30.5,0) 124(-30.75,-8.2) 125(-31,0) 126(-31.25,-8.2) 127(-31.5,0) 128(-31.75,-8.2) 129(-32,0) 130(-32.25,-8.2) 131(-32.5,0) 132(-32.75,-8.2) 133(-33,0) 134(-33.25,-8.2) 135(-33.5,0) 136(-33.75,-8.2) 137(-34,0) 138(-34.25,-8.2) 139(-34.5,0) 140(-34.75,-8.2) 141(-35,0) 142(-35.25,-8.2) 143(-35.5,0) 144(-35.75,-8.2) 145(-38,0) 146(-38.25,-8.2) 147(-38.5,0) 148(-38.75,-8.2) 149(-39,0) 150(-39.25,-8.2) 151(-39.5,0) 152(-39.75,-8.2) 153(-40,0) 154(-40.25,-8.2) 155(-40.5,0) 156(-40.75,-8.2) 157(-41,0) 158(-41.25,-8.2) 159(-41.5,0) 160(-41.75,-8.2) 161(-42,0) 162(-42.25,-8.2) 163(-42.5,0) 164(-42.75,-8.2) 165(-43,0) 166(-43.25,-8.2) 167(-43.5,0) 168(-43.75,-8.2) 169(-44,0) 170(-44.25,-8.2) 171(-44.5,0) 172(-44.75,-8.2) 173(-45,0) 174(-45.25,-8.2) 175(-45.5,0) 176(-45.75,-8.2) 177(-46,0) 178(-46.25,-8.2) 179(-46.5,0) 180(-46.75,-8.2) 181(-47,0) 182(-47.25,-8.2) 183(-47.5,0) 184(-47.75,-8.2) 185(-48,0) 186(-48.25,-8.2) 187(-48.5,0) 188(-48.75,-8.2) 189(-49,0) 190(-49.25,-8.2) 191(-49.5,0) 192(-49.75,-8.2) 193(-50,0) 194(-50.25,-8.2) 195(-50.5,0) 196(-50.75,-8.2) 197(-51,0) 198(-51.25,-8.2) 199(-51.5,0) 200(-51.75,-8.2) 201(-52,0) 202(-52.25,-8.2) 203(-52.5,0) 204(-52.75,-8.2) 205(-53,0) 206(-53.25,-8.2) 207(-53.5,0) 208(-53.75,-8.2) 209(-54,0) 210(-54.25,-8.2) 211(-54.5,0) 212(-54.75,-8.2) 213(-55,0) 214(-55.25,-8.2) 215(-55.5,0) 216(-55.75,-8.2) 217(-56,0) 218(-56.25,-8.2) 219(-56.5,0) 220(-56.75,-8.2) 221(-57,0) 222(-57.25,-8.2) 223(-57.5,0) 224(-57.75,-8.2) 225(-58,0) 226(-58.25,-8.2) 227(-58.5,0) 228(-58.75,-8.2) 229(-59,0) 230(-59.25,-8.2) 231(-59.5,0) 232(-59.75,-8.2) 233(-60,0) 234(-60.25,-8.2) 235(-60.5,0) 236(-60.75,-8.2) 237(-61,0) 238(-61.25,-8.2) 239(-61.5,0) 240(-61.75,-8.2) 241(-62,0) 242(-62.25,-8.2) 243(-62.5,0) 244(-62.75,-8.2) 245(-63,0) 246(-63.25,-8.2) 247(-63.5,0) 248(-63.75,-8.2) 249(-64,0) 250(-64.25,-8.2) 251(-64.5,0) 252(-64.75,-8.2) 253(-65,0) 254(-65.25,-8.2) 255(-65.5,0) 256(-65.75,-8.2) 257(-66,0) 258(-66.25,-8.2) 259(-66.5,0) 260(-66.75,-8.2)
  rect 2.007x3.505 smd: 261(-71.125,7.9) 262(4.375,3.9)
LOTES_APCI0096-P002A_75P
  round 1.092 hole 1.092 unplated: (-0.75,-4.725)
  round 1.6 hole 1.6 unplated: (19.25,-4.725)
  oval 0.305x1.549 smd: 1(0,0) 2(0.25,-6.45) 3(0.5,0) 4(0.75,-6.45) 5(1,0) 6(1.25,-6.45) 7(1.5,0) 8(1.75,-6.45) 9(2,0) 10(2.25,-6.45) 11(2.5,0) 12(2.75,-6.45) 13(3,0) 14(3.25,-6.45) 15(3.5,0) 16(3.75,-6.45) 17(4,0) 18(4.25,-6.45) 19(4.5,0) 20(4.75,-6.45) 21(5,0) 22(5.25,-6.45) 23(5.5,0) 24(5.75,-6.45) 25(6,0) 26(6.25,-6.45) 27(6.5,0) 28(6.75,-6.45) 29(7,0) 30(7.25,-6.45) 31(7.5,0) 32(7.75,-6.45) 33(8,0) 34(8.25,-6.45) 35(8.5,0) 36(8.75,-6.45) 37(9,0) 38(9.25,-6.45) 39(9.5,0) 40(9.75,-6.45) 41(10,0) 42(10.25,-6.45) 43(10.5,0) 44(10.75,-6.45) 45(11,0) 46(11.25,-6.45) 47(11.5,0) 48(11.75,-6.45) 49(12,0) 50(12.25,-6.45) 51(12.5,0) 52(12.75,-6.45) 53(13,0) 54(13.25,-6.45) 55(13.5,0) 56(13.75,-6.45) 57(14,0) 58(14.25,-6.45) 67(16.5,0) 68(16.75,-6.45) 69(17,0) 70(17.25,-6.45) 71(17.5,0) 72(17.75,-6.45) 73(18,0) 74(18.25,-6.45) 75(18.5,0)
  rect 1.194x2.743 smd: 76(-1.1,-0.225) 77(19.6,-0.225)
LOTES_AUSB0015-P002A_9P
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x2.591 hole 0.787x2.007: 10(-11.35,-1.59) 13(4.35,-1.59)
  oval 1.397x2.388 hole 0.787x1.803: 11(-11.35,-9.09) 12(4.35,-9.09)
MAG_MMD05CZR47M_4P
  custom 0.591x0.591 smd: 1(0,0) 4(6.248,0)
  rect 1.956x0.508 smd: 2(1.257,0) 3(4.991,0)
MAG_MMD-06CZ-R82M-V1L_2P
  rect 2.159x3.505 smd: 1(0,0) 2(5.85,0)
MAG_MMD-10DZ-R22MEX2L_2P
  rect 3.81x3.988 smd: 1(0,0) 2(9.2,0)
MC74VHC1G08DFT2G_SC70-5
  oval 0.381x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
MEC1404-NU-TR_VTQFP128_14X14
  oval 1.753x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.203x1.753 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
MHPC_NS892407_24P
  oval 0.635x1.778 smd: 1(0,0) 2(0.99,0) 3(1.98,0) 4(2.97,0) 5(3.96,0) 6(4.95,0) 7(5.94,0) 8(6.93,0) 9(7.92,0) 10(8.91,0) 11(9.9,0) 12(10.89,0) 13(10.89,8.99) 14(9.9,8.99) 15(8.91,8.99) 16(7.92,8.99) 17(6.93,8.99) 18(5.94,8.99) 19(4.95,8.99) 20(3.96,8.99) 21(2.97,8.99) 22(1.98,8.99) 23(0.99,8.99) 24(0,8.99)
MMBT3904WH_SOT323-3
  oval 0.61x0.787 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15AX700SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15PX181SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
N15P-GT_BGA_908P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A5(3.3,0) A6(4.1,0) A8(5.8,0) A9(6.6,0) A11(8.3,0) A12(9.1,0) A14(10.8,0) A15(11.6,0) A17(13.3,0) A18(14.1,0) A20(15.8,0) A21(16.6,0) A23(18.3,0) A24(19.1,0) A26(20.8,0) A27(21.6,0) A29(23.3,0) A30(24.1,0) A32(25.8,0) A33(26.6,0) AA1(0,-16.6) AA2(0.8,-16.6) AA3(1.6,-16.6) AA4(2.4,-16.6) AA5(3.2,-16.6) AA6(4.05,-16.6) AA7(4.9,-16.6) AA8(5.7,-16.6) AA27(21.7,-16.6) AA28(22.5,-16.6) AA29(23.35,-16.6) AA30(24.2,-16.6) AA31(25,-16.6) AA32(25.8,-16.6) AA33(26.6,-16.6) AA34(27.4,-16.6) AB2(0.8,-17.45) AB3(1.6,-17.45) AB4(2.4,-17.45) AB5(3.2,-17.45) AB7(4.9,-17.45) AB8(5.7,-17.45) AB27(21.7,-17.45) AB28(22.5,-17.45) AB30(24.2,-17.45) AB31(25,-17.45) AB32(25.8,-17.45) AB33(26.6,-17.45) AC1(0,-18.3) AC2(0.8,-18.3) AC3(1.6,-18.3) AC4(2.4,-18.3) AC5(3.2,-18.3) AC6(4.05,-18.3) AC7(4.9,-18.3) AC8(5.7,-18.3) AC27(21.7,-18.3) AC28(22.5,-18.3) AC29(23.35,-18.3) AC30(24.2,-18.3) AC31(25,-18.3) AC32(25.8,-18.3) AC33(26.6,-18.3) AC34(27.4,-18.3) AD1(0,-19.1) AD2(0.8,-19.1) AD3(1.6,-19.1) AD4(2.4,-19.1) AD5(3.2,-19.1) AD6(4.05,-19.1) AD7(4.9,-19.1) AD8(5.7,-19.1) AD27(21.7,-19.1) AD28(22.5,-19.1) AD29(23.35,-19.1) AD30(24.2,-19.1) AD31(25,-19.1) AD32(25.8,-19.1) AD33(26.6,-19.1) AD34(27.4,-19.1) AE2(0.8,-19.95) AE3(1.6,-19.95) AE4(2.4,-19.95) AE5(3.2,-19.95) AE7(4.9,-19.95) AE8(5.7,-19.95) AE27(21.7,-19.95) AE28(22.5,-19.95) AE30(24.2,-19.95) AE31(25,-19.95) AE32(25.8,-19.95) AE33(26.6,-19.95) AF1(0,-20.8) AF2(0.8,-20.8) AF3(1.6,-20.8) AF4(2.4,-20.8) AF5(3.2,-20.8) AF6(4.05,-20.8) AF7(4.9,-20.8) AF8(5.7,-20.8) AF27(21.7,-20.8) AF28(22.5,-20.8) AF29(23.35,-20.8) AF30(24.2,-20.8) AF31(25,-20.8) AF32(25.8,-20.8) AF33(26.6,-20.8) AF34(27.4,-20.8) AG1(0,-21.6) AG2(0.8,-21.6) AG3(1.6,-21.6) AG4(2.4,-21.6) AG5(3.2,-21.6) AG6(4.05,-21.6) AG7(4.9,-21.6) AG8(5.7,-21.7) AG9(6.6,-21.7) AG10(7.45,-21.7) AG11(8.3,-21.7) AG12(9.1,-21.7) AG13(9.95,-21.7) AG14(10.8,-21.7) AG15(11.6,-21.7) AG16(12.45,-21.7) AG17(13.3,-21.7) AG18(14.1,-21.7) AG19(14.95,-21.7) AG20(15.8,-21.7) AG21(16.6,-21.7) AG22(17.45,-21.7) AG23(18.3,-21.7) AG24(19.1,-21.7) AG25(19.95,-21.7) AG26(20.8,-21.7) AG27(21.7,-21.7) AG28(22.5,-21.6) AG29(23.35,-21.6) AG30(24.2,-21.6) AG31(25,-21.6) AG32(25.8,-21.6) AG33(26.6,-21.6) AG34(27.4,-21.6) AH2(0.8,-22.45) AH3(1.6,-22.45) AH4(2.4,-22.45) AH5(3.2,-22.45) AH6(4.05,-22.45) AH7(4.9,-22.5) AH8(5.8,-22.5) AH9(6.6,-22.5) AH10(7.45,-22.5) AH11(8.3,-22.5) AH12(9.1,-22.5) AH13(9.95,-22.5) AH14(10.8,-22.5) AH15(11.6,-22.5) AH16(12.45,-22.5) AH17(13.3,-22.5) AH18(14.1,-22.5) AH19(14.95,-22.5) AH20(15.8,-22.5) AH21(16.6,-22.5) AH22(17.45,-22.5) AH23(18.3,-22.5) AH24(19.1,-22.5) AH25(19.95,-22.5) AH26(20.8,-22.5) AH27(21.6,-22.5) AH28(22.5,-22.5) AH29(23.35,-22.45) AH30(24.2,-22.45) AH31(25,-22.45) AH32(25.8,-22.45) AH33(26.6,-22.45) AJ1(0,-23.3) AJ2(0.8,-23.3) AJ3(1.6,-23.3) AJ4(2.4,-23.3) AJ5(3.2,-23.3) AJ6(4.05,-23.35) AJ7(4.95,-23.35) AJ8(5.8,-23.35) AJ9(6.6,-23.35) AJ11(8.3,-23.35) AJ12(9.1,-23.35) AJ14(10.8,-23.35) AJ15(11.6,-23.35) AJ17(13.3,-23.35) AJ18(14.1,-23.35) AJ20(15.8,-23.35) AJ21(16.6,-23.35) AJ23(18.3,-23.35) AJ24(19.1,-23.35) AJ26(20.8,-23.35) AJ27(21.6,-23.35) AJ28(22.45,-23.35) AJ29(23.35,-23.35) AJ30(24.2,-23.3) AJ31(25,-23.3) AJ32(25.8,-23.3) AJ33(26.6,-23.3) AJ34(27.4,-23.3) AK1(0,-24.1) AK2(0.8,-24.1) AK3(1.6,-24.1) AK4(2.4,-24.1) AK5(3.2,-24.2) AK6(4.1,-24.2) AK7(4.95,-24.2) AK8(5.8,-24.2) AK9(6.6,-24.2) AK10(7.45,-24.2) AK11(8.3,-24.2) AK12(9.1,-24.2) AK13(9.95,-24.2) AK14(10.8,-24.2) AK15(11.6,-24.2) AK16(12.45,-24.2) AK17(13.3,-24.2) AK18(14.1,-24.2) AK19(14.95,-24.2) AK20(15.8,-24.2) AK21(16.6,-24.2) AK22(17.45,-24.2) AK23(18.3,-24.2) AK24(19.1,-24.2) AK25(19.95,-24.2) AK26(20.8,-24.2) AK27(21.6,-24.2) AK28(22.45,-24.2) AK29(23.3,-24.2) AK30(24.2,-24.2) AK31(25,-24.1) AK32(25.8,-24.1) AK33(26.6,-24.1) AK34(27.4,-24.1) AL2(0.8,-24.95) AL3(1.6,-24.95) AL4(2.4,-25) AL5(3.3,-25) AL6(4.1,-25) AL7(4.95,-25) AL8(5.8,-25) AL9(6.6,-25) AL10(7.45,-25) AL11(8.3,-25) AL12(9.1,-25) AL13(9.95,-25) AL14(10.8,-25) AL15(11.6,-25) AL16(12.45,-25) AL17(13.3,-25) AL18(14.1,-25) AL19(14.95,-25) AL20(15.8,-25) AL21(16.6,-25) AL22(17.45,-25) AL23(18.3,-25) AL24(19.1,-25) AL25(19.95,-25) AL26(20.8,-25) AL27(21.6,-25) AL28(22.45,-25) AL29(23.3,-25) AL30(24.1,-25) AL31(25,-25) AL32(25.8,-24.95) AL33(26.6,-24.95) AM1(0,-25.8) AM2(0.8,-25.8) AM3(1.6,-25.8) AM4(2.45,-25.8) AM5(3.3,-25.8) AM6(4.1,-25.8) AM7(4.95,-25.8) AM8(5.8,-25.8) AM9(6.6,-25.8) AM10(7.45,-25.8) AM11(8.3,-25.8) AM12(9.1,-25.8) AM13(9.95,-25.8) AM14(10.8,-25.8) AM15(11.6,-25.8) AM16(12.45,-25.8) AM17(13.3,-25.8) AM18(14.1,-25.8) AM19(14.95,-25.8) AM20(15.8,-25.8) AM21(16.6,-25.8) AM22(17.45,-25.8) AM23(18.3,-25.8) AM24(19.1,-25.8) AM25(19.95,-25.8) AM26(20.8,-25.8) AM27(21.6,-25.8) AM28(22.45,-25.8) AM29(23.3,-25.8) AM30(24.1,-25.8) AM31(24.95,-25.8) AM32(25.8,-25.8) AM33(26.6,-25.8) AM34(27.4,-25.8) AN1(0,-26.6) AN2(0.8,-26.6) AN3(1.6,-26.6) AN4(2.45,-26.6) AN5(3.3,-26.6) AN6(4.1,-26.6) AN7(4.95,-26.6) AN8(5.8,-26.6) AN9(6.6,-26.6) AN10(7.45,-26.6) AN11(8.3,-26.6) AN12(9.1,-26.6) AN13(9.95,-26.6) AN14(10.8,-26.6) AN15(11.6,-26.6) AN16(12.45,-26.6) AN17(13.3,-26.6) AN18(14.1,-26.6) AN19(14.95,-26.6) AN20(15.8,-26.6) AN21(16.6,-26.6) AN22(17.45,-26.6) AN23(18.3,-26.6) AN24(19.1,-26.6) AN25(19.95,-26.6) AN26(20.8,-26.6) AN27(21.6,-26.6) AN28(22.45,-26.6) AN29(23.3,-26.6) AN30(24.1,-26.6) AN31(24.95,-26.6) AN32(25.8,-26.6) AN33(26.6,-26.6) AN34(27.4,-26.6) AP2(0.8,-27.4) AP3(1.6,-27.4) AP5(3.3,-27.4) AP6(4.1,-27.4) AP8(5.8,-27.4) AP9(6.6,-27.4) AP11(8.3,-27.4) AP12(9.1,-27.4) AP14(10.8,-27.4) AP15(11.6,-27.4) AP17(13.3,-27.4) AP18(14.1,-27.4) AP20(15.8,-27.4) AP21(16.6,-27.4) AP23(18.3,-27.4) AP24(19.1,-27.4) AP26(20.8,-27.4) AP27(21.6,-27.4) AP29(23.3,-27.4) AP30(24.1,-27.4) AP32(25.8,-27.4) AP33(26.6,-27.4) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.45,-0.8) B5(3.3,-0.8) B6(4.1,-0.8) B7(4.95,-0.8) B8(5.8,-0.8) B9(6.6,-0.8) B10(7.45,-0.8) B11(8.3,-0.8) B12(9.1,-0.8) B13(9.95,-0.8) B14(10.8,-0.8) B15(11.6,-0.8) B16(12.45,-0.8) B17(13.3,-0.8) B18(14.1,-0.8) B19(14.95,-0.8) B20(15.8,-0.8) B21(16.6,-0.8) B22(17.45,-0.8) B23(18.3,-0.8) B24(19.1,-0.8) B25(19.95,-0.8) B26(20.8,-0.8) B27(21.6,-0.8) B28(22.45,-0.8) B29(23.3,-0.8) B30(24.1,-0.8) B31(24.95,-0.8) B32(25.8,-0.8) B33(26.6,-0.8) B34(27.4,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.45,-1.6) C5(3.3,-1.6) C6(4.1,-1.6) C7(4.95,-1.6) C8(5.8,-1.6) C9(6.6,-1.6) C10(7.45,-1.6) C11(8.3,-1.6) C12(9.1,-1.6) C13(9.95,-1.6) C14(10.8,-1.6) C15(11.6,-1.6) C16(12.45,-1.6) C17(13.3,-1.6) C18(14.1,-1.6) C19(14.95,-1.6) C20(15.8,-1.6) C21(16.6,-1.6) C22(17.45,-1.6) C23(18.3,-1.6) C24(19.1,-1.6) C25(19.95,-1.6) C26(20.8,-1.6) C27(21.6,-1.6) C28(22.45,-1.6) C29(23.3,-1.6) C30(24.1,-1.6) C31(24.95,-1.6) C32(25.8,-1.6) C33(26.6,-1.6) C34(27.4,-1.6) D2(0.8,-2.45) D3(1.6,-2.45) D4(2.4,-2.4) D5(3.3,-2.4) D6(4.1,-2.4) D7(4.95,-2.4) D8(5.8,-2.4) D9(6.6,-2.4) D10(7.45,-2.4) D11(8.3,-2.4) D12(9.1,-2.4) D13(9.95,-2.4) D14(10.8,-2.4) D15(11.6,-2.4) D16(12.45,-2.4) D17(13.3,-2.4) D18(14.1,-2.4) D19(14.95,-2.4) D20(15.8,-2.4) D21(16.6,-2.4) D22(17.45,-2.4) D23(18.3,-2.4) D24(19.1,-2.4) D25(19.95,-2.4) D26(20.8,-2.4) D27(21.6,-2.4) D28(22.45,-2.4) D29(23.3,-2.4) D30(24.1,-2.4) D31(25,-2.4) D32(25.8,-2.45) D33(26.6,-2.45) E1(0,-3.3) E2(0.8,-3.3) E3(1.6,-3.3) E4(2.4,-3.3) E5(3.2,-3.2) E6(4.1,-3.2) E7(4.95,-3.2) E8(5.8,-3.2) E9(6.6,-3.2) E10(7.45,-3.2) E11(8.3,-3.2) E12(9.1,-3.2) E13(9.95,-3.2) E14(10.8,-3.2) E15(11.6,-3.2) E16(12.45,-3.2) E17(13.3,-3.2) E18(14.1,-3.2) E19(14.95,-3.2) E20(15.8,-3.2) E21(16.6,-3.2) E22(17.45,-3.2) E23(18.3,-3.2) E24(19.1,-3.2) E25(19.95,-3.2) E26(20.8,-3.2) E27(21.6,-3.2) E28(22.45,-3.2) E29(23.3,-3.2) E30(24.2,-3.2) E31(25,-3.3) E32(25.8,-3.3) E33(26.6,-3.3) E34(27.4,-3.3) F1(0,-4.1) F2(0.8,-4.1) F3(1.6,-4.1) F4(2.4,-4.1) F5(3.2,-4.1) F6(4.05,-4.05) F7(4.95,-4.05) F8(5.8,-4.05) F9(6.6,-4.05) F11(8.3,-4.05) F12(9.1,-4.05) F14(10.8,-4.05) F15(11.6,-4.05) F17(13.3,-4.05) F18(14.1,-4.05) F20(15.8,-4.05) F21(16.6,-4.05) F23(18.3,-4.05) F24(19.1,-4.05) F26(20.8,-4.05) F27(21.6,-4.05) F28(22.45,-4.05) F29(23.35,-4.05) F30(24.2,-4.1) F31(25,-4.1) F32(25.8,-4.1) F33(26.6,-4.1) F34(27.4,-4.1) G2(0.8,-4.95) G3(1.6,-4.95) G4(2.4,-4.95) G5(3.2,-4.95) G6(4.05,-4.95) G7(4.9,-4.9) G8(5.8,-4.9) G9(6.6,-4.9) G10(7.45,-4.9) G11(8.3,-4.9) G12(9.1,-4.9) G13(9.95,-4.9) G14(10.8,-4.9) G15(11.6,-4.9) G16(12.45,-4.9) G17(13.3,-4.9) G18(14.1,-4.9) G19(14.95,-4.9) G20(15.8,-4.9) G21(16.6,-4.9) G22(17.45,-4.9) G23(18.3,-4.9) G24(19.1,-4.9) G25(19.95,-4.9) G26(20.8,-4.9) G27(21.6,-4.9) G28(22.5,-4.9) G29(23.35,-4.95) G30(24.2,-4.95) G31(25,-4.95) G32(25.8,-4.95) G33(26.6,-4.95) H1(0,-5.8) H2(0.8,-5.8) H3(1.6,-5.8) H4(2.4,-5.8) H5(3.2,-5.8) H6(4.05,-5.8) H7(4.9,-5.8) H8(5.7,-5.7) H9(6.6,-5.7) H10(7.45,-5.7) H11(8.3,-5.7) H12(9.1,-5.7) H13(9.95,-5.7) H14(10.8,-5.7) H15(11.6,-5.7) H16(12.45,-5.7) H17(13.3,-5.7) H18(14.1,-5.7) H19(14.95,-5.7) H20(15.8,-5.7) H21(16.6,-5.7) H22(17.45,-5.7) H23(18.3,-5.7) H24(19.1,-5.7) H25(19.95,-5.7) H26(20.8,-5.7) H27(21.7,-5.7) H28(22.5,-5.8) H29(23.35,-5.8) H30(24.2,-5.8) H31(25,-5.8) H32(25.8,-5.8) H33(26.6,-5.8) H34(27.4,-5.8) J1(0,-6.6) J2(0.8,-6.6) J3(1.6,-6.6) J4(2.4,-6.6) J5(3.2,-6.6) J6(4.05,-6.6) J7(4.9,-6.6) J8(5.7,-6.6) J27(21.7,-6.6) J28(22.5,-6.6) J29(23.35,-6.6) J30(24.2,-6.6) J31(25,-6.6) J32(25.8,-6.6) J33(26.6,-6.6) J34(27.4,-6.6) K2(0.8,-7.45) K3(1.6,-7.45) K4(2.4,-7.45) K5(3.2,-7.45) K7(4.9,-7.45) K8(5.7,-7.45) K27(21.7,-7.45) K28(22.5,-7.45) K30(24.2,-7.45) K31(25,-7.45) K32(25.8,-7.45) K33(26.6,-7.45) L1(0,-8.3) L2(0.8,-8.3) L3(1.6,-8.3) L4(2.4,-8.3) L5(3.2,-8.3) L6(4.05,-8.3) L7(4.9,-8.3) L8(5.7,-8.3) L27(21.7,-8.3) L28(22.5,-8.3) L29(23.35,-8.3) L30(24.2,-8.3) L31(25,-8.3) L32(25.8,-8.3) L33(26.6,-8.3) L34(27.4,-8.3) M1(0,-9.1) M2(0.8,-9.1) M3(1.6,-9.1) M4(2.4,-9.1) M5(3.2,-9.1) M6(4.05,-9.1) M7(4.9,-9.1) M8(5.7,-9.1) M27(21.7,-9.1) M28(22.5,-9.1) M29(23.35,-9.1) M30(24.2,-9.1) M31(25,-9.1) M32(25.8,-9.1) M33(26.6,-9.1) M34(27.4,-9.1) N2(0.8,-9.95) N3(1.6,-9.95) N4(2.4,-9.95) N5(3.2,-9.95) N7(4.9,-9.95) N8(5.7,-9.95) N27(21.7,-9.95) N28(22.5,-9.95) N30(24.2,-9.95) N31(25,-9.95) N32(25.8,-9.95) N33(26.6,-9.95) P1(0,-10.8) P2(0.8,-10.8) P3(1.6,-10.8) P4(2.4,-10.8) P5(3.2,-10.8) P6(4.05,-10.8) P7(4.9,-10.8) P8(5.7,-10.8) P27(21.7,-10.8) P28(22.5,-10.8) P29(23.35,-10.8) P30(24.2,-10.8) P31(25,-10.8) P32(25.8,-10.8) P33(26.6,-10.8) P34(27.4,-10.8) R1(0,-11.6) R2(0.8,-11.6) R3(1.6,-11.6) R4(2.4,-11.6) R5(3.2,-11.6) R6(4.05,-11.6) R7(4.9,-11.6) R8(5.7,-11.6) R27(21.7,-11.6) R28(22.5,-11.6) R29(23.35,-11.6) R30(24.2,-11.6) R31(25,-11.6) R32(25.8,-11.6) R33(26.6,-11.6) R34(27.4,-11.6) T2(0.8,-12.45) T3(1.6,-12.45) T4(2.4,-12.45) T5(3.2,-12.45) T7(4.9,-12.45) T8(5.7,-12.45) T27(21.7,-12.45) T28(22.5,-12.45) T30(24.2,-12.45) T31(25,-12.45) T32(25.8,-12.45) T33(26.6,-12.45) U1(0,-13.3) U2(0.8,-13.3) U3(1.6,-13.3) U4(2.4,-13.3) U5(3.2,-13.3) U6(4.05,-13.3) U7(4.9,-13.3) U8(5.7,-13.3) U27(21.7,-13.3) U28(22.5,-13.3) U29(23.35,-13.3) U30(24.2,-13.3) U31(25,-13.3) U32(25.8,-13.3) U33(26.6,-13.3) U34(27.4,-13.3) V1(0,-14.1) V2(0.8,-14.1) V3(1.6,-14.1) V4(2.4,-14.1) V5(3.2,-14.1) V6(4.05,-14.1) V7(4.9,-14.1) V8(5.7,-14.1) V27(21.7,-14.1) V28(22.5,-14.1) V29(23.35,-14.1) V30(24.2,-14.1) V31(25,-14.1) V32(25.8,-14.1) V33(26.6,-14.1) V34(27.4,-14.1) W2(0.8,-14.95) W3(1.6,-14.95) W4(2.4,-14.95) W5(3.2,-14.95) W7(4.9,-14.95) W8(5.7,-14.95) W27(21.7,-14.95) W28(22.5,-14.95) W30(24.2,-14.95) W31(25,-14.95) W32(25.8,-14.95) W33(26.6,-14.95) Y1(0,-15.8) Y2(0.8,-15.8) Y3(1.6,-15.8) Y4(2.4,-15.8) Y5(3.2,-15.8) Y6(4.05,-15.8) Y7(4.9,-15.8) Y8(5.7,-15.8) Y27(21.7,-15.8) Y28(22.5,-15.8) Y29(23.35,-15.8) Y30(24.2,-15.8) Y31(25,-15.8) Y32(25.8,-15.8) Y33(26.6,-15.8) Y34(27.4,-15.8)
  round 0.406 smd: AA12(8.2,-17.2) AA13(9.2,-17.2) AA14(10.2,-17.2) AA15(11.2,-17.2) AA16(12.2,-17.2) AA17(13.2,-17.2) AA18(14.2,-17.2) AA19(15.2,-17.2) AA20(16.2,-17.2) AA21(17.2,-17.2) AA22(18.2,-17.2) AA23(19.2,-17.2) AB12(8.2,-18.2) AB13(9.2,-18.2) AB14(10.2,-18.2) AB15(11.2,-18.2) AB16(12.2,-18.2) AB17(13.2,-18.2) AB18(14.2,-18.2) AB19(15.2,-18.2) AB20(16.2,-18.2) AB21(17.2,-18.2) AB22(18.2,-18.2) AB23(19.2,-18.2) AC12(8.2,-19.2) AC13(9.2,-19.2) AC14(10.2,-19.2) AC15(11.2,-19.2) AC16(12.2,-19.2) AC17(13.2,-19.2) AC18(14.2,-19.2) AC19(15.2,-19.2) AC20(16.2,-19.2) AC21(17.2,-19.2) AC22(18.2,-19.2) AC23(19.2,-19.2) M12(8.2,-8.2) M13(9.2,-8.2) M14(10.2,-8.2) M15(11.2,-8.2) M16(12.2,-8.2) M17(13.2,-8.2) M18(14.2,-8.2) M19(15.2,-8.2) M20(16.2,-8.2) M21(17.2,-8.2) M22(18.2,-8.2) M23(19.2,-8.2) N12(8.2,-9.2) N13(9.2,-9.2) N14(10.2,-9.2) N15(11.2,-9.2) N16(12.2,-9.2) N17(13.2,-9.2) N18(14.2,-9.2) N19(15.2,-9.2) N20(16.2,-9.2) N21(17.2,-9.2) N22(18.2,-9.2) N23(19.2,-9.2) P12(8.2,-10.2) P13(9.2,-10.2) P14(10.2,-10.2) P15(11.2,-10.2) P16(12.2,-10.2) P17(13.2,-10.2) P18(14.2,-10.2) P19(15.2,-10.2) P20(16.2,-10.2) P21(17.2,-10.2) P22(18.2,-10.2) P23(19.2,-10.2) R12(8.2,-11.2) R13(9.2,-11.2) R14(10.2,-11.2) R15(11.2,-11.2) R16(12.2,-11.2) R17(13.2,-11.2) R18(14.2,-11.2) R19(15.2,-11.2) R20(16.2,-11.2) R21(17.2,-11.2) R22(18.2,-11.2) R23(19.2,-11.2) T12(8.2,-12.2) T13(9.2,-12.2) T14(10.2,-12.2) T15(11.2,-12.2) T16(12.2,-12.2) T17(13.2,-12.2) T18(14.2,-12.2) T19(15.2,-12.2) T20(16.2,-12.2) T21(17.2,-12.2) T22(18.2,-12.2) T23(19.2,-12.2) U12(8.2,-13.2) U13(9.2,-13.2) U14(10.2,-13.2) U15(11.2,-13.2) U16(12.2,-13.2) U17(13.2,-13.2) U18(14.2,-13.2) U19(15.2,-13.2) U20(16.2,-13.2) U21(17.2,-13.2) U22(18.2,-13.2) U23(19.2,-13.2) V12(8.2,-14.2) V13(9.2,-14.2) V14(10.2,-14.2) V15(11.2,-14.2) V16(12.2,-14.2) V17(13.2,-14.2) V18(14.2,-14.2) V19(15.2,-14.2) V20(16.2,-14.2) V21(17.2,-14.2) V22(18.2,-14.2) V23(19.2,-14.2) W12(8.2,-15.2) W13(9.2,-15.2) W14(10.2,-15.2) W15(11.2,-15.2) W16(12.2,-15.2) W17(13.2,-15.2) W18(14.2,-15.2) W19(15.2,-15.2) W20(16.2,-15.2) W21(17.2,-15.2) W22(18.2,-15.2) W23(19.2,-15.2) Y12(8.2,-16.2) Y13(9.2,-16.2) Y14(10.2,-16.2) Y15(11.2,-16.2) Y16(12.2,-16.2) Y17(13.2,-16.2) Y18(14.2,-16.2) Y19(15.2,-16.2) Y20(16.2,-16.2) Y21(17.2,-16.2) Y22(18.2,-16.2) Y23(19.2,-16.2)
