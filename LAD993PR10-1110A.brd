# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS#5: length 68.3
  IN1 w0.076: v2(115.96,79.28) 116.18,79.05 116.31,79.05 116.5,78.86 116.5,77.46 116.72,77.25 116.72,73.2 117.89,72.03 118.24,72.03 118.38,72.03 120.67,69.74 122.34,69.74 122.47,69.61
  IN1 w0.094: 122.47,69.61 125.84,66.24 125.84,42.18 125.51,41.86 125.51,33.85 125.11,33.44 124.7,33.44 124.34,33.09 124.34,30.26 124.14,30.06 124.14,25.87 123.62,25.35 123.62,23.73 123.71,23.64 123.81,23.64 v2(124.03,23.86)
  BOTTOM w0.089: UH1.W9 115.63,78.95 v2(115.96,79.28)
  BOTTOM w0.114: JDIMM2.198 121.91,21 122.04,21.12 122.04,21.34 122.94,22.25 122.94,23.24 123.28,23.58 123.75,23.58 v2(124.03,23.86)
DDR_B_DQS#6: length 68.9
  IN1 w0.076: v2(118.69,79.27) 119.1,78.87 119.1,75.18 119.47,74.81 120.29,74.81
  IN1 w0.094: v2(129.58,24.8) 129.37,25.01 129.17,25.01 128.87,25.31 128.87,26.36 129.35,26.84 129.35,30.04 130.28,30.98 130.28,34.96 131.1,35.78 131.1,39.6 130.37,40.33 130.37,67.64 126.52,71.48 125.4,71.48 124.92,71 124.89,71 124.85,70.95 124.42,70.95 120.67,74.7 120.39,74.7 120.29,74.81
  BOTTOM w0.089: v2(118.69,79.27) 118.56,79.27 UH1.R9
  BOTTOM w0.114: JDIMM2.219 127.16,27.14 127.28,27.02 127.28,26.72 128.07,25.93 128.41,25.93 128.77,25.57 128.77,25.25 129.03,24.99 129.39,24.99 v2(129.58,24.8)
DDR_B_DQS#7: length 71.9
  IN1 w0.076: v2(121.39,78.56) 121.39,78.69 121.55,78.86 121.66,78.86 121.78,78.74 121.78,77.83 122.08,77.53 122.79,77.53 122.99,77.34 123.5,77.34 123.82,77.02 124.07,77.02 124.75,76.33 126.59,76.33 126.61,76.31 126.63,76.31
  IN1 w0.094: 126.63,76.31 127.81,76.31 134.87,69.25 134.87,54.1 135.21,53.76 135.21,53.16 135.21,53.16 135.21,50.52 135.79,49.94 135.79,41.08 136.87,40.01 136.87,33.13 136.66,32.92 136.66,29.46 133.85,26.65 133.85,25.46 133.43,25.03 133.43,23.84 133.43,23.66 133.39,23.63 133.39,22.78 133.3,22.68 133.07,22.68 132.93,22.83 v2(132.93,22.98)
  BOTTOM w0.089: v2(121.39,78.56) 121,78.95 UH1.M9
  BOTTOM w0.114: JDIMM2.240 132.41,20.8 132.53,20.92 132.53,21.12 132.14,21.51 132.14,22.34 132.47,22.67 132.62,22.67 v2(132.93,22.98)
DDR_B_MA0: length 69.1
  IN1 w0.076: v2(107.72,79.27) 107.29,78.84 107.29,77.81 107.73,77.38 107.73,75.42 107.97,75.17 107.97,73.64 108.26,73.35
  IN1 w0.152: 108.26,73.35 108.26,65.81 110.6,63.47 110.6,53.08 107.43,49.91 107.43,39.49 106.89,38.95 106.89,33.3 106.63,33.04 106.63,29.76 107.74,28.66 107.74,24.87 107.27,24.4 107.27,21.91 107.75,21.44 108.32,21.44 108.51,21.63 108.51,22.56 108.71,22.75 v2(109,22.75)
  BOTTOM w0.076: v2(107.72,79.27) 107.59,79.27 UH1.AJ9
  BOTTOM w0.185: v2(109,22.75) 108.3,22.75 106.41,20.85 JDIMM2.144
DDR_B_MA1: length 68.1
  IN1 w0.076: 105.89,75.64 105.89,76.31 v2(106.25,76.68)
  IN1 w0.152: 105.89,75.64 105.68,75.43 105.68,64.86 107.13,63.41 107.13,56.29 104.1,53.26 104.1,46.41 103.9,46.22 103.32,46.22 103.13,46.02 103.13,45.06 103.32,44.86 103.9,44.86 104.1,44.67 104.1,42.9 103.9,42.71 103.33,42.71 103.14,42.52 103.14,41.95 103.33,41.76 103.9,41.76 104.1,41.56 104.1,41.12 103.9,40.92 103.17,40.92 102.9,40.65 102.9,40.23 103.1,40.02 103.1,28.72 104.3,27.52 104.3,24.1 105.05,23.35 105.05,23.08 104.67,22.7 104.4,22.7 v2(103.87,23.22)
  BOTTOM w0.076: v2(106.25,76.68) 106.39,76.68 UH1.AK6
  BOTTOM w0.185: v2(103.87,23.22) 104.43,23.78 104.43,24.82 103.66,25.59 JDIMM2.133
DDR_B_MA2: length 65.9
  IN1 w0.152: v2(106.28,76.02) 106.29,76 106.29,75.86 106.29,75.85 106.29,75.56 106.03,75.3 106.03,65.02 107.63,63.43 107.63,55.74 107.43,55.53 107.08,55.53 106.88,55.34 106.88,55.07 107.48,54.48 107.48,54.3 107.11,53.93 106.93,53.93 106.34,54.52 106.06,54.52 105.79,54.25 105.79,53.98 106.39,53.38 106.39,53.2 106.08,52.89 105.86,52.89 105.22,53.53 105.04,53.53 104.68,53.18 104.68,53 105.32,52.35 105.32,52.14 104.84,51.65 104.84,40.73 104.07,39.97 104.07,34.41 103.56,33.89 103.56,28.96 104.8,27.73 104.8,24.31 105.18,23.92 v2(105.63,23.92)
  BOTTOM w0.076: UH1.AK5 106.6,76.34 106.28,76.02 v2(106.28,76.02)
  BOTTOM w0.185: v2(105.63,23.92) 105.37,23.92 103.41,21.96 JDIMM2.132
DDR_B_MA3: length 68.1
  IN1 w0.152: v2(103.8,24.59) 103.8,27.31 102.61,28.51 102.61,32.03 102.15,32.49 102.15,33.14 102.61,33.6 102.61,39.81 102.18,40.24 102.18,40.64 102.61,41.07 102.61,43.38 102.8,43.57 103.27,43.57 103.46,43.77 103.46,44.15 103.27,44.35 102.8,44.35 102.61,44.54 102.61,46.76 102.8,46.95 103.37,46.95 103.56,47.14 103.56,47.53 103.37,47.72 102.8,47.72 102.61,47.91 102.61,48.3 102.8,48.49 103.34,48.49 103.53,48.69 103.53,49.07 103.34,49.27 102.8,49.27 102.61,49.46 102.61,49.84 102.8,50.04 103.34,50.04 103.53,50.23 103.53,50.62 103.34,50.81 102.8,50.81 102.61,51 102.61,51.39 102.8,51.58 103.34,51.58 103.53,51.78 103.53,52.16 103.34,52.35 102.8,52.35 102.61,52.55 102.61,53.05 102.76,53.2 103.33,53.2 105.4,55.27 105.4,55.54 105.18,55.76 105.18,56.04 105.45,56.31 105.73,56.31 105.95,56.09 106.22,56.09 106.63,56.5 106.63,63.44 105.34,64.72 105.34,72.35 104.68,73.02 104.68,73.64 105.29,74.25 105.29,75.84 v2(105.5,76.05)
  BOTTOM w0.076: v2(105.5,76.05) 105.56,76.05 105.84,76.34 UH1.AL5
  BOTTOM w0.185: JDIMM2.131 103.16,25.24 v2(103.8,24.59)
DDR_B_MA4: length 68
  IN1 w0.152: v2(102.73,21.49) 102.8,21.43 104.91,21.43 105.04,21.55 105.04,22.07 104.91,22.2 103.5,22.2 103.31,22.39 103.31,22.86 103.08,23.08 103.08,23.39 103.31,23.61 103.31,27.11 102.11,28.31 102.11,31.82 101.65,32.28 101.65,33.35 102.11,33.81 102.11,39.52 101.65,39.98 101.65,40.82 102.11,41.28 102.11,45.4 101.92,45.59 101.87,45.59 101.68,45.79 101.68,46.17 101.87,46.36 101.92,46.36 102.11,46.56 102.11,46.94 101.92,47.14 101.87,47.14 101.68,47.33 101.68,47.72 101.87,47.91 101.92,47.91 102.11,48.1 102.11,53.47 102.48,53.85 102.75,53.85 102.88,53.72 103.15,53.72 103.42,54 103.42,54.27 103.2,54.49 103.2,54.77 103.47,55.04 103.75,55.04 103.97,54.82 104.24,54.82 104.52,55.09 104.52,55.36 104.29,55.59 104.29,55.86 106.13,57.7 106.13,63.26 104.99,64.41 104.99,72.07 104.44,72.62 104.44,73.99 104.99,74.54 104.99,76.25 v2(105.4,76.65)
  BOTTOM w0.076: v2(105.4,76.65) 105.53,76.65 UH1.AL6
  BOTTOM w0.185: JDIMM2.128 102.41,21.17 v2(102.73,21.49)
DDR_B_MA5: length 65.7
  IN1 w0.152: v2(102.71,22.8) 102.14,22.8 101.93,23.01 101.93,23.45 102.08,23.6 102.57,23.6 102.81,23.83 102.81,26.9 101.61,28.1 101.61,31.61 101.15,32.07 101.15,40.37 101,40.52 100.51,40.52 100.32,40.71 100.32,41.1 100.51,41.29 101.42,41.29 101.61,41.48 101.61,44.41 101.42,44.61 101.35,44.61 101.15,44.8 101.15,48.28 101.35,48.47 101.42,48.47 101.61,48.66 101.61,49.05 101.42,49.24 101.35,49.24 101.15,49.43 101.15,49.82 101.35,50.01 101.42,50.01 101.61,50.21 101.61,50.59 101.42,50.78 101.35,50.78 101.15,50.98 101.15,51.36 101.35,51.56 101.42,51.56 101.61,51.75 101.61,52.14 101.42,52.33 101.35,52.33 101.15,52.52 101.15,53.43 105.64,57.91 105.64,63.16 104.63,64.16 104.63,71.97 104.2,72.41 104.2,74.11 104.61,74.52 v2(104.61,76.7)
  BOTTOM w0.076: v2(104.61,76.7) 104.74,76.7 UH1.AM6
  BOTTOM w0.185: v2(102.71,22.8) 102.35,22.8 101.91,22.36 JDIMM2.126
DDR_B_MA6: length 66.4
  IN1 w0.076: 104.35,74.69 104.35,75.96 104.25,76.06 104.25,76.88 104.82,77.44 104.92,77.44 104.96,77.48 v2(104.98,77.48)
  IN1 w0.152: v2(101.77,24.08) 102.08,24.08 102.24,24.24 102.24,26.77 101.06,27.94 101.06,28.76 100.65,29.17 100.65,30.34 100.92,30.62 100.92,30.98 100.65,31.25 100.65,39.89 100.52,40.02 100.26,40.02 99.63,40.65 99.63,41.6 99.83,41.79 100.46,41.79 100.65,41.98 100.65,42.76 101,43.11 101,43.53 100.65,43.87 100.65,53.59 105.14,58.08 105.14,62.95 104.3,63.78 104.3,71.82 103.95,72.18 103.95,74.2 103.95,74.21 103.95,74.29 104.35,74.69
  BOTTOM w0.076: v2(104.98,77.48) 104.82,77.65 UH1.AN7
  BOTTOM w0.185: v2(101.77,24.08) 101.46,23.77 101.46,23.59 101.82,23.22 102,23.22 102.45,23.67 102.45,26.69 102.16,26.98 JDIMM2.127
DDR_B_MA7: length 68.3
  IN1 w0.076: 103.46,74.34 103.51,74.4 103.51,75.02 103.4,75.14 103.4,76.83 104.2,77.64 104.2,77.96 104.6,78.36 104.6,79.82 104.71,79.92 v2(104.98,79.92)
  IN1 w0.152: 103.46,74.34 103.46,71.62 103.62,71.47 103.62,63.21 104.14,62.69 104.14,58.7 99.01,53.57 99.01,51.65 98.82,51.45 98.32,51.45 98.13,51.26 98.13,50.88 98.32,50.68 98.76,50.68 99.02,50.42 99.02,44.37 98.56,43.91 98.56,40.33 99.66,39.24 99.66,28.76 100.07,28.35 100.07,27.53 101.24,26.36 101.24,23.32 101.43,23.13 101.43,22.42 101.54,22.31 102.06,22.31 102.25,22.12 102.25,21.62 102.06,21.43 101.07,21.43 v2(100.91,21.27)
  BOTTOM w0.076: UH1.AN10 104.84,79.92 v2(104.98,79.92)
  BOTTOM w0.185: v2(100.91,21.27) JDIMM2.122
DDR_B_MA8: length 67.5
  IN1 w0.076: v2(104.99,78.07) 103.9,76.98 103.9,75.88 104.12,75.65 104.12,74.8 103.71,74.39 103.71,74.31
  IN1 w0.152: v2(101.72,25.42) 101.74,25.44 101.74,26.56 100.57,27.74 100.57,28.56 100.15,28.97 100.15,39.44 99.11,40.49 99.11,42.11 99.3,42.3 99.96,42.3 100.15,42.49 100.15,42.96 99.96,43.15 99.29,43.15 99.1,43.35 99.1,43.73 99.29,43.93 99.96,43.93 100.15,44.12 100.15,44.5 99.96,44.7 99.72,44.7 99.52,44.89 99.52,45.28 99.72,45.47 99.96,45.47 100.15,45.66 100.15,46.05 99.96,46.24 99.72,46.24 99.53,46.44 99.53,46.82 99.72,47.01 99.96,47.01 100.15,47.21 100.15,47.59 99.96,47.79 99.72,47.79 99.53,47.98 99.53,48.37 99.72,48.56 99.96,48.56 100.15,48.75 100.15,49.14 99.96,49.33 99.71,49.33 99.52,49.52 99.52,49.91 99.71,50.1 99.96,50.1 100.15,50.3 100.15,50.68 99.96,50.87 99.68,50.87 99.49,51.07 99.49,51.45 99.68,51.65 99.96,51.65 100.15,51.84 100.15,52.23 99.96,52.42 99.68,52.42 99.49,52.61 99.49,53 99.68,53.19 99.96,53.19 100.15,53.38 100.15,53.77 104.64,58.26 104.64,62.74 103.95,63.44 103.95,71.72 103.71,71.96 103.71,74.3 103.71,74.31
  BOTTOM w0.076: UH1.AN8 104.76,78.3 v2(104.99,78.07)
  BOTTOM w0.185: JDIMM2.125 101.66,25.48 v2(101.72,25.42)
DDR_B_MA9: length 68.6
  IN1 w0.076: 102.93,75.02 103.04,75.13 103.04,77.01 103.69,77.66 103.69,79.32 v2(103.14,79.87)
  IN1 w0.152: v2(100.24,24.84) 100.24,25.94 99.07,27.12 99.07,27.58 98.12,28.54 98.12,28.8 97.92,29 97.66,29 97.47,29.19 97.47,29.58 97.87,29.98 97.87,30.35 97.68,30.54 97.36,30.54 97.17,30.73 97.17,31.12 97.36,31.31 97.66,31.31 97.86,31.51 97.86,31.89 97.66,32.09 97.36,32.09 97.17,32.28 97.17,32.66 97.36,32.86 98.45,32.86 98.65,33.05 98.65,33.44 98.45,33.63 97.62,33.63 97.43,33.82 97.43,34.21 97.62,34.4 97.92,34.4 98.12,34.59 98.12,39.37 97.1,40.38 97.1,40.8 97.29,41 97.31,41 97.5,41.19 97.5,41.58 97.31,41.77 97.29,41.77 97.1,41.96 97.1,52.95 103.15,59 103.15,62.81 102.93,63.03 102.93,75.02
  BOTTOM w0.076: v2(103.14,79.87) 102.76,80.25 UH1.AR11
  BOTTOM w0.185: JDIMM2.121 100.66,25.25 v2(100.24,24.84)
DDR_B_MA10: length 66.3
  IN1 w0.076: 109.13,73.64 108.61,74.15 108.61,77.95 v2(108.63,77.97)
  IN1 w0.152: 109.13,73.64 109.13,73.62 109.14,73.61 109.14,67.17 109.61,66.71 109.61,66.48 111.99,64.1 111.99,52.28 109.88,50.17 109.88,48.95 109.69,48.76 108.95,48.76 108.82,48.63 108.82,48.11 108.95,47.98 109.69,47.98 109.88,47.79 109.88,43.35 109.76,43.22 108.95,43.22 108.82,43.09 108.82,42.57 108.95,42.45 109.76,42.45 109.88,42.32 109.88,41.46 108.8,40.38 108.8,32.92 109,32.73 109.23,32.73 109.38,32.58 109.38,32.11 109.23,31.96 109,31.96 108.87,31.83 108.87,31.26 109.18,30.95 109.18,30.47 108.87,30.17 108.87,29.84 109.39,29.32 109.39,27.65 109.47,27.57 109.47,21.85 v2(108.91,21.28)
  BOTTOM w0.076: v2(108.63,77.97) 108.5,77.97 UH1.AH7
  BOTTOM w0.185: JDIMM2.146 v2(108.91,21.28)
DDR_B_MA11: length 72.8
  IN1 w0.076: 103.22,74.84 103.22,76.94 103.97,77.69 103.97,77.99 104.42,78.44 104.42,80.02 v2(104.98,80.57)
  IN1 w0.152: v2(100.85,22.71) 100.74,22.81 100.74,26.15 99.57,27.32 99.57,27.81 98.82,28.55 98.82,28.99 99.16,29.33 99.16,29.76 98.82,30.1 98.82,30.54 99.16,30.87 99.16,31.31 98.82,31.64 98.82,32.08 99.16,32.42 99.16,33.68 98.61,34.23 98.61,36.4 98.81,36.59 98.94,36.59 99.14,36.78 99.14,37.17 98.94,37.36 98.81,37.36 98.61,37.56 98.61,37.94 98.81,38.13 98.94,38.13 99.14,38.33 99.14,38.71 98.94,38.91 98.81,38.91 98.61,39.1 98.61,39.57 98.03,40.16 98.03,44.25 98.22,44.44 98.33,44.44 98.52,44.63 98.52,45.02 98.33,45.21 97.79,45.21 97.6,45.4 97.6,45.79 97.79,45.98 98.33,45.98 98.52,46.18 98.52,46.56 98.33,46.76 97.79,46.76 97.6,46.95 97.6,47.33 97.79,47.53 98.33,47.53 98.52,47.72 98.52,48.11 98.33,48.3 97.79,48.3 97.6,48.49 97.6,49.1 97.79,49.3 98.18,49.3 98.37,49.49 98.37,49.88 98.18,50.07 97.79,50.07 97.6,50.26 97.6,52.8 103.64,58.85 103.64,62.74 103.22,63.17 103.22,74.84
  BOTTOM w0.076: v2(104.98,80.57) 104.84,80.57 UH1.AN11
  BOTTOM w0.185: v2(100.85,22.71) 100.41,22.27 JDIMM2.120
DDR_B_MA12: length 67.1
  IN1 w0.076: 102.65,75.17 102.87,75.4 102.87,77.18 103.51,77.81 103.51,78.9 v2(103.15,79.26)
  IN1 w0.152: v2(100.22,23.35) 99.75,23.83 99.75,25.74 98.57,26.91 98.57,27.38 96.67,29.28 96.67,34.15 97.62,35.1 97.62,39.16 96.6,40.18 96.6,53.1 102.65,59.15 102.65,75.17
  BOTTOM w0.076: v2(103.15,79.26) 102.81,79.6 UH1.AR10
  BOTTOM w0.185: v2(100.22,23.35) 99.66,23.91 99.66,26.13 100.16,26.63 JDIMM2.119
DDR_B_MA13: length 70.4
  IN1 w0.076: v2(110.46,79.27) 109.94,78.75 109.94,77.74 110.25,77.43 110.25,74.69 110.99,73.95 110.99,71.42
  IN1 w0.152: v2(113.95,22.39) 113.75,22.39 112.9,21.55 112.09,21.55 111.81,21.83 111.81,22.27 112,22.46 112.3,22.46 112.88,23.03 112.88,23.95 112.23,24.6 112.23,25.16 112.63,25.55 112.63,28.8 112.58,28.85 112.58,32.41 112.42,32.58 112.42,34.06 112.19,34.28 112.19,39.31 113.13,40.25 113.13,48.87 116.44,52.18 116.44,63.47 110.83,69.08 110.83,71.26 110.99,71.42
  BOTTOM w0.076: v2(110.46,79.27) 110.14,78.95 UH1.AF9
  BOTTOM w0.185: JDIMM2.158 111.91,21.04 113.37,22.49 113.85,22.49 v2(113.95,22.39)
DDR_B_PAR: length 67.6
  IN1 w0.076: v2(107.72,77.97) 107.72,77.73 108.04,77.41 108.04,75.75 108.21,75.58 108.21,73.78 108.59,73.4
  IN1 w0.152: v2(109,24.15) 108.78,24.15 108.54,23.92 108.54,23.26 108.42,23.13 107.99,23.13 107.86,23.26 107.86,24.25 108.47,24.86 108.47,28.82 107.09,30.2 107.09,31.61 107.25,31.77 107.59,31.77 107.78,31.96 107.78,32.35 107.59,32.54 107.25,32.54 107.09,32.71 107.09,32.85 107.13,32.89 107.35,33.12 107.35,38.76 107.89,39.3 107.89,49.72 111.06,52.89 111.06,63.68 108.59,66.14 108.59,73.4
  BOTTOM w0.076: UH1.AJ7 107.59,77.97 v2(107.72,77.97)
  BOTTOM w0.185: v2(109,24.15) 108.57,24.15 107.24,25.47 107.24,27.08 JDIMM2.143
DDR_B_RAS#: length 67.7
  IN1 w0.076: v2(108.63,79.92) 109,79.55 109,79 109.16,78.84 109.16,77.73 109.01,77.58 109.01,74.41 109.64,73.79
  IN1 w0.152: v2(110.97,22.96) 112.1,22.96 112.34,23.2 112.34,23.77 112.07,24.04 110.66,24.04 110.47,24.24 110.47,27.92 110.34,28.05 110.34,33.2 109.8,33.74 109.8,39.96 110.88,41.04 110.88,49.75 113.64,52.5 113.64,63.75 109.64,67.75 109.64,73.79
  BOTTOM w0.076: UH1.AH10 108.5,79.92 v2(108.63,79.92)
  BOTTOM w0.185: JDIMM2.152 110.41,22.4 v2(110.97,22.96)
DDR_B_WE#: length 65.5
  IN1 w0.076: 110.09,71.38 110.46,71.75 110.46,73.29 109.21,74.54 109.21,77.54 109.33,77.66 109.33,79.08 109.18,79.23 109.18,80.03 v2(108.63,80.57)
  IN1 w0.152: 110.09,71.38 110.09,68 114.17,63.92 114.17,63.08 114.36,62.89 114.48,62.89 114.67,62.7 114.67,62.31 114.48,62.12 114.36,62.12 114.17,61.92 114.17,61.54 114.36,61.35 114.48,61.35 114.67,61.15 114.67,60.77 114.48,60.57 114.36,60.57 114.17,60.38 114.17,59.99 114.36,59.8 114.48,59.8 114.67,59.61 114.67,59.22 114.48,59.03 114.36,59.03 114.17,58.84 114.17,58.45 114.36,58.26 114.48,58.26 114.67,58.06 114.67,57.68 114.48,57.48 114.36,57.48 114.17,57.29 114.17,56.91 114.36,56.71 114.48,56.71 114.67,56.52 114.67,56.13 114.48,55.94 114.36,55.94 114.17,55.75 114.17,55.36 114.36,55.17 114.48,55.17 114.67,54.97 114.67,54.59 114.48,54.4 114.36,54.4 114.17,54.2 114.17,53.82 114.36,53.62 114.48,53.62 114.67,53.43 114.67,53.04 114.48,52.85 114.36,52.85 114.17,52.66 114.17,52.25 111.38,49.45 111.38,40.84 110.3,39.76 110.3,33.95 110.84,33.41 110.84,28.25 110.96,28.13 v2(110.96,26.32)
  BOTTOM w0.076: v2(108.63,80.57) 108.5,80.57 UH1.AH11
  BOTTOM w0.185: v2(110.96,26.32) 110.91,26.32 110.16,27.08 JDIMM2.151
DDR_CKE0_DIMMA: length 45.3
  IN4 w0.152: v2(95.9,37.19) 95.44,37.66 95.44,39.13 95.72,39.42 95.72,45.08 95.29,45.51 95.29,57.73 98.25,60.69 98.25,67.83 99.49,69.07 v2(99.57,69.07)
  BOTTOM w0.076: 100.09,69.59 100.09,69.86 100.97,70.74 100.97,72.89 101.62,73.54 UH1.AT1
  BOTTOM w0.185: 100.09,69.59 100.09,69.58 v2(99.57,69.07) ; JDIMM1.109 97.65,40.04 97.38,39.77 96.24,39.77 95.43,38.96 95.43,37.67 v2(95.9,37.19)
DDR_CKE1_DIMMA: length 45.6
  IN4 w0.152: v2(99.56,67.85) 99.31,67.85 98.73,67.27 98.73,60.38 95.81,57.45 95.81,45.72 96.24,45.29 96.24,38.81 95.94,38.51 v2(95.9,38.51)
  BOTTOM w0.076: UH1.AT2 101.91,74.09 101.91,73.6 101.18,72.86 101.18,70.6 100.72,70.15 100.72,69.59
  BOTTOM w0.185: JDIMM1.110 97.9,33.74 96.45,35.19 96.45,38.02 95.96,38.51 v2(95.9,38.51) ; v2(99.56,67.85) 100.72,69.01 100.72,69.59
DDR_CKE2_DIMMB: length 66.9
  IN1 w0.152: v2(102.23,78.01) 101.77,78.01 101.11,77.34 101.11,76.87 100,75.76 100,66.64 99.87,66.51 99.87,60.07 93.25,53.45 93.25,27.7 93.51,27.45 93.51,27.24 93.25,26.99 93.25,26.78 93.53,26.5 93.81,26.5 93.91,26.6 94.18,26.6 94.45,26.33 94.45,26.05 94.35,25.95 94.35,25.68 94.63,25.41 94.9,25.41 95.2,25.71 95.47,25.71 95.75,25.44 95.75,25.16 95.44,24.86 95.44,24.57 95.95,24.07 96.2,24.07 v2(96.55,24.42)
  BOTTOM w0.089: v2(102.23,78.01) 102.07,78.01 UH1.AT8
  BOTTOM w0.185: v2(96.55,24.42) 96.45,24.52 96.45,25.06 96.58,25.19 97.04,25.19 97.16,25.31 97.16,26.51 97.66,27 JDIMM2.109
DDR_CKE3_DIMMB: length 67.1
  IN1 w0.152: v2(96.52,23.11) 96.22,23.11 92.75,26.58 92.75,53.66 99.41,60.33 99.41,66.42 99.07,66.76 99.07,75.25 100.82,77 100.82,77.43 101.79,78.4 101.79,79.48 v2(102.23,79.92)
  BOTTOM w0.089: v2(102.23,79.92) 102.1,79.92 UH1.AT10
  BOTTOM w0.185: JDIMM2.110 97.91,21.73 v2(96.52,23.11)
DDR_CS0_DIMMA#: length 51.2
  IN4 w0.152: v2(113.49,37.67) 113.54,37.72 113.74,37.72 113.93,37.91 113.93,41.96 114.62,42.65 114.62,45.63 114.44,45.81 114.08,45.81 113.9,45.99 113.9,46.52 114.08,46.7 114.44,46.7 114.62,46.88 114.62,54.46 115.25,55.08 115.25,58.91 113.37,60.79 v2(113.14,60.79)
  BOTTOM w0.076: UH1.AD5 111.35,76.01 110.83,76.01 110.61,75.8 110.61,71.92 110.3,71.6 110.3,70.86
  BOTTOM w0.185: 110.3,70.86 110.3,62.65 112.16,60.79 v2(113.14,60.79) ; v2(113.49,37.67) 113.47,37.67 113.41,37.61 112.19,37.61 111.5,38.29 109.79,38.29 109.36,38.72 109.36,39.7 109.65,39.99 JDIMM1.149
DDR_CS1_DIMMA#: length 54.3
  IN4 w0.152: v2(113.15,62.2) 113.72,62.2 114.25,61.67 114.25,61.37 114.13,61.25 114.13,60.95 114.43,60.64 114.73,60.64 114.85,60.76 115.15,60.76 115.56,60.36 115.56,60 115.41,59.85 115.41,59.48 115.81,59.08 115.81,54.35 115.6,54.14 115.39,54.14 115.17,53.92 115.17,53.5 115.39,53.28 115.6,53.28 115.81,53.07 115.81,52.64 115.6,52.43 115.39,52.43 115.17,52.22 115.17,51.79 115.39,51.58 115.6,51.58 115.81,51.36 115.81,50.94 115.6,50.72 115.39,50.72 115.14,50.48 115.14,42.43 114.51,41.8 114.51,36.14 114.33,35.96 114.05,35.96 113.61,36.4 v2(113.45,36.4)
  BOTTOM w0.076: UH1.AE2 110.94,74.14 111.22,73.86 111.22,73.5 110.95,73.22 110.95,71.62 110.81,71.48 110.81,70.67
  BOTTOM w0.185: JDIMM1.157 111.65,40.06 112.33,39.38 113.64,39.38 113.99,39.04 113.99,36.66 113.72,36.4 v2(113.45,36.4) ; v2(113.15,62.2) 112.1,62.2 111.87,62.42 111.87,62.69 112.36,63.17 112.36,63.43 112.1,63.7 111.83,63.7 111.35,63.21 111.08,63.21 110.81,63.48 110.81,70.67
DDR_CS2_DIMMB#: length 64.3
  IN1 w0.076: 110.69,71.55 110.69,73.81 110.02,74.48 110.02,77.43 109.77,77.67 109.77,79 110.05,79.28 110.05,79.5 v2(110.44,79.89)
  IN1 w0.152: 110.69,71.55 110.42,71.29 110.42,68.52 115.65,63.29 115.65,52.56 112.31,49.21 112.31,40.6 111.36,39.65 111.36,34 111.63,33.73 111.63,32.2 111.75,32.07 111.75,28.51 111.8,28.46 111.8,25.9 v2(110.96,25.05)
  BOTTOM w0.076: UH1.AF11 110.09,80.25 v2(110.44,79.89)
  BOTTOM w0.185: JDIMM2.149 109.66,26.36 v2(110.96,25.05)
DDR_CS3_DIMMB#: length 66.9
  IN1 w0.076: 112.23,69.88 112.23,72.15 112,72.38 112,74.56 111.69,74.88 111.69,76.83 111.31,77.21 v2(111.31,77.3)
  IN1 w0.152: 112.23,69.88 118.27,63.84 118.27,49.29 115.6,46.62 115.6,40.14 114.45,38.99 114.45,32.13 114.58,32 114.58,24.29 114.84,24.03 114.84,23.4 115.29,22.95 v2(115.29,22.92)
  BOTTOM w0.076: UH1.AE7 111.26,77.3 v2(111.31,77.3)
  BOTTOM w0.185: v2(115.29,22.92) 114.68,23.53 114.68,24.9 113.47,26.1 112.78,26.1 111.66,27.22 JDIMM2.157
DDR_VTT_PG_CTRL: length 3.2
  BOTTOM w0.114: UC1.2 v3(86.05,82.46) 86.88,82.46 UH1.BT13
DGPU_HOLD_RST#: length 75.4
  IN4 w0.094: v2(161,28.23) 160.51,27.75 160.05,27.75 160.05,27.75 154.43,27.75 154.12,28.06 152.28,28.06 v2(151.9,28.44)
  BOTTOM w0.089: UH2.AL36 161.37,28.61 v2(161,28.23)
  BOTTOM w0.114: v2(151.9,28.44) 151.27,29.07 149.11,29.07 148.43,29.75 143.39,29.75 142.68,30.46 142.68,32.98 144.1,34.4 144.1,42.46 140.95,45.61 140.95,52.14 140.07,53.03 140.07,63.96 135.24,68.78 135.24,72.79 137.69,75.24 138.51,75.24 139.5,76.24 RV58.2 140.28,76.3 v3(141.36,76.3) UV14.1
DGPU_PEX_RST#: length 59.1
  TOP w0.114: v2(171.47,60.21) 173.07,60.21 174.67,61.81 174.67,63.32 173.76,64.23 173.76,65.14 173.94,65.32 UV22.2 ; v2(157.31,72.05) 157.62,72.35 RV571.1 RV573.1 156.45,72.47 UV18.4
  IN1 w0.094: v2(146.92,80.42) 146.92,80.36 146.98,80.3 146.98,78.25 146.8,78.07 146.8,75.98 147.99,74.79 147.99,72.38 148.45,71.92 157.18,71.92 v2(157.31,72.05) 159.09,72.05 159.4,72.36 165.65,72.36 166.77,71.23 166.77,70.58 166.98,70.37 168.83,70.37 169.7,69.49 169.7,61.98 v2(171.47,60.21)
  BOTTOM w0.114: RV208.2 RV609.1 RV40.1 148.99,80.46 RV39.2 148.98,80.55 148.37,81.16 147.2,81.16 146.92,80.88 v2(146.92,80.42)
DGPU_PEX_RST#_R: length 13
  BOTTOM w0.114: RV40.2 151.12,80.86 v3(151.72,80.86) 152.22,80.86 152.26,80.83 152.93,80.83 153.93,79.83 155.65,79.83 155.89,80.08 155.89,81.19 156.13,81.43 156.34,81.43 156.66,81.75 156.66,82.01 156.99,82.33 158.04,82.33 158.37,82.65 158.37,82.86 158.48,82.98 158.48,84.09 158.37,84.21 158.37,84.83 UV1.AJ12
DGPU_PWR_EN: length 332.8
  TOP w0.114: RH129.1 157.9,29.71 158.06,29.87 159.49,29.87 v2(160,29.35) 160,29.28 160.41,28.87 162.21,28.87 163.11,27.97 RH127.1 163.25,28.34 162.68,28.9 162.68,29.75 162.93,29.99 163.1,29.99 163.56,30.45 163.56,32.53 162.14,33.95 161.02,33.95 159.31,35.66 158.65,35.66 158.38,35.93 156.28,35.93 155.78,36.44 153.76,36.44 153.36,36.04 v2(150.12,36.04) ; QZ12.2 153.16,80.37 153.45,80.66 v2(153.45,81.17) ; v2(142.61,65.98) 143.51,66.88 143.51,72.32 143.22,72.61 143.22,73.7 144.01,74.49 145.93,74.49 v2(145.93,74.5)
  IN1 w0.094: v2(142.61,65.98) 142.45,65.83 142.45,64.89 140.39,62.82 140.39,46.07 150.12,36.33 v2(150.12,36.04) ; v2(210.45,113.66) 210.45,113.4 209.36,112.32 204.73,112.32 201.68,115.37 200.99,115.37 197.88,118.48 196.99,118.48 195.97,119.5 192.54,119.5 190.51,121.53 190.51,124.7 188.6,126.61 188.6,132.07 187.78,132.89 154.12,132.89 153.38,132.15 153.38,123.62 150.68,120.92 148.4,120.92 147.13,119.65 147.13,118.02 147.27,117.88 147.27,113.39 146.57,112.69 146.57,111.78 147.23,111.12 148.96,111.12 149.43,110.65 149.43,109.51 146.83,106.92 144.82,106.92 v2(144.28,107.46)
  IN3 w0.127: v2(145.93,74.5) 146.53,75.1 146.53,79.71 146.11,80.13 v2(146.11,81.74) 145.65,82.2 145.65,82.9 143.19,85.36 143.19,97.47 142.5,98.16 142.5,101.23 144.28,103.01 v2(144.28,107.46)
  IN4 w0.094: v2(150.12,36.04) 150.13,36.04 150.61,36.52 152.84,36.52 154.59,38.27 155.66,38.27 157.47,40.08 157.47,42.11 158.81,43.44 163.2,43.44 163.62,43.86 168.59,43.86 168.89,44.16 168.89,44.92 169.48,45.51 170.01,45.51 171.66,43.86 176.32,43.86 178.43,41.75 178.43,41.3 180.34,39.39 180.79,39.39 181.82,38.36 187.21,38.36 187.42,38.57 188.08,38.57 189.11,37.54 190.59,37.54 191.54,36.59 193.73,36.59 194.64,37.5 194.64,50.42 v2(194.28,50.78)
  BOTTOM w0.076: UH2.AJ39 159.82,29.53 v2(160,29.35)
  BOTTOM w0.114: v2(153.45,81.17) 152.47,81.17 152.45,81.2 151.02,81.2 150.82,81 149.03,81 148.46,81.57 v3(147.71,81.57) 147.24,81.57 147.03,81.37 146.49,81.37 v2(146.11,81.74) ; PR1011.1 210.96,114.16 v2(210.45,113.66) ; v2(194.28,50.78) 192.34,50.78 186.13,56.99 186.13,57.95 185.39,58.69 180.3,58.69 179.36,59.63 179.36,60.39 177.91,61.84 177.91,66.58 177.4,67.08 175.37,67.08 174.53,67.92 173.95,67.92 173.73,67.71 173.73,66.74 174.05,66.42 174.55,66.42 175.14,65.83 UV23.1
DGPU_PWR_EN#: length 7.5
  TOP w0.114: QZ12.6 153.81,78.51 153.49,78.83 152.46,78.83 152.09,78.46 152.09,77.91 152.12,77.88 152.12,77.35 152.3,77.18 RV399.1 152.22,76.32 RV534.2 151.73,75.23 151.73,74.75 151.37,74.39 v3(151.08,74.39)
DGPU_PWR_EN#_R: length 1.9
  TOP w0.114: RV399.2 153.21,77.17 CV499.1 153.16,77.22 QZ12.5
DGPU_PWRGD_EC: length 59.9
  TOP w0.114: RH500.1 167.9,19.78 v2(167.75,19.93) ; UE1.24 219.17,20.94 v2(218.64,20.41)
  IN1 w0.094: v2(167.75,19.93) 167.98,19.7 168.74,19.7 170.38,18.05 178.13,18.05 178.51,17.67 183.07,17.67 183.5,18.11 188.12,18.11 188.72,17.51 197.52,17.51 200.04,20.03 210.3,20.03 211.81,21.54 213.19,21.54 213.9,20.84 218.21,20.84 v2(218.64,20.41)
  BOTTOM w0.076: UH2.BD24 167.59,22.35 167.59,21.76 167.8,21.55 167.8,19.98 v2(167.75,19.93)
DGPU_PWROK: length 116
  TOP w0.114: RH86.2 155.1,31.05 156.94,31.05 157.86,30.14 160.18,30.14 160.61,29.71 v2(160.61,29.33) ; UV19.2 149.3,73.03 149.03,72.76 149.03,72.13 148.68,71.77 147.08,71.77 v2(146.3,72.55)
  IN1 w0.094: v2(160.61,29.33) 160.6,29.33 160.07,29.86 154.42,29.86 153.68,30.6 153.01,30.6 150.76,32.85 150.76,35.97 140.59,46.15 140.59,62.45 143.01,64.88 143.01,66.92 144.8,68.7 144.8,71.71 145.4,72.31 146.07,72.31 v2(146.3,72.55) 146.3,72.78 145.9,73.18 145.39,73.18 144.18,74.4 144.18,74.9 143.02,76.06 143.02,79.11 143.91,80.01 143.91,80.59 145.17,81.85 145.17,82.26 144.88,82.55 144.46,82.55 143.08,83.94 v2(143.08,99.54)
  BOTTOM w0.089: v2(160.61,29.33) 160.59,29.36 UH2.AJ38
  BOTTOM w0.114: PR900.2 144.69,109.79 144.69,107.29 144.53,107.13 v4(144.53,100.51) 143.56,99.54 v2(143.08,99.54)
  BOTTOM w0.254: PU900.1 141.81,111.2 142.02,110.99 143.65,110.99 144.18,110.45 PR900.2
DH1_NVVDD: length 25.8
  IN4 w0.635: 173.95,57.17 169.47,57.17 ; 169.47,57.17 169.47,56.11 v2(169.48,56.1) ; 169.47,57.17 156.18,57.17 156.12,57.1 156.11,57.1 154.7,55.69 154.7,51.78
  BOTTOM w0.203: PU1600.2 175.24,57.02 v2(174.94,57.32)
  vias: v2(154.19,50.87) v2(155.05,50.87) v2(168.84,56.1) v2(174.53,57.75) v3(169.58,55.51)
DH1_NVVDDS: length 14.5
  IN4 w0.635: 200.16,62.17 200.16,60.15 201.86,58.45 201.86,56.34 201.65,56.12 201.65,54.33 ; 200.42,62.42 205.34,62.42
  BOTTOM w0.127: v2(206,62.47) v4(206,61.51)
  vias: v2(200.42,63.67) v2(200.42,63.06) v2(202.09,53.97) v2(202.55,53.53) v2(205.37,62.47)
DH2_NVVDD: length 34.5
  TOP w0.127: v2(174.58,51.78) 174.58,51.77 v4(173.87,51.06)
  IN1 w0.635: v2(150.72,50.84) 151.6,50.84 154.37,48.07 160.84,48.07 161.91,49.14 166.51,49.14 166.81,49.44 169.4,49.44 170.84,50.88 173.38,50.88 174.25,51.76 174.63,51.76 ; v2(151.65,55.87) v2(150.96,55.87) 150.33,55.87 149.51,55.06 149.51,51.27 v2(149.95,50.84)
  vias: v2(174.86,52.34)
DH_CHG: length 24.2
  TOP w0.114: v2(29.35,33.7) v4(29.35,33.07)
  IN1 w0.635: 29.35,33.01 29.35,31.87 27.65,30.17 27.65,29.01 31.7,24.96 31.7,18.9 30.95,18.15 v2(25.66,18.15) v2(24.9,18.15)
  vias: v2(29.35,34.28)
DISPOFF#: length 10
  TOP w0.114: UZ23.1 66.7,29.66 66.54,29.82 64.84,29.82 64.52,29.5 63.26,29.5 RV536.1 ; RV536.1 62.49,29.96 61.85,30.61 v3(61.47,30.61) 61.1,30.98 v2(61.1,31.23) ; RV536.1 RV566.2
  BOTTOM w0.114: JEDP1.17 61.88,32.01 v2(61.1,31.23)
DL1_NVVDD: length 19.7
  TOP w0.127: v2(172.6,56.2) v4(172.6,56.94)
  IN1 w0.508: 162.86,57.01 163.03,56.85 v2(163.03,56.23)
  IN1 w0.635: 172.17,56.61 171.76,57.01 160.72,57.01 160.06,56.35 160.06,51.15 v2(159.83,50.92)
  vias: v2(160.51,50.92) v2(162.42,56.2) v2(173.09,55.79)
DL1_NVVDDS: length 19.4
  IN1 w0.635: 204.63,56.63 204.63,58.05 207.05,60.47 207.05,63.49 206.31,64.23 206.31,68.32 205.85,68.77 201.08,68.77
  BOTTOM w0.127: v2(205.72,69.61) v4(205.72,70.6)
  vias: v2(200.37,69.33) v2(200.37,68.75) v2(204.63,55.95) v2(204.63,55.36) v2(205.11,69.61)
DL2_NVVDD: length 35.9
  TOP w0.127: v2(173.03,54.09) v4(173.85,54.09)
  IN3 w0.635: 145.45,50.92 148.79,50.92 150.59,49.11 168.39,49.11 171.59,52.31 171.59,52.77 172.45,53.63 ; 144.78,56 144.78,52.02
  BOTTOM w0.203: PU1600.17 173.47,54.53 v2(173.03,54.09)
  vias: v2(144.26,56.61) v2(144.71,50.79) v2(144.84,56.89) v2(144.97,51.32) v2(172.58,53.63)
DL_CHG: length 13.5
  TOP w0.114: v2(31.25,33.9) v4(31.25,33.15)
  IN4 w0.635: 30.62,33.01 29.22,33.01 28.01,31.8 28.01,28.63 26.93,27.55 v2(22.74,27.55) v2(22.03,27.55)
  vias: v2(30.87,34.41)
DMI_CRX_PTX_N0: length 73.5
  TOP w0.114: v2(125.93,78.45) 126.15,78.23 126.15,78.05 126.43,77.77 127.53,77.77 130.04,75.26 130.04,73.86 133.6,70.3 141.45,62.45 141.45,47.13 144.06,44.52 144.27,44.52 147.94,44.52 152.22,48.8 164.94,48.8 167.5,46.24 167.5,45.39 v2(167.35,45.24)
  BOTTOM w0.076: UH1.E8 125.61,78.12 v2(125.93,78.45) ; v2(167.35,45.24) 167.48,45.11 167.48,44.68 166.92,44.13 166.65,44.13 166.36,43.84 166.36,43.78 166.06,43.48 166.02,43.48 165.89,43.35 165.89,43.06 UH2.C27
DMI_CRX_PTX_N1: length 71.4
  TOP w0.114: v2(125.33,77.66) 125.73,77.27 126.8,77.27 129.28,74.79 129.28,73.43 140.79,61.91 140.79,46.88 143.86,43.81 148.36,43.81 152.71,48.16 164.5,48.16 166.27,46.39 166.27,45.53 v2(166.23,45.48)
  BOTTOM w0.076: UH1.F6 v2(125.33,77.66) ; v2(166.23,45.48) 166.29,45.42 166.29,44.55 165.5,43.76 165.5,43.41 165.63,43.29 UH2.B28
DMI_CRX_PTX_N2: length 69.3
  TOP w0.114: v2(125.92,76.88) 125.93,76.87 125.93,76.87 126.16,76.64 126.16,76.47 127.37,75.26 127.37,74.39 140.14,61.63 140.14,46.62 143.66,43.1 148.71,43.1 v1(151.2,45.6) 153.12,47.52 163.43,47.52 165.13,45.81 165.13,45.41 v2(165,45.28)
  BOTTOM w0.076: UH1.E5 125.92,76.79 v2(125.92,76.88) ; UH2.B29 165.12,43.14 164.99,43.02 164.93,43.02 164.81,43.14 164.81,43.26 165.1,43.56 165.1,43.89 165.38,44.17 165.38,44.49 165.33,44.55 165.33,44.77 165.22,44.88 165.22,45.06 v2(165,45.28)
DMI_CRX_PTX_N3: length 71.7
  TOP w0.114: v2(123.92,79.26) 124.11,79.07 124.22,79.07 124.9,78.4 124.9,78.29 124.94,78.24 124.94,77.37 125.36,76.96 125.36,75.75 139.65,61.45 139.65,46.51 143.5,42.66 148.89,42.66 153.33,47.1 163.14,47.1 164.57,45.66 164.57,45.07 164.82,44.82 164.82,44.56 v2(164.97,44.41)
  BOTTOM w0.076: UH1.J9 123.61,78.95 v2(123.92,79.26) ; v2(164.97,44.41) 164.84,44.29 164.84,43.6 164.5,43.26 UH2.B30
DMI_CRX_PTX_P0: length 73.5
  TOP w0.114: v2(167.94,45.25) 167.72,45.47 167.72,46.34 165.03,49.02 152.13,49.02 147.85,44.74 144.15,44.74 141.67,47.22 141.67,62.55 130.26,73.95 130.26,75.35 127.63,77.99 126.53,77.99 126.37,78.15 126.37,78.24 v2(126.58,78.45)
  BOTTOM w0.076: v2(167.94,45.25) 167.88,45.25 167.65,45.02 167.65,44.62 166.99,43.96 166.71,43.96 166.53,43.77 166.53,43.71 166.37,43.55 166.37,43.45 166.52,43.29 166.52,43.16 166.42,43.06 166.29,43.06 166.12,43.23 UH2.B27 ; v2(126.58,78.45) 126.26,78.12 UH1.D8
DMI_CRX_PTX_P1: length 71.4
  TOP w0.114: v2(166.82,45.49) 166.94,45.61 166.94,45.81 166.79,45.96 166.58,45.96 166.49,46.04 166.49,46.48 164.6,48.38 152.62,48.38 148.27,44.03 143.95,44.03 141.02,46.97 141.02,62.01 129.5,73.52 129.5,74.88 127.53,76.85 127.52,76.85 127.52,76.85 126.89,77.48 126.11,77.48 v2(125.93,77.66)
  BOTTOM w0.076: v2(125.93,77.66) 125.93,77.59 UH1.E6 ; UH2.A28 165.77,43.58 165.88,43.58 165.98,43.69 165.98,43.76 165.89,43.86 165.89,43.91 166.46,44.48 166.46,45 166.56,45.11 166.89,45.11 166.96,45.18 166.96,45.35 v2(166.82,45.49)
DMI_CRX_PTX_P2: length 69.3
  TOP w0.114: v2(165.59,45.28) 165.36,45.51 165.36,45.91 163.52,47.74 153.03,47.74 151.25,45.96 151.22,45.96 150.84,45.58 150.84,45.55 148.61,43.32 143.75,43.32 140.36,46.72 140.36,61.72 127.59,74.48 127.59,75.35 126.39,76.56 126.39,76.69 v2(126.57,76.88)
  BOTTOM w0.076: UH2.C29 165.12,42.82 165.37,43.08 165.37,43.3 165.27,43.41 165.27,43.82 165.55,44.1 165.55,44.56 165.49,44.62 165.49,44.84 165.39,44.95 165.39,45.08 v2(165.59,45.28) ; v2(126.57,76.88) 126.57,76.87 126.26,76.56 UH1.D5
DMI_CRX_PTX_P3: length 71.7
  TOP w0.114: v2(123.99,78.45) 123.86,78.57 123.86,78.76 123.96,78.86 124.13,78.86 124.68,78.31 124.68,78.2 124.73,78.15 124.73,77.28 125.14,76.88 125.14,75.66 139.43,61.36 139.43,46.42 143.41,42.44 148.99,42.44 153.42,46.87 163.05,46.87 164.35,45.57 164.35,44.97 164.6,44.72 164.6,44.61 164.4,44.42 v2(164.38,44.42)
  BOTTOM w0.076: v2(164.38,44.42) 164.19,44.23 164.19,44.12 164.27,44.04 164.57,44.04 164.67,43.94 164.67,43.67 164.62,43.61 UH2.A30 ; UH1.J8 123.67,78.45 v2(123.99,78.45)
DMI_CTX_PRX_N0: length 77.1
  TOP w0.114: v2(165.74,39.23) 165.9,39.23 166.05,39.08 166.05,38.98 165.9,38.83 165.26,38.83 164.98,38.55 164.98,37.38 164.53,36.92 161.93,36.92 161.44,37.42 145.08,37.42 135.52,46.98 135.52,61.04 136.29,61.82 136.94,61.82 v2(137.17,61.59)
  BOTTOM w0.076: 129.24,78.33 129.18,78.39 127.94,78.39 127.85,78.29 127.85,78.15 127.94,78.05 UH1.A8
  BOTTOM w0.102: v2(165.74,39.23) 166.23,38.75 UH2.L27
  BOTTOM w0.114: 129.24,78.33 130.04,78.33 132.2,76.17 v1(132.2,74.02) 132.2,64.85 135.27,61.77 136.99,61.77 v2(137.17,61.59)
DMI_CTX_PRX_N1: length 74
  TOP w0.114: v2(137.13,59.57) 137.03,59.67 137.03,59.85 137.19,60 138.29,60 138.78,59.52 138.78,46.17 143.19,41.75 153.04,41.75 153.49,41.29 157.03,41.29 158.76,43.02 165.29,43.02 166.43,41.88 167.23,41.88 167.38,41.73 167.38,41.23 167.15,41.01 166.94,41.01 166.81,41.14 v2(166.81,41.38)
  BOTTOM w0.076: UH1.B6 127.39,77.27 127.31,77.34 127.31,77.54 127.37,77.59 128.91,77.59 129.23,77.26 129.3,77.26 ; v2(166.81,41.38) 166.98,41.38 UH2.E24
  BOTTOM w0.114: v2(137.13,59.57) 137.13,59.86 136.97,60.03 135.82,60.03 131.41,64.44 131.41,75.39 129.53,77.26 129.3,77.26
DMI_CTX_PRX_N2: length 69.7
  TOP w0.114: v2(165.77,40.62) 165.47,40.91 165.14,40.91 164.94,41.12 164.94,41.45 164.59,41.8 162.32,41.8 162.04,41.52 158.33,41.52 157.36,40.55 152.61,40.55 152.12,41.04 142.99,41.04 137.37,46.66 137.37,52.95 138.09,53.67 138.09,57.61 137.88,57.82 137.26,57.82 137.13,57.7 v2(137.13,57.5)
  BOTTOM w0.076: 129.3,76.3 129.26,76.3 128.74,76.82 128.17,76.82 128.1,76.75 128.1,76.61 UH1.A5
  BOTTOM w0.101: UH2.G27 v2(165.77,40.62)
  BOTTOM w0.114: 129.3,76.3 129.42,76.3 130.7,75.03 130.7,63.58 136.33,57.95 137.13,57.95 137.25,57.83 137.25,57.62 v2(137.13,57.5)
DMI_CTX_PRX_N3: length 70.2
  TOP w0.114: v2(137.14,56.32) 136.98,56.16 136.62,56.16 136.32,55.85 136.32,46.81 143.1,40.03 147,40.03 148.63,38.39 155.57,38.39 156.1,38.93 160.8,38.93 161.95,37.79 163.72,37.79 164.04,38.1 164.04,38.45 164.12,38.53 164.36,38.53 164.4,38.5 v2(164.5,38.4)
  BOTTOM w0.076: UH1.B4 126.97,75.77 126.88,75.85 126.88,76 127,76.12 127.34,76.12 127.55,75.9 127.67,75.9 127.96,76.19 128.69,76.19 129.23,75.64 129.26,75.64 129.3,75.61
  BOTTOM w0.089: v2(164.5,38.4) 164.79,38.69 UH2.L29
  BOTTOM w0.114: v2(137.14,56.32) 136.98,56.16 136.68,56.16 130.13,62.7 130.13,74.77 129.3,75.61
DMI_CTX_PRX_P0: length 77.1
  TOP w0.114: v2(165.74,38.34) 165.74,38.39 165.54,38.6 165.36,38.6 165.21,38.45 165.21,37.29 164.62,36.7 161.84,36.7 161.34,37.2 144.99,37.2 135.3,46.89 135.3,61.14 136.2,62.04 136.99,62.04 v2(137.17,62.22)
  BOTTOM w0.076: 129.3,78.55 127.88,78.55 127.68,78.36 127.68,78.18 UH1.B8
  BOTTOM w0.102: v2(165.74,38.34) 165.95,38.34 166.23,38.06 UH2.N27
  BOTTOM w0.114: v2(137.17,62.22) 136.94,61.99 135.37,61.99 132.42,64.94 132.42,73.73 132.43,73.74 132.43,74.31 132.42,74.32 132.42,76.27 130.13,78.55 129.3,78.55
DMI_CTX_PRX_P1: length 74.1
  TOP w0.114: v2(137.14,60.42) 137.34,60.22 138.39,60.22 139,59.61 139,46.26 143.29,41.97 153.13,41.97 153.59,41.51 156.94,41.51 158.67,43.24 165.38,43.24 166.52,42.1 167.32,42.1 167.6,41.82 167.6,41.14 167.25,40.78 166.98,40.78 v2(166.81,40.62)
  BOTTOM w0.076: UH1.C6 127.08,77.27 127.15,77.34 127.15,77.6 127.3,77.75 128.98,77.75 129.24,77.49 129.3,77.49
  BOTTOM w0.101: UH2.G24 v2(166.81,40.62)
  BOTTOM w0.114: v2(137.14,60.42) 136.98,60.25 135.92,60.25 131.63,64.53 131.63,75.48 129.62,77.49 129.3,77.49
DMI_CTX_PRX_P2: length 69.6
  TOP w0.114: v2(137.14,58.38) 137.14,58.16 137.25,58.05 137.97,58.05 138.31,57.7 138.31,53.57 137.6,52.86 137.6,46.75 143.08,41.27 152.21,41.27 152.7,40.78 157.27,40.78 158.24,41.74 161.94,41.74 162.22,42.02 164.68,42.02 165.16,41.54 165.16,41.21 165.24,41.14 165.52,41.14 v2(165.77,41.38)
  BOTTOM w0.076: 129.3,76.53 129.27,76.53 128.81,76.99 128.1,76.99 127.6,76.48 UH1.B5
  BOTTOM w0.101: UH2.E26 v2(165.77,41.38)
  BOTTOM w0.114: 129.3,76.53 129.52,76.53 130.92,75.13 130.92,63.68 136.42,58.18 136.93,58.18 v2(137.14,58.38)
DMI_CTX_PRX_P3: length 70.2
  TOP w0.114: v2(164.51,39.23) 164.69,39.05 164.69,38.92 164.56,38.79 164.06,38.79 163.81,38.54 163.81,38.19 163.63,38.01 162.04,38.01 160.9,39.16 156.01,39.16 155.47,38.62 148.72,38.62 147.09,40.25 143.19,40.25 136.54,46.9 136.54,55.76 136.72,55.93 136.98,55.93 137.14,55.78 v2(137.14,55.65)
  BOTTOM w0.076: UH1.D4 126.74,75.45 127.45,75.45 128.03,76.02 128.62,76.02 129.12,75.52 129.12,75.51 129.13,75.5 129.13,75.47 129.13,75.47 129.13,75.46 129.14,75.45
  BOTTOM w0.089: v2(164.51,39.23) 164.57,39.17 164.77,39.17 UH2.K29
  BOTTOM w0.114: v2(137.14,55.65) 137.14,55.75 136.96,55.93 136.58,55.93 129.91,62.61 129.91,74.68 129.14,75.45
DMIC_CLK: length 46.3
  TOP w0.114: v2(271.54,26.57) 271.76,26.34 RA28.1 CA30.1 272.22,24.57 DA1.2 272.81,24.44 272.91,24.54 RA37.2
  IN1 w0.094: v2(271.54,26.57) 271.39,26.72 271.39,27.03 271.13,27.3 270.58,27.3 269.85,26.56 267.42,26.56 267.34,26.48 262.93,26.48 262.58,26.14 256.59,26.14 255.38,24.93 251.54,24.93 251.06,25.42 251.06,25.67 v2(251.23,25.84)
  BOTTOM w0.114: v2(251.23,25.84) 250.97,26.1 250.97,26.43 250.56,26.84 250.05,26.84 248.73,26.84 248.39,27.17 248.39,32.41 247.07,33.73 243.78,33.73 242.83,34.69 241.46,34.69 241.18,34.97 241.18,36.21 241.69,36.72 EC5206.1 RZ41.2
DMIC_CLK_CAM: length 7.5
  BOTTOM w0.114: JCAM1.3 239.02,42.94 238.67,42.59 238.67,39.86 238.99,39.54 239.61,39.54 239.62,39.54 v1(240.67,39.54) 241,39.54 241.28,39.26 241.28,38.95 RZ41.1
DMIC_CLK_R: length 5.6
  TOP w0.114: RA28.2 273.71,25.77 276.03,25.77 276.54,26.28 v3(276.77,26.28) 277.68,26.28 277.81,26.15 HDA1.3
DMIC_DAT: length 47.9
  TOP w0.114: RA36.2 271.33,24.41 DA1.3 271.35,24.68 270.95,25.09 v3(270.95,25.29) v2(270.95,26.58) 271.6,27.23 RA27.1
  IN1 w0.094: v2(250.59,25.84) 250.83,25.6 250.83,25.34 251.43,24.74 255.51,24.74 256.71,25.93 262.65,25.93 263.01,26.29 267.45,26.29 267.5,26.34 269.97,26.34 270.69,27.05 271.03,27.05 271.15,26.93 271.15,26.78 v2(270.95,26.58)
  BOTTOM w0.114: RZ42.2 EC5205.1 240.21,36.3 240.21,34.98 240.78,34.41 242.78,34.41 243.69,33.5 246.94,33.5 248.17,32.27 248.17,27.08 248.64,26.62 250.47,26.62 250.75,26.34 250.75,26 v2(250.59,25.84)
DMIC_DATA_CAM: length 7.6
  BOTTOM w0.114: JCAM1.4 238.02,43.01 238.44,42.59 238.44,39.77 238.9,39.31 v1(239.24,39.31) 240.91,39.31 241.06,39.16 241.06,38.93 RZ42.1
DMIC_DATA_R: length 7.4
  TOP w0.114: HDA1.2 277.42,26.55 277.31,26.66 CA62.1 274.85,26.09 274.28,26.09 RA27.2 272.92,27.45 272.92,28.41 v3(273.1,28.59)
E51_TX1: length 5.6
  TOP w0.114: RN3.2 196.63,29.25 196.63,30.42 v3(196.61,30.44) 196.61,31.02 v2(196.25,31.37)
  BOTTOM w0.114: JNGFF1.36 195.06,30.22 195.2,30.36 195.41,30.36 195.65,30.6 195.65,30.77 v2(196.25,31.37)
E51_TX2: length 4.8
  TOP w0.114: RN5.2 195.15,29.59 RN4.1 195.23,29.66 v2(195.23,30.77)
  BOTTOM w0.114: JNGFF1.30 193.56,30.19 194.14,30.77 v2(195.23,30.77)
EAPD#: length 4.9
  TOP w0.114: HDA1.4 277.44,25.76 v2(277.4,25.8)
  BOTTOM w0.114: D2.3 275.98,27.47 RA70.1 277.19,26.96 v3(277.43,26.72) 277.47,26.69 277.47,25.86 v2(277.4,25.8)
EC_AGND: length 13.6
  TOP w0.203: UE1.112 v2(228.25,32.99)
  BOTTOM w0.508: CE81.2 227.71,27.5 RE67.2 ; CE81.2 229.69,28.32 RE14.1 CE98.2 228.48,28.74 227.95,29.28 227.95,30.65 228.23,30.93 RE124.1 228.25,31.28 CE104.2 228.25,32.98 v2(228.25,32.99) ; CE81.2 229.09,27.5 v4(230.12,26.47) 230.54,26.05 231.12,26.05 CE87.2
EC_MUTE#: length 70.8
  TOP w0.114: v2(273.75,28.95) 274.48,29.68 RA23.2 275.6,29.28 276.31,28.57 279.11,28.57 279.51,28.16 HDA1.47
  IN3 w0.127: v2(226.37,24.32) 226.73,24.68 229.17,24.68 229.49,25 229.49,25.49 230.27,26.28 231.15,26.28 232.29,27.42 236.6,27.42 238.11,28.93 244.03,28.93 246.18,31.08 256.39,31.08 260.77,35.45 v2(262.53,35.45)
  BOTTOM w0.114: v2(262.53,35.45) 262.53,34.21 266.88,29.87 268.45,29.87 268.83,30.25 268.83,31.01 269.06,31.24 270.86,31.24 272.69,29.4 273.29,29.4 v2(273.75,28.95) 274.2,29.4 D2.2 ; RE58.2 225.18,27.81 225.31,27.68 225.54,27.68 v3(226.37,26.84) v2(226.37,24.32)
EC_MUTE#_R: length 4
  TOP w0.114: v3(224.9,33.3) 225.45,32.75 UE1.119 225.45,30.43 v2(225.49,30.39)
  BOTTOM w0.114: RE58.1 225.18,30.09 v2(225.49,30.39)
EC_SPI_CLK: length 3.4
  TOP w0.114: UE1.32 218.99,17.74 v3(218.39,17.14) 218.34,17.08 RE40.2
EC_SPI_CLK_R: length 74.5
  TOP w0.114: v2(162.44,17.22) 161.59,17.22 161.48,17.34 161.48,17.71 161.6,17.83 162.79,17.83 162.96,18.01 162.96,18.63 163.08,18.75 163.39,18.75 163.51,18.63 163.51,17.62 163.74,17.39 164.03,17.39 164.15,17.26 164.15,16.88 164.03,16.75 163.84,16.75 163.73,16.64 163.73,16.23 163.84,16.12 164.18,16.12 164.28,16.01 164.28,15.53 165.61,14.21 168,14.21 v4(168.89,13.32) 172.54,9.68 172.82,9.68 173.36,9.13 173.36,8.91 173.77,8.5 174.1,8.5 174.25,8.35 174.25,7.97 174.1,7.81 172.91,7.81 172.55,8.17 172.55,9.21 v2(172.6,9.26) ; v2(215.58,16.73) 215.93,17.08 RE40.1
  IN1 w0.094: v2(215.58,16.73) 214.72,15.87 200.7,15.87 198.31,13.49 196.33,13.49 194.97,12.13 184.97,12.13 182.38,9.53 178.62,9.53 178.31,9.21 172.65,9.21 v2(172.6,9.26)
  BOTTOM w0.114: v2(162.44,17.22) 162.32,17.35 RH507.2 ; RE126.1 172.15,9.26 v2(172.6,9.26)
EC_SPI_CS#: length 5
  TOP w0.114: v3(218.4,21.11) 217.55,21.11 RE59.2 217.13,20.68 218.14,19.67 219.27,19.67 219.34,19.74 UE1.27
EC_SPI_CS#_R: length 67.4
  TOP w0.114: v2(212.1,17.26) 211.68,17.69 211.68,18.17 213.99,20.49 216.01,20.49 RE59.1 ; v2(180.62,10.01) 177.66,7.05 172.76,7.05 171.76,8.05 171.76,9.58 171.65,9.69 170.43,9.69 169.88,10.23 169.87,10.23 169.02,11.09 168.67,11.42 168.64,11.45 168.54,11.56 168.44,11.65 168.44,11.65 v4(166.97,13.12) 165.16,13.12 v2(163.4,14.89)
  IN1 w0.094: v2(180.62,10.01) 180.62,10.41 185.17,14.96 188.81,14.96 189.27,15.42 198.58,15.42 200.2,17.03 211.87,17.03 v2(212.1,17.26)
  BOTTOM w0.076: 163.36,14.85 v2(163.4,14.89)
  BOTTOM w0.114: RH101.2 163.14,14.63 163.36,14.85 ; v2(180.62,10.01) 180.62,11.05 181.11,11.55 UH8.1
EC_SPI_SI: length 5.7
  TOP w0.114: v3(214.96,19.33) 216.66,19.33 RE41.2 217.65,19.28 219.26,19.28 219.32,19.34 UE1.28
EC_SPI_SI_R: length 73.4
  TOP w0.114: RE41.1 213.95,19.8 212.16,18 v2(212.09,18)
  IN1 w0.094: v2(177.05,9.69) 177.68,10.33 179.58,10.33 184.61,15.36 188.64,15.36 189.1,15.81 198.41,15.81 200.03,17.43 211.52,17.43 v2(212.09,18)
  BOTTOM w0.114: RH509.2 164.69,17.66 164.69,16.56 164.93,16.32 164.93,16.04 164.69,15.8 v4(164.69,15.55) 164.69,15.42 164.91,15.2 164.91,14.93 164.69,14.71 164.69,14.41 166.27,12.83 167.39,12.83 167.79,12.44 168.01,12.44 168.2,12.63 168.49,12.63 168.66,12.47 168.66,12.31 168.36,12 168.36,11.84 168.52,11.68 168.68,11.68 169.57,12.57 169.75,12.57 169.95,12.37 169.95,12.19 169.07,11.32 169.07,11.14 169.27,10.94 169.45,10.94 170.33,11.81 170.51,11.81 170.71,11.61 170.71,11.43 170.06,10.79 170.06,9.86 170.19,9.74 171.18,9.74 171.36,9.56 171.36,9.39 171.1,9.13 170.7,9.13 170.57,9.01 170.57,7.57 170.79,7.36 RE128.1 171.33,7.36 171.84,6.85 175.14,6.85 177.05,8.75 v2(177.05,9.69)
EC_SPI_SO: length 3.1
  TOP w0.114: RE42.2 218.55,18.86 v3(218.56,18.87) 219.3,18.87 219.36,18.94 UE1.29
EC_SPI_SO_R: length 70.6
  TOP w0.114: RE42.1 216.02,18.67 215.23,18.67 v2(214.58,18.02)
  IN1 w0.094: v2(184.26,12.33) 184.26,13.49 185.33,14.56 188.97,14.56 189.43,15.02 198.83,15.02 200.29,16.47 213.81,16.47 214.58,17.25 v2(214.58,18.02)
  BOTTOM w0.114: RH508.2 164.13,17.91 164.13,14.38 v4(164.91,13.6) 166.2,12.31 167.3,12.31 169.64,9.96 169.64,9.27 170.11,8.81 170.11,7.26 170.94,6.43 183.84,6.43 184.4,6.99 184.4,8.54 185.01,9.15 185.01,10.92 RE127.1 185.23,11.37 v2(184.26,12.33)
EC_WAKE#: length 59.6
  TOP w0.114: v3(175.02,12.98) 175.32,12.68 v2(175.32,12.6) ; UE1.35 222.65,17.95 221.92,18.68 221.92,20.03 221.52,20.42 v2(221.52,20.63)
  IN4 w0.094: v2(175.32,12.6) 175.32,13.01 176.04,13.73 179.15,13.73 183.18,17.76 188.16,17.76 188.98,16.95 193.63,16.95 197.08,20.4 197.08,20.71 197.3,20.93 198.32,20.93 199.93,22.54 214.35,22.54 214.79,22.09 216.94,22.09 217.63,21.41 219.49,21.41 220.04,20.86 221.29,20.86 v2(221.52,20.63)
  BOTTOM w0.114: RH11.2 174.71,14.14 175.32,13.53 v2(175.32,12.6)
EDP_AUXN: length 150.5
  IN4 w0.094: v2(128.56,92.62) 128.63,92.62 128.81,92.81 128.81,93.11 129.01,93.32 129.21,93.32 129.75,93.86 129.75,95.46 127.53,97.67 126.25,97.67 125.3,98.62 125.3,100.47 126.24,101.41 126.24,103.37 123.6,106 106.31,106 105.4,105.1 105.25,105.1 105.25,105.1 87.01,105.1 80.02,98.1 80.02,93.24 77.67,90.89 77.67,87.64 72.88,82.86 71.59,82.86 71.01,82.29 71.01,81.17 68.14,78.3 68.14,75.73 66.18,73.77 64.45,73.77 61.54,70.86 61.54,69 60.7,68.16 60.7,54.17 59.58,53.05 59.58,48.26 54.54,43.21 50.94,43.21 50.46,42.74 50.46,35.64 51.12,34.98 51.82,34.98 51.91,35.07 51.91,35.29 51.82,35.39 v2(51.6,35.39)
  BOTTOM w0.076: v2(128.56,92.62) 128.64,92.62 128.85,92.41 128.85,92.18 128.57,91.91 128.11,91.91 128,92.02 127.89,92.02 127.77,91.91 127.28,91.91 127.19,92 127.19,92.18 127.23,92.23 UH1.B26
  BOTTOM w0.114: CV591.1 52.53,35.11 51.87,35.11 v2(51.6,35.39)
EDP_AUXN_C: length 1.7
  BOTTOM w0.114: CV591.2 54.15,35.13 54.6,35.13 54.75,35.28 55.07,35.28 55.24,35.44 RV552.1
EDP_AUXN_R: length 7.3
  BOTTOM w0.114: RV552.2 56.16,35.44 56.32,35.28 56.72,35.28 56.85,35.15 59.82,35.15 61.06,36.38 61.85,36.38 61.97,36.51 JEDP1.26
EDP_AUXP: length 150.6
  IN4 w0.094: v2(51.6,34.57) 51.38,34.79 51.05,34.79 50.28,35.56 50.28,42.81 50.86,43.4 54.46,43.4 59.4,48.33 59.4,53.13 60.51,54.24 60.51,68.24 61.35,69.08 61.35,70.93 64.37,73.95 66.1,73.95 67.95,75.81 67.95,78.37 70.83,81.24 70.83,82.36 71.51,83.05 72.81,83.05 77.48,87.72 77.48,90.96 79.83,93.32 79.83,98.18 86.94,105.28 105.33,105.28 106.24,106.19 123.68,106.19 126.43,103.44 126.43,101.34 125.49,100.4 125.49,98.69 126.32,97.86 127.61,97.86 129.93,95.53 129.93,93.78 129.28,93.13 129.09,93.13 128.99,93.04 128.99,92.77 v2(129.14,92.62)
  BOTTOM w0.076: UH1.C26 127.02,92.11 127.02,91.93 127.23,91.73 128.63,91.73 129.02,92.12 129.02,92.5 v2(129.14,92.62)
  BOTTOM w0.114: CV592.1 52.58,34.89 51.91,34.89 v2(51.6,34.57)
EDP_AUXP_C: length 1.7
  BOTTOM w0.114: CV592.2 54.13,34.9 54.68,34.9 54.81,34.78 55.07,34.78 55.24,34.61 RV549.1
EDP_AUXP_R: length 7.3
  BOTTOM w0.114: RV549.2 56.16,34.61 56.32,34.78 56.67,34.78 56.81,34.92 59.91,34.92 61.15,36.16 61.83,36.16 61.97,36.01 JEDP1.25
EDP_COMP: length 2.8
  TOP w0.127: v3(128.31,100.38) 127.91,99.99 RH30.1
  TOP w0.508: v2(126.36,99.88) 126.47,99.99 RH30.1
  BOTTOM w0.305: v2(126.36,99.88) 126.23,99.75 UH1.D37
EDP_DISP_UTIL: length 85.4
  TOP w0.114: v2(145.56,36.39) 145.86,36.69 v4(153.06,36.69) 155.88,36.69 156.39,36.18 158.54,36.18 158.79,35.93 159.52,35.93 159.73,35.72 RH20.1
  IN3 w0.127: v2(128.78,97.39) 129.38,96.79 129.38,95.11 130.19,94.3 131.02,94.3 133.18,92.14 133.18,82.92 135.83,80.28 135.83,74.31 135.69,74.18 135.69,69.45 135.69,69.26 138.32,66.63 138.32,54.1 137.73,53.52 137.73,50.81 138.18,50.36 138.18,45.16 144.64,38.7 144.64,37.31 v2(145.56,36.39)
  BOTTOM w0.102: UH1.A33 v2(128.78,97.39)
EDP_HPD: length 139.2
  TOP w0.114: v2(64.53,31.87) 64.02,32.38 63.31,32.38 RV551.1 62.79,31.88 v3(61.7,31.88)
  IN1 w0.094: v2(64.53,31.87) 65.69,30.7 65.69,26.41 66.56,25.54 66.56,20.41 67.71,19.26 68.52,19.26 68.52,19.26 79.56,19.26 79.89,18.93 v2(79.89,18.66)
  IN4 w0.094: v2(79.89,18.66) 80.48,19.24 137.92,19.24 139.52,20.84 141.08,20.84 147.8,27.57 152.11,27.57 152.59,27.09 153.31,27.09 154.75,25.65 154.75,22.99 156.74,21 161.47,21 162.41,21.94 164.2,21.94 164.91,22.64 166.83,22.64 166.9,22.58 172.13,22.58 173.14,21.57 173.14,21.38 173.55,20.97 174.54,20.97 174.58,20.92 175.83,20.92 v2(176.3,21.39)
  BOTTOM w0.089: v2(176.3,21.39) 176.2,21.49 176.2,22.06 175.94,22.32 UH2.BD7
  BOTTOM w0.114: JEDP1.18 62.85,32.51 63.88,32.51 v2(64.53,31.87)
EDP_TXN0: length 132.8
  IN4 w0.094: v2(125.33,94.19) 125.25,94.19 124.71,94.73 124.71,94.87 124.2,95.38 122.36,95.38 121.63,94.65 120.94,94.65 120.47,95.11 120.47,101.11 119.01,102.57 88.55,102.57 85.36,99.38 85.36,90.44 77.97,83.05 77.97,81.32 75.3,78.65 72.76,78.65 71.16,77.05 71.16,75 66.79,70.62 65.16,70.62 64.2,69.66 64.2,68.26 63.19,67.25 63.19,48.2 52.65,37.66 51.34,37.66 51.1,37.42 51.1,36.93 51.28,36.75 52.03,36.75 52.15,36.87 52.15,37.05 52.05,37.16 v2(51.6,37.16)
  BOTTOM w0.076: UH1.E29 125.61,94.48 v2(125.33,94.19)
  BOTTOM w0.114: v2(51.6,37.16) 51.88,36.87 52.51,36.87 CV581.1
EDP_TXN0_C: length 1.7
  BOTTOM w0.114: CV581.2 54.15,36.91 54.6,36.91 54.75,37.05 55.07,37.05 55.24,37.22 RV539.1
EDP_TXN0_R: length 7.1
  BOTTOM w0.114: RV539.2 56.16,37.22 56.32,37.05 56.83,37.05 56.96,36.93 59.97,36.93 60.93,37.88 61.85,37.88 61.98,38.01 JEDP1.29
EDP_TXN1: length 130.5
  IN4 w0.094: v2(51.6,38.89) 51.83,38.66 52.37,38.66 62.3,48.59 62.3,67.46 63.4,68.57 63.4,69.05 63.4,69.05 63.4,70.29 64.63,71.52 66.48,71.52 70.21,75.25 70.21,77.33 72.48,79.6 74.66,79.6 76.79,81.73 76.79,83.02 84.16,90.39 84.16,99.35 88.2,103.39 121.42,103.39 122.82,102 122.82,100.07 123.45,99.43 123.45,97.86 126.19,95.12 126.19,94.75 126.53,94.42 126.53,93.92 125.99,93.39 v2(125.95,93.39)
  BOTTOM w0.076: UH1.E28 125.61,93.69 125.92,93.39 v2(125.95,93.39)
  BOTTOM w0.114: v2(51.6,38.89) 51.76,38.73 52.59,38.73 CV586.1
EDP_TXN1_C: length 1.7
  BOTTOM w0.114: RV541.1 55.24,39 55.07,38.83 54.78,38.83 54.63,38.68 54.15,38.68 CV586.2
EDP_TXN1_R: length 7.9
  BOTTOM w0.114: JEDP1.32 61.97,39.51 61.85,39.38 61.26,39.38 59.61,37.73 57.8,37.73 57.39,38.14 57.39,38.34 57.05,38.68 56.74,38.68 56.6,38.83 56.32,38.83 56.16,39 RV541.2
EDP_TXN2: length 130.5
  IN4 w0.094: v2(127.92,94.99) 127.67,94.73 127.57,94.73 127.44,94.86 127.44,95.66 126.97,96.14 126.14,96.14 125.66,96.62 125.51,96.76 125.51,96.76 124.18,98.1 124.18,101.65 121.83,104 87.87,104 82.81,98.95 82.81,93.08 81.06,91.33 81.06,88.56 78.14,85.64 77.35,85.64 75.12,83.4 75.12,82.29 73.92,81.09 72.76,81.09 69.34,77.68 69.34,75.39 66.62,72.67 64.91,72.67 62.82,70.58 62.82,68.89 62.82,68.81 61.7,67.69 61.7,48.89 53.26,40.44 51.83,40.44 v2(51.6,40.68)
  BOTTOM w0.076: v2(127.92,94.99) 127.92,94.86 127.65,94.59 UH1.B29
  BOTTOM w0.114: v2(51.6,40.68) 51.8,40.48 52.57,40.48 CV588.1
