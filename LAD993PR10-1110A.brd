# Allegro board LAD993PR10-1110A.brd (continued)
## Nets (continued)
N129713353: PC1412.2 PU1401.5
N129713363: PR1415.2 PU1401.1
N129713367: PR1417.2 PU1401.2
N129713379: PC1410.1 PR1414.2 PU1401.24
N129714262: PC1411.2 PR1416.2 PU1401.3
N129715037: PR1432.2 PU1402.26
N129715137: PR1433.2 PU1402.7
N129715139: PC1419.1 PR1433.1
N129715141: PC1419.2 PU1402.5
N129715151: PR1429.2 PU1402.1
N129715155: PR1431.2 PU1402.2
N129715167: PC1418.1 PR1428.2 PU1402.24
N129715635: PC1420.2 PR1430.2 PU1402.3
N129716454: PR1504.2 PU1500.26
N129716544: PR1505.2 PU1500.7
N129716546: PC1502.1 PR1505.1
N129716548: PC1502.2 PU1500.5
N129716558: PR1501.2 PU1500.1
N129716562: PR1503.2 PU1500.2
N129716574: PC1500.1 PR1500.2 PU1500.24
N129717674: PC1501.2 PR1502.2 PU1500.3
N129718561: PR1516.2 PU1501.26
N129718659: PR1517.2 PU1501.7
N129718661: PC1510.1 PR1517.1
N129718663: PC1510.2 PU1501.5
N129718673: PR1513.2 PU1501.1
N129718677: PR1515.2 PU1501.2
N129718689: PC1508.1 PR1512.2 PU1501.24
N129719256: PC1509.2 PR1514.2 PU1501.3
N129830333: PR407.2 PU400.6
N129937820: PL1505.3 PR1529.1
N129937845: PL1505.2 PR1528.1
N130381075: PR1000.1 PU1000.9
N130402506: JFAN2.1 Q13.1 RE101.2
N130402546: DE7.1 JFAN1.3 RE82.2
N130402633: DE9.1 JFAN2.3 RE84.2
N130584913: T92.1(TP-1) UH2.AR17
N130791078: QV1.2 QV1.5 RV571.2 RV572.2
N130949507: T1.1(TP-1) UH2.BC18
N130955932: CA21.2 RA72.1
N130956130: CD92.2 RA73.1
N130959682: JDEG1.1 RE60.1
N130960109: RE111.2 T3.1(TP-1)
N130982801: RL43.2 UL1.26
N131307421: CV578.2 QV11.3 RV535.2 RV570.1
N131307439: QV2.1 RV570.2
N131311358: DC2.2 RC11.1
N131431549: QE20.2 QE20.3 RH504.2
N131431604: QE23.5 QE23.6 RH505.2
N131431963: LED3.2 RW3.1
N131431980: LED4.2 RW4.1
N131432059: QE24.5 QE24.6 RH506.2
N131436195: JFAN1.1 Q12.1 RE100.2
N131680753: PC1630.1 PR1611.2
N131681151: PC1678.1 PR1622.2
N131712060: PR1615.2 PU1600.9
N131712748: PC1644.1 PR1613.1 PU1600.18
N131741378: PC1676.2 PR1620.2 PR1623.2 PU1600.11
N131741387: PC1676.1 PR1617.2 PR1618.2 PU1600.10
N131741412: PR1600.2 PR1601.1 PR1602.1 PU1600.4
N131741423: PC1645.1 PR1614.2 PR1615.1
N131748830: PC1711.1 PR1710.2
N131748958: PC1712.1 PR1713.1 PU1700.18
N131748960: PC1713.1 PR1714.2 PR1715.1
N131749104: PC1723.1 PR1716.2 PR1717.2 PU1700.10
N131749108: PC1723.2 PR1720.2 PR1721.2 PU1700.11
N131749147: PC1731.1 PR1719.1 PU1700.12
N131807894: RV591.1 UV1.AF8
N131836548: QV89.2 RV582.1 RV610.1 UV22.4
N131855116: PQ901.2 PR908.2 PR909.2
N131866512: PC1625.1 PR1606.2 PR1607.2 PR1608.1
N131868325: PR1609.2 PR1612.1
N131873134: PC1677.1 PR1621.1 PU1600.12
N131901413: PC1709.1 PR1706.2 PR1707.2 PR1708.1
N131901439: PR1709.2 PR1712.1
N131902783: PR1715.2 PU1700.9
N131912612: PC1626.1 PR1610.2
N131912705: PC1646.2 PR1616.2
N131913656: PC1710.1 PR1711.2
N131943637: PQ901.1 PR910.2
N131973567: QZ11.1 RZ73.2
N131973815: QZ10.3 RZ100.2
N132121209: CV903.1 RV594.2 RV595.2
N132122697: CV904.1 RV596.2 RV597.2
N132123770: CV905.1 RV598.2 RV599.2
N132124417: CV906.1 RV600.2 RV601.2
N132421462: RV602.1 UV1.R32
N132421465: RV603.1 UV1.AC32
N132541936: CA66.2 QA2.3 RA79.1 RA80.2
N132541970: QA1.1 RA79.2
N132584446: TV107.1(TP-1) UV1.AH8
N132584577: TV106.1(TP-1) UV1.AB8
N132618344: RV604.1 UV1.C12
N132880980: PR1530.2 PU1503.1
N132881948: PC1520.2 PR1531.2 PU1503.2
N132883328: PR1532.1 PU1503.12
N132883570: PC1523.1 PR1533.2 PU1503.11
N132883768: PC1522.1 PR1527.1
N132883846: PR1527.2 PU1503.5
N132883854: PC1522.2 PU1503.4
N133233549: PQ301.4 PR303.1
N133233615: PQ306.4 PR325.1
N133325166: RV605.1 UV1.C20
N134039053: RV606.1 UV21.1
N134039285: QV3.2 RV56.1
N134040693: QZ8.3 RZ9.2
N134041170: CV921.1 QZ7.5 QZ7.6 RZ104.2
N134041902: QZ12.3 RZ11.2
N134042310: CV922.1 QZ10.5 QZ10.6 RZ105.2
N134042900: QZ7.3 RZ10.2
N134045472: RZ33.2 UE4.3
N134170652: QV88.5 QV88.6 RV609.2
N134170665: QV88.2 RV614.2
N134170915: QV88.4 RV615.2 RV616.2
N134234965: QV92.2 QV92.3 RZ109.2
N134312093: QZ13.2 QZ13.3 R1.2 R5.1
N134312858: QZ13.5 R3.2 R4.1
N134404381: PQ103.5 PR113.2 PR115.1
N134410660: PQ203.2 PQ203.3 PR209.2 PR214.1
N134534683: QZ13.6 R2.1
N134535293: QV93.2 RV611.1
N201821498: CA23.1 HDA1.19
N201821507: CA15.2 HDA1.34
N201821575: CA16.2 HDA1.28
N201821604: CA27.1 HDA1.7
N201821615: CA20.2 HDA1.35
N201821733: CA20.1 HDA1.37
N201821740: CA19.2 HDA1.27 RA11.2
N1211736753: T91.1(TP-1) UH2.R44
N1211736758: T94.1(TP-1) UH2.U42
N1331773500: CA34.2 RA36.1
N1331775041: CA35.2 RA37.1
N1336984400: T120.1(TP-1) UH2.AL42
N12117367569: T182.1(TP-1) UH2.AG35

Pads without a net: FD1 1; FD2 1; FD3 1; FD4 1; HDA1 11 12 14 15 23 48; JAPS 16 17 18; JBAT10 8; JBL1 3; JCAM1 11 13; JDIMM1 87 88 91 92 95 97 100 101 104 105 134 162 165; JDIMM2 87 88 91 92 95 97 100 101 104 105 134 162 165; JEDP1 4 15 23; JHDD1 4 15 16; JIO1 6 27; JKB1 2 3; JNGFF1 6 8 9 11 12 13 14 21 23 24 26 32 34 38 40 50 51 52 53 54 56 57 58 59 60 62 63 65; JNGFF2 6 8 20 22 24 26 28 30 32 34 36 40 42 44 46 48 56 58 67; PU600 9 10 12; PU700 10 12; PU800 10 12; PU1000 10 12; PU1400 6 25 27; PU1401 6 25 27; PU1402 6 25 27; PU1500 6 25 27; PU1501 6 25 27; PU1700 13 14 15 16 17; PU1800 5; RP15 4 5; SW5 2 3; UA1 4; UA2 30; UC1 1; UC16 1; UE1 31 69; UE6 1; UH1 A27 AA14 AD2 AD4 AE1 AE5 AE9 AE10 AE11 AE29 AF10 AF29 AF30 AF31 AF32 AF33 AF34 AG13 AG14 AG31 AG32 AG33 AG34 AG35 AG36 AH13 AH14 AH29 AH30 AH31 AH32 AH35 AH36 AJ8 AJ10 AJ11 AJ13 AJ14 AK3 AL1 AL2 AL3 AM10 AM11 AT3 AT5 AT7 AT11 AT13 AU13 AW7 AW8 AW9 AW10 AW11 AW13 AY1 AY2 AY3 AY4 AY5 AY7 AY8 AY9 AY10 AY11 AY13 B2 B27 B30 B33 B34 B36 B38 BA1 BA2 BA3 BA4 BA5 BH30 BJ13 BJ14 BJ16 BJ17 BJ19 BJ20 BJ21 BJ23 BJ24 BJ26 BJ27 BJ28 BJ33 BJ34 BJ35 BJ36 BK16 BK17 BK19 BK20 BK21 BK23 BK24 BK26 BK27 BK28 BL14 BL15 BL16 BL17 BL18 BL19 BL20 BL21 BL22 BL23 BL24 BL25 BL26 BL27 BL28 BL31 BL33 BL34 BM14 BM15 BM16 BM17 BM19 BM22 BM24 BM31 BM33 BN1 BN15 BN16 BN17 BN22 BN23 BN27 BN28 BN33 BN35 BP1 BP13 BP15 BP16 BP17 BP19 BP22 BP23 BR1 BR2 BR15 BR16 BR17 BR19 BR22 BR23 BR27 BR31 BR35 BT2 BT15 BT16 BT17 BT19 BT22 BT23 BT27 BT30 C1 C30 C33 C34 C38 D1 D27 D34 E1 E2 E3 E26 E27 E30 E33 E36 E37 F26 F30 F33 F34 F35 F37 G3 G13 G38 H24 H33 H34 H36 H37 J3 J24 J34 J35 J37 J38 K36 K37 N29 R14; UH2 A14 A16 A21 A39 A40 A41 AA44 AA45 AB13 AB33 AB35 AB36 AB39 AB41 AB42 AB43 AB44 AC2 AC3 AC43 AD31 AD35 AD38 AE17 AE45 AF2 AF3 AF17 AG14 AG15 AG39 AG44 AH43 AH44 AJ7 AJ8 AJ11 AJ13 AJ33 AJ35 AJ42 AJ43 AJ44 AK44 AK45 AL7 AL8 AL39 AL43 AM43 AM44 AN17 AN24 AN29 AN36 AN38 AN41 AN42 AN43 AR15 AR19 AR22 AR29 AT2 AT31 AT43 AT44 AU43 AU44 AV2 AV3 AV4 AV44 AW2 AW4 AW31 AW35 AY2 B13 B14 B15 B16 B19 B20 B21 B23 B24 B36 B39 BA4 BA35 BA41 BB3 BB13 BB17 BB19 BB36 BB38 BC8 BC19 BC22 BC35 BC36 BC38 BD1 BD6 BD8 BD14 BD18 BD21 BD23 BD27 BD34 BD35 BD38 BD39 BE2 BE5 BE6 BE21 BE34 BE39 C14 C15 C19 C20 C23 C24 C36 D5 D7 D8 D43 E6 E11 E17 E20 E35 E41 E42 E45 F41 F45 G11 G13 G15 G17 G19 G35 G37 G44 G45 H13 H15 H40 H42 H43 H44 J45 K13 K15 K17 K22 K24 K37 K44 L1 L2 L5 L7 L17 L22 L24 L37 L39 L44 M44 M45 N2 N3 N7 N8 N29 N31 N38 N39 N42 N43 N44 P1 P2 P3 P24 P27 P29 P31 P43 P44 R2 R3 R4 R11 R13 R24 R27 R35 R36 R39 R41 R42 R43 T44 U5 U7 U13 U35 U36 U39 U41 V1 V2 W2 W3 W7 W10 W11 W13 W39 Y5; UM1 2 10 12 25 26 28 29 37; US1 9; UT1 8; UV1 A9 A26 A27 A30 AB3 AB4 AC1 AC2 AC3 AC4 AC5 AC6 AC28 AD1 AD2 AD3 AD4 AD5 AD6 AE3 AE4 AF1 AF2 AF3 AF4 AF5 AF30 AF32 AG1 AG7 AG10 AG12 AG26 AH6 AH9 AH31 AJ4 AJ5 AJ6 AJ8 AJ9 AJ11 AJ26 AJ28 AJ31 AJ32 AJ33 AK2 AK3 AK4 AK5 AK6 AK8 AK9 AK26 AK31 AL3 AL4 AL6 AL7 AL8 AL9 AL10 AL11 AM1 AM2 AM3 AM4 AM5 AM6 AM7 AM8 AM9 AM34 AN2 AN3 AN5 AN6 AN8 AN9 AP3 AP5 AP6 AP8 AP9 B2 B6 B23 C6 C15 D6 D7 D9 D19 D20 D22 D23 D26 D28 E1 E4 E26 E34 F2 F26 G14 G20 H30 H31 J30 J31 J32 J33 K3 K4 M4 M5 M30 M34 N8 P1 P3 P4 P8 R4 R5 R28 V32; UV6 A5 A10 U5 U10; UV7 A5 A10 U5 U10; UV8 A5 A10 U5 U10; UV9 A5 A10 U5 U10; UZ8 3

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 156 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 8766 vias
v3: diameter 0.305, hole 0.152, TOP to BOTTOM, 626 vias
v4: diameter 0.406, hole 0.203, TOP to BOTTOM, 394 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.2V_DDR_OT: length 4.4
  BOTTOM w0.254: PU500.19 99.36,10.2 99.34,10.04 99.2,9.9 97.2,9.9 v3(96.62,9.32) 96,8.7 PR500.1
1.2V_VCCPLL_OC: length 0.7
  TOP w0.114: 71.94,46.92 v4(71.94,46.17)
1.2V_VDDQ_EN: length 63.7
  TOP w0.114: RZ102.2 151.79,18.82 DZ1.2 151.26,18.44 150.35,17.53 CZ102.1 150.35,16.11 v3(149.79,15.55) 148.8,15.55 v2(148.77,15.57)
  IN3 w0.127: v2(94.88,15.97) 94.88,16.02 95.26,16.4 109.66,16.4 110.23,15.83 111.4,15.83 112.53,14.7 118.53,14.7 119.29,15.46 123.07,15.46 124.23,16.61 134.58,16.61 134.86,16.33 144.88,16.33 145.12,16.08 148.41,16.08 148.77,15.72 v2(148.77,15.57)
  BOTTOM w0.114: v2(94.88,15.97) 94.65,15.74 PR507.1
1V8_EN_LS3V3: length 8.1
  TOP w0.114: RZ108.2 205.47,59.33 QV92.6 v3(201.86,60.1) 199.46,60.1 RV606.2
1V8_GFX_RUN: length 1.7
  BOTTOM w0.127: RZ69.1 152.51,109.15 v3(153.07,108.59)
1V8_MAIN_EN: length 205
  TOP w0.114: v2(145.2,103.62) 145.2,105.72 146.96,107.48 148.39,107.48 DV14.2 150.32,109.41 151.42,109.41 151.9,108.93 RZ106.1 ; v2(181.62,51.91) 182.13,51.4 189.56,51.4 196.07,57.91 196.62,57.91 197.79,59.09 197.79,60.25 198.3,60.75 201.56,60.75 201.76,60.54 205.27,60.54 QV92.5
  IN1 w0.094: v2(145.2,103.62) 145.24,103.58 146.02,103.58 149.48,100.12 149.48,87.85 152.15,85.18 152.15,84.67 154.89,81.93 159.62,81.93 159.7,81.86 160.31,81.86 161.19,82.74 162.76,82.74 163.83,81.67 165.3,81.67 165.65,82.02 169.23,82.02 169.85,82.64 170.2,82.64 170.49,82.35 170.49,80.99 v2(170.88,80.61)
  IN3 w0.127: v2(175.08,61.33) 175.27,61.33 175.61,61.67 176.63,61.67 176.86,61.45 176.86,60.53 176.57,60.24 176.57,59.07 179.68,55.95 179.68,54.47 181.2,52.95 181.2,52.33 v2(181.62,51.91) 178.61,48.9 175.71,48.9 175.07,49.55 175.07,50.29 177.01,52.24 177.01,54.78 175.5,56.29 175.5,57.6 169.01,64.09 145.11,64.09 144.51,64.68 144.51,66.94 145.69,68.12 145.69,69.7 146.85,70.86 146.85,72.66 146.3,73.21 146.3,73.82 146.76,74.27 146.76,79.8 146.39,80.17 146.39,80.86 147.14,81.61 147.14,82.63 143.42,86.35 143.42,97.56 143.13,97.86 143.13,98.86 143.67,99.41 143.67,102.07 145.2,103.6 v2(145.2,103.62)
  BOTTOM w0.114: RV55.1 144.86,107.01 144.86,103.96 v2(145.2,103.62) ; v2(170.88,80.61) 171.27,81.01 UV1.P7 ; UV23.2 175.59,65.18 175.42,65.01 175.42,63.62 175.6,63.44 175.6,62.19 175.08,61.67 v2(175.08,61.33) 175.08,61.08 v3(174.87,60.87) 174.65,60.65 RV608.2
1V8_RUN_EN: length 50.8
  TOP w0.114: v2(144.87,110.98) 145.18,111.29 146.01,111.29 146.2,111.48 146.82,111.48 148.09,110.21 149.02,110.21 149.33,110.53 DV14.1 150.87,109.85 RZ106.2 153.27,109.85 154.49,108.63 154.49,105.55 153.18,104.24 153.18,100.47 151.71,99 149.09,99 v2(148.89,98.8) ; QZ10.2 156.14,80.06 v2(156.73,80.65)
  IN1 w0.094: v2(148.89,98.8) 148.89,88.16 151.95,85.1 151.95,84.59 155.9,80.65 v2(156.73,80.65)
  BOTTOM w0.114: v2(144.87,110.98) 145.47,110.37 v3(145.86,110.37) UZ17.3
1VS_GFX_PG: length 174.8
  TOP w0.508: v2(177.02,67.55) 175.89,67.55 174.09,69.36 174.09,70.31 173.36,71.03 172.91,71.03 172.09,71.85 DV13.2 ; PR801.2 231.1,42.87 v2(231.1,42.28) ; v2(193.48,46.95) 193.32,47.12 191.41,47.12 189.95,48.58 v4(182.48,48.58) 180.74,48.58 179.93,47.77 v2(179.93,47.64) ; UV19.1 149.74,72.25 148.65,71.16 146.19,71.16 145.65,71.7 v2(145.65,71.82)
  IN3 w0.508: v2(177.02,67.55) 176.44,66.98 176.44,62.8 188.81,50.43 190,50.43 v2(193.48,46.95) 195.13,45.3 197.24,45.3 201.46,41.09 204.48,41.09 208.39,37.17 208.39,36.31 209.12,35.59 212.06,35.59 212.33,35.85 213.05,35.85 213.18,35.73 214.21,35.73 217.54,39.06 219.64,39.06 220.33,39.74 229.75,39.74 231.24,41.23 231.24,42.14 v2(231.1,42.28)
  IN4 w0.508: v2(179.93,47.64) 179.93,49.46 178.42,50.97 174.58,50.97 172.93,49.32 156.83,49.32 156.32,49.82 150.23,49.82 146.29,45.89 144.54,45.89 144.1,45.46 142.4,45.46 141.44,46.42 141.44,56.05 144.56,59.17 144.56,71.19 145.19,71.82 v2(145.65,71.82)
3.3V_CAM_EN#: length 68.9
  TOP w0.114: v2(207.27,46.22) 207.27,44.06 205.64,42.43 202.5,42.43 202.44,42.49 197.78,42.49 197.5,42.21 196.17,42.21 195.96,42.41 194.96,42.41 193.81,41.26 193.81,39.39 193.19,38.76 192.08,38.76 191.23,37.91 191.23,36.52 187.21,32.51 v2(187.21,31.79)
  IN4 w0.094: v2(165.72,26.46) 165.72,26.49 166.64,27.41 168.07,27.41 168.28,27.63 170.39,27.63 170.65,27.88 175.19,27.88 175.28,27.79 176.47,27.79 177.22,28.54 179.74,28.54 179.91,28.71 181.53,28.71 184.48,31.66 187.08,31.66 v2(187.21,31.79)
  BOTTOM w0.102: UH2.AR27 166.07,26.91 165.72,26.56 v2(165.72,26.46)
  BOTTOM w0.114: PR113.1 v4(208.06,53.93) 208.06,52.42 206.56,50.92 206.56,47.62 206.89,47.28 RZ38.1 208.44,47.28 QZ9.2 208.29,46.22 v2(207.27,46.22)
3V/5VALW_EN: length 17.6
  TOP w0.114: v2(55.1,25.57) v4(54.58,26.09)
  IN1 w0.254: v2(55.1,25.57) 55.25,25.42 55.25,17.67 v2(54.62,17.03)
  BOTTOM w0.254: PR407.1 54.49,17.16 v2(54.62,17.03) ; PD401.2 PD401.3 ; PD401.2 54.28,27.36 54.91,28 PQ403.1 55.69,27.69 PC422.1 PR418.2 55.56,26.03 v2(55.1,25.57) ; PD401.2 53.6,27.35 PR409.2
3VS:
  vias: v4(213.59,15.76)
3VS_TP: length 2.7
  TOP w0.508: UE4.1 136.86,16.79 v3(136.08,17.57) 135.38,17.57 RE93.1
5VS:
  vias: v4(213.52,10.28)
5VS_FAN1: length 2.7
  TOP w0.508: JFAN1.2 v3(55.26,32.97) 55.26,31.95 RE104.2
5VS_FAN2: length 8.1
  TOP w0.127: JFAN2.2 247.82,35.68 248.12,35.39 248.12,33.43 246.95,32.26 v3(246.95,31.54)
  TOP w0.508: JFAN2.2 244.47,35.68 RE105.2
+0.6VS: length 35.3
  TOP w1.016: 136.65,19.18 133.13,19.18 131.39,17.43 v4(125.84,17.43) 125.22,17.43 124.93,17.73 116.32,17.73 113.38,14.79 108.6,14.79 ; 137.12,23.35 137.12,24.7 137.76,25.34 137.76,26.78 137.54,27 137.54,28.2
  vias: v2(105.52,15.87) v2(106.11,15.88) v2(136.94,22.08) v2(137.27,31.19) v2(137.28,30.6) v2(137.4,22.49)
+0.6VSP:
  vias: v3(101.53,14.01)
+0.95VSP: length 10.6
  TOP w0.254: v2(67.57,64.76) 67.75,64.58 PC712.1 67.45,64.13 66.89,63.57 66.89,62.98 66.43,62.52 PR703.1
  BOTTOM w0.254: v2(73.8,66.16) 72.4,64.76 71.64,64.76 70.88,65.52 68.34,65.52 v2(67.57,64.76)
  vias: v2(73.03,71.75) v2(73.03,71.11) v2(73.03,70.48) v2(73.67,71.75) v2(73.67,71.11) v2(73.67,70.48) v2(74.18,66.67) v2(74.43,66.13) v2(74.69,67.05) v2(74.94,66.49) v2(75.19,67.43) v2(75.42,66.87) v2(75.7,67.81) v4(75.49,65.18)
+1.0VSP: length 9.6
  BOTTOM w0.254: PC810.1 214.61,40.22 217.66,40.22 v3(218.22,40.78) 219.14,40.78 PC806.1 219.95,39.97 219.95,39.78 220.53,39.19 221.38,39.19 PR805.1
  vias: v2(212.09,43.4) v2(212.22,42.76) v2(212.48,43.93) v2(212.73,43.4) v2(212.86,42.76) v2(212.86,42.13) v2(213.12,43.93) v2(213.36,43.4) v2(213.75,43.93)
+1.2V_DDR: length 145
  TOP w0.508: v2(81.98,82.39) 82.86,83.28 86.8,83.28 87.23,83.71 92.15,83.71 94.56,81.3 94.58,81.28 95.05,81.28 95.36,80.97 ; RH206.1 73.11,43.73
  BOTTOM w0.254: JDIMM2.75 89.16,29.64 88.66,30.14 v2(88.63,30.14) ; v2(73.06,31.49) 73.4,31.83 JDIMM1.12 ; v2(77.26,29.57) 78.38,29.57 78.66,29.29 JDIMM2.33 ; JDIMM1.54 83.9,31.32 v2(83.83,31.24) ; JDIMM1.159 112.15,42.2 111.9,42.46 v2(111.83,42.46)
  BOTTOM w0.305: v2(111.3,30.83) 111.54,30.83 112.4,31.69 JDIMM1.160 ; JDIMM2.241 132.66,29.57 v2(132.65,29.58) ; JDIMM2.130 102.91,19.11 102.48,18.69 v2(101.67,18.69) 101.41,18.95 JDIMM2.124 ; JDIMM1.148 109.4,31.51 v2(109.35,31.46) ; v2(95.7,31.3) 95.64,31.23 94.96,31.23 94.4,31.78 JDIMM1.96 ; v2(111.3,31.44) 111.21,31.44 110.9,31.74 JDIMM1.154 ; JDIMM2.123 v2(101.16,29.52) 100.09,29.52 99.66,29.09 JDIMM2.117 ; v2(78.97,43.04) 78.95,43.04 78.93,43.02 78.61,43.02 78.39,42.8 78.39,42.23 78.65,41.97 JDIMM1.33 ; v2(122.08,43.96) 122.63,43.41 122.63,42.73 122.15,42.25 JDIMM1.199 ; JDIMM1.220 127.4,31.85 127.77,31.49 v2(128.15,31.49) ; JDIMM1.75 89.15,42.4 89.81,43.06 v2(90.15,43.06) ; JDIMM2.96 94.41,18.72 ; JDIMM1.163 113.15,42.17 112.15,43.17 112.02,43.17 111.91,43.28 v2(111.84,43.28) 110.03,43.28 109.15,42.41 JDIMM1.147 ; v2(101.15,30.15) 100.92,30.15 99.9,31.16 JDIMM1.118 ; JDIMM1.153 110.65,42.21 110.93,42.48 111.81,42.48 v2(111.83,42.46) ; JDIMM2.118 99.91,18.71 v2(99.96,18.66) ; JDIMM1.111 98.15,42.59 97.78,42.97 97.6,42.97 v2(97.56,43.01) 97.88,43.33 98.86,43.33 99.65,42.54 JDIMM1.117 ; JDIMM2.12 v2(73.41,18.66) ; v2(113.62,29.45) 113.22,29.45 113.17,29.4 113.16,29.4 JDIMM2.163 ; JDIMM2.112 98.41,19.14 98,18.74 v2(98,18.71) ; JDIMM1.142 105.9,31.8 105.63,31.52 v2(104.94,31.52) 104.71,31.52 104.4,31.82 JDIMM1.136 ; v2(121.39,29.45) 121.74,29.45 122.16,29.02 JDIMM2.199 ; JDIMM2.129 102.66,29.3 103.55,30.19 v2(104.95,30.19) ; v2(117.71,31.56) 117.18,31.56 116.9,31.83 JDIMM1.178 ; JDIMM2.220 v2(127.41,18.66) ; JDIMM2.135 104.16,29.25 104.46,29.55 v2(104.94,29.55) 105.25,29.55 105.66,29.15 JDIMM2.141 ; v2(101.15,42.54) JDIMM1.123 ; JDIMM1.124 101.4,31.7 v2(101.14,31.44) 102.56,31.44 102.9,31.78 JDIMM1.130 ; v2(98.38,29.63) 98.16,29.41 JDIMM2.111 ; CH197.1 81.42,83.11 UC1.5 ; JDIMM1.135 104.15,41.89 103.81,42.23 v2(103.64,42.23) 102.99,42.23 102.65,41.9 JDIMM1.129 ; JDIMM2.136 104.41,18.91 v2(104.66,18.66) ; v2(101.13,44.06) 101.2,44.14 104.3,44.14 105.65,42.78 JDIMM1.141 ; JDIMM1.241 132.65,42.97 131.12,44.51 v2(131.11,44.51) ; JDIMM2.159 112.16,29.12 111.79,29.48 v2(111.3,29.48) 111.3,29.48 110.96,29.48 110.66,29.17 JDIMM2.153 ; v2(109.38,30.01) 109.16,29.79 JDIMM2.147 ; JDIMM1.112 98.4,31.58 v2(98.34,31.51) ; JDIMM2.178 v2(116.91,18.66) ; JDIMM2.54 v2(83.91,18.66)
  BOTTOM w0.33: JDIMM2.142 v2(105.91,18.68) ; JDIMM2.154 v2(110.91,18.68) ; v2(112.79,18.68) 112.76,18.66 112.74,18.66 112.41,18.99 JDIMM2.160 ; JDIMM2.148 v2(109.41,18.68)
  BOTTOM w0.508: RD35.1 97.85,18.59 97.94,18.68 v2(98,18.71) ; CH197.1 81.98,82.53 v2(81.98,82.39) ; 94.41,18.72 v2(94.41,18.66) 94.4,18.65 94.4,18.61 91.53,15.74 CD11.1
  vias: v2(99.58,77.33) v2(99.55,76.64) v2(102.07,76.62) v2(102.23,80.57) v2(102.24,81.27) v2(106.82,80.61) v2(107.71,80.66) v2(109.53,79.38) v2(109.61,76.65) v2(110.47,80.53) v2(111.24,17.08) v2(111.41,18.3) v2(111.49,17.67) v2(111.9,18.66) v2(111.95,17.11) v2(112.25,17.64) v2(112.4,18.23) v2(112.61,17.11) v2(112.89,17.64) v2(113.21,17.15) v2(113.45,17.82) v2(113.77,17.32) v2(114.06,17.83) v2(114.31,17.08) v2(114.62,76.6) v2(114.77,17.54) v2(117.09,76.63) v2(117.79,78.73) v2(123.2,80.67) v2(123.86,76.65) v2(124.01,21.28) v2(143.71,32.87) v2(143.71,32.29) v2(143.71,31.7) v4(78.01,47.07) v4(79.31,49.94) v4(81.15,52.67)
+1.2V_DDRP: length 20.9
  IN1 w0.254: v2(100.8,8.85) 101.2,8.45 102.32,8.45 104.05,6.72 113.83,6.72 114.16,7.05 114.16,10.05 v2(112.81,11.39)
  BOTTOM w0.254: PR503.1 PC508.1 100.57,8.63 v2(100.8,8.85)
  vias: v4(113.23,12.03)
+1.2V_PWROK: length 4.1
  BOTTOM w0.254: PR501.1 96.89,8.83 97.52,9.46 v3(98.05,9.46) 99.34,9.46 99.8,9.92 PU500.18
+1.2V_RTM: length 21.5
  TOP w0.203: UM1.30 267.71,39.44 268.02,39.74 ; UM1.15 v2(271.71,34.53) ; UM1.46 v2(263.66,34.53) ; UM1.18 v2(271.71,35.73) ; UM1.11 269.31,32.44 269.67,32.08 272.51,32.08 CM837.1 ; CM838.1 267.6,30.09 267.6,30.98 267.31,31.26 UM1.6 ; UM1.43 263.69,35.73 v2(263.66,35.77)
  TOP w0.305: 268.02,39.74 268.51,39.74 268.89,40.12 268.89,41.04 CM229.1 269.4,40.99 v2(269.4,40.66)
  TOP w0.508: CM837.1 CM823.1 272.68,31.23 v2(272.17,30.72) ; CM838.1 CM839.1 268.61,30.34 v2(268.23,30.72)
  BOTTOM w0.508: CM10.1 271.33,36.12 v2(271.71,35.73) ; CM4.1 263.71,34.58 v2(263.66,34.53) ; CM12.1 271.33,34.92 v2(271.71,34.53) ; CM141.1 263.83,35.93 v2(263.66,35.77)
  vias: v4(269.96,39.16)
+1.2V_VCCPLL_OC: length 207.7
  TOP w0.508: RZ67.2 69.24,47.78 69.1,47.92 CZ49.1 69.1,48.71 67.14,50.66 67.14,52.52 68.36,53.74 76.74,53.74 87.82,64.81 v4(87.82,67.31) 87.82,68.8 89.27,70.25 89.27,74.28 88.4,75.15 88.4,79.08 87.94,79.54 87.94,80.24 88.98,81.27 v2(93.1,81.27) ; RH107.1 115.98,80.85 v2(115.98,80.61)
  IN2 w1.016: 148.02,23.51 146.53,23.51 143.7,26.34 143.7,27.55 140.34,30.9 140.34,32.26 138.47,34.13 135.1,34.13 134.5,34.73 134.5,40.25 135.8,41.54 135.8,45.68 132.98,48.5 132.98,62.73 128.18,67.53 128.18,73.68 127.85,74.01 127.85,77.54 ; 187.94,22.11 188.27,22.11 189.8,23.64 189.8,28.23 191.02,29.45 196.48,29.45 199.15,32.12 201.75,32.12 202.77,33.14 202.77,33.91 203.39,34.53 206.04,34.53 206.75,33.82 216.09,33.82 217.18,34.92 234.12,34.92 239.07,39.87 246.77,39.87 247.79,38.85 257.95,38.85 259.6,40.5 261.38,40.5
  BOTTOM w0.305: v2(123.98,80.02) 124.31,80.34 UH1.G11 ; UH1.BH13 92.91,81.27 v2(93.1,81.27)
  vias: v2(129.42,77.92) v2(262.01,40.5) v2(262.65,40.5)
+1.8V_AVDD: length 11
  TOP w0.127: v4(285.68,30.39) 285.63,30.44 v2(284.03,30.44)
  TOP w0.203: HDA1.40 282.31,28.23 282.36,28.28 282.36,28.98
  TOP w0.508: CA63.2 283.89,30.44 v2(284.03,30.44) ; CA1.1 288.17,28.32 CA2.1 v2(288.41,29.31)
  BOTTOM w0.508: v2(288.41,29.31) 288.19,29.31 287.27,30.23 RA1.1 285.85,30.58 284.17,30.58 v2(284.03,30.44)
+1.8V_DVDD: length 4.7
  TOP w0.508: RA3.1 287.41,30.22 v3(287.16,29.96) 286.9,29.71 v2(286.9,29.33) 286.04,29.33 285.63,28.92 CA3.1
  BOTTOM w0.508: RA1.2 286.22,29.33 v2(286.9,29.33)
+1.8V_GFX_AON: length 321.6
  TOP w0.102: 170.9,79.34 170.63,79.34 170.47,79.5 170.47,80
  TOP w0.356: v2(148.52,72.66) 148.24,72.38 UV19.5
  TOP w0.381: v2(149.57,81.64) 149.96,82.03 RV57.2
  TOP w0.457: CV573.1 147.84,109.21 v2(147.29,108.66) ; UV18.5 155.5,73.77 v2(155,73.27)
  TOP w0.508: 189.61,132.74 189.61,131.88 188.97,131.24 188.97,130.24 188.73,129.7 188.73,128.06 189.82,125.21 189.82,124.48 192.16,122.14 v2(192.95,122.14) ; RZ11.1 v2(152.83,82.26) ; RV588.1 193.66,60.87 193.5,60.87 193.45,60.82 QV90.5 192.47,60.82 192.16,60.52 192.16,58.89 v2(191.75,58.49) ; CV214.1 171.79,76.62 RV513.2 171.79,78.65 RV577.2 ; CV214.1 171.85,76.34 172.92,75.28 172.92,73.33 173.52,72.74 RV60.2 174.1,72.74 174.46,73.09 174.46,74.08 175.04,74.67 175.04,75.74 174.41,76.38 174.41,76.59 ; CV214.1 RV580.2 ; RV147.2 191.34,73.5 RV148.2 RV158.2 189.49,73.37 RV581.2 188.4,73.45 RV157.2 RV149.2 RV159.2 RV150.2 184.36,73.45 184.03,73.12 RV146.2 183.46,73.05 RV593.2 181.12,73.05 v2(180.76,72.68) ; v2(146.51,108.61) 145.97,108.61 PR909.1 ; 174.41,76.59 173.75,76.59 RV574.2 ; 174.41,76.59 174.41,80.48 ; v2(199.93,51.86) 200.21,51.58 PR1700.1 ; v2(189.49,58.61) 189.87,58.99 RV589.1 190.15,60.65 190.31,60.65 190.49,60.82 QV90.2 ; v2(177.26,66.28) 177.26,65.33 QV10.2 ; v2(177.01,68.2) 176.11,68.2 174.79,69.52 v4(174.79,70.7) 174.79,71.72 175.65,72.58
  TOP w0.635: 189.6,133.11 189.34,133.37 152.31,133.37
  IN1 w0.889: 151.57,131.54 152.53,130.58 152.53,123.81 150.33,121.61 148.12,121.61 146.6,120.09 146.59,120.09 146.39,119.89 146.39,117.44 146.6,117.23 146.6,113.78 145.78,112.96 145.78,110.63 146.63,109.78
  IN2 w0.508: v2(149.57,81.64) 149.57,81.24 151.19,79.62 152.16,79.62 152.83,80.29 v2(152.83,82.26) ; 150.81,131.59 150.81,124.5 146.14,119.83 146.14,118.01 145.7,117.58 143.91,117.58 143.32,116.98 143.32,115.46 142.54,114.68 142.54,112.61 142.43,112.5 142.43,110.96 143.52,109.87 146,109.87 146.17,109.69 v2(146.54,109.69)
  IN2 w0.762: 151.88,133.19 152.03,133.34 189.62,133.34
  IN2 w1.397: 193.15,124.04 190.08,127.12 190.08,130.95
  IN3 w0.508: v2(180.76,72.68) 180.38,72.3 180.38,68.81 179.77,68.2 178.08,68.2 ; 178.08,68.2 178.1,68.18 178.1,67.38 177.26,66.54 v2(177.26,66.28) 177.26,63.15 180.83,59.58 188.53,59.58 v2(189.49,58.61) 189.62,58.49 v2(191.75,58.49) 192.11,58.13 192.11,56.91 197.16,51.86 v2(199.93,51.86) 202.32,49.47 202.32,47.92 203.74,46.5 203.74,44.44 209.18,39 215.85,39 216.51,39.66 219.39,39.66 220.08,40.35 229.37,40.35 v2(230.51,41.49) ; 178.08,68.2 v2(177.01,68.2)
  BOTTOM w0.305: UV1.J8 175.1,82.2 v2(175.1,82.97)
  BOTTOM w0.457: RV39.1 147.74,80.44 v2(147.46,80.17)
  BOTTOM w0.508: v2(159.83,73.55) 159.85,73.52 RV191.2 ; v2(177.01,68.2) 175.64,68.2 174.63,69.21 RV42.2 173.96,69.31 173.25,68.6 173.25,66.34 173.76,65.83 UV23.5 ; RV532.2 148.47,76.47 v2(147.9,77.04) ; PR804.1 227.49,37.07 228.69,38.27 228.69,39.66 v2(230.51,41.49) ; v2(171.78,82.29) 172.46,82.97 173.48,82.97 UV1.K8 ; v2(149.39,75.39) 149.12,75.12 RV41.2 149.93,73.94 RV34.2 ; PR1600.1 177.71,59.65 177.71,61.15 176.74,62.12 176.74,63.91 177.26,64.43 v2(177.26,66.28)
  vias: v2(144.87,98.87) v2(145.48,98.87) v2(146.11,98.85) v2(146.9,109.16) v2(148.55,73.93) v2(150.71,132.65) v2(150.75,132.04) v2(151.39,132.63) v2(151.37,132.02) v2(159.83,71.9) v2(160.51,71.9) v2(166.1,73.27) v2(173.06,72.23) v2(173.7,72.13) v2(173.82,71.54) v2(190.21,133.42) v2(190.26,132.71) v2(190.76,133) v2(190.97,133.56) v2(192.9,121.43) v2(192.9,120.74) v2(192.91,120.12)
+1.8V_GFX_RUN: length 25.5
  TOP w0.508: v2(173.34,82.26) 173.03,82.26 172.83,82.06 CV117.1 ; RV590.2 154.96,82.67 RZ100.1 153.92,81.88 v2(153.51,82.29) ; CV840.1 157.63,98.29 157.53,98.39 156.37,98.39 155.89,98.87 v2(155.89,98.98)
  IN1 w0.508: v2(148.27,98.88) 148.27,88.21 151.55,84.93 151.55,84.43 153.51,82.46 v2(153.51,82.29)
  BOTTOM w0.305: UV1.L8 173.78,81.81 v2(173.39,81.42) 173.38,81.42 UV1.M8
  vias: v2(147.53,104.1) v2(147.81,104.66) v2(148.12,104.13) v2(159.19,96.5) v2(159.55,75.03) v2(159.95,96.5) v2(159.98,90.64) v2(160,88.1) v2(160.18,75.03) v2(160.79,88.1) v2(160.88,86.4) v2(161.17,88.59) v2(161.27,89.19) v2(161.47,86.4) v4(147.81,103.42)
+1.8V_PLLVDD:
  vias: v4(163.05,77.21)
+1.8VS:
  vias: v4(290.84,31.52)
+1.8VSP: length 11.3
  BOTTOM w0.254: PR1004.1 PC1006.1 201.43,115.31 v4(200.78,115.95) 197.44,119.29 197.44,119.45 196.25,120.64
  vias: v2(195.29,121.68) v2(195.26,120.87) v2(197.04,121.64) v2(197.04,120.65)
+1.35VS_VGA: length 191.7
  TOP w0.254: v2(167.3,119.69) 166.81,119.2 166.81,118.15 166.39,117.73 CV851.1
  TOP w0.305: CV869.1 185.54,124.83 v2(184.8,124.09)
  TOP w0.381: v2(176.8,118.49) 175.9,117.59 CV379.1 ; CV186.1 196.43,86.92 v2(197.06,86.28)
  TOP w0.4: v2(207.86,109.06) v2(207.86,108.46) ; v2(176.8,126.49) v2(176,127.29) 175.6,127.69 v2(175,127.69) ; v2(209.46,88.68) v2(209.46,88.08) ; v2(157.5,127.29) v2(157.5,126.49) v2(156.7,126.49) UV7.G14 v2(155.7,126.89) ; v2(205.86,106.66) v2(205.06,106.66) v2(205.06,107.46) UV9.G14 v2(205.46,108.46) ; v2(205.86,86.28) v2(205.86,85.48) v2(205.06,85.48) v2(205.06,84.68) ; v2(209.46,109.06) v2(209.46,108.46) ; v2(209.46,75.88) v2(209.46,76.48) ; v2(207.86,88.68) v2(207.86,88.08) ; v2(174.4,129.29) v2(175,129.29) ; v2(207.86,96.26) v2(207.86,96.86) ; v2(187.2,130.89) v2(186.6,130.89) ; v2(167.9,130.89) v2(167.3,130.89) ; v2(207.86,75.88) v2(207.86,76.48) ; v2(209.46,96.26) v2(209.46,96.86) ; v2(183.2,127.29) v2(184,127.29) v2(184.8,127.29) v2(184.8,126.49) ; v2(174.4,130.89) v2(175,130.89) ; v2(165.5,130.49) v2(165.5,129.69) ; v2(199.86,76.48) v2(199.86,75.88) ; v2(175,127.69) v2(175,126.89) v2(174.4,126.89) ; v2(175,127.69) v2(174.4,127.69) ; v2(205.46,88.68) v2(205.46,88.08) ; v2(187.2,129.29) v2(186.6,129.29) ; v2(187.2,119.69) v2(186.6,119.69) ; v2(155.7,119.69) v2(155.1,119.69)
  TOP w0.406: v2(178.4,126.49) 178.02,126.87 v2(177.6,127.29) v2(176.8,126.49) ; v2(187.2,127.69) v2(186.6,127.69) v2(186.6,126.89) 186,126.89 v2(185.6,126.49) v2(184.8,126.49) ; v2(164.22,103.11) 163.68,103.65 RV603.2
  TOP w0.508: CV404.1 196.42,106.66 v2(197.06,106.66) ; v2(206.66,104.26) 206.72,104.21 CV399.1 ; v2(156.7,126.49) 156.75,126.43 CV387.1 ; v2(199.86,75.88) 199.8,75.82 CV391.1 ; RV96.1 205.7,88.92 v2(205.46,88.68) ; v2(199.86,96.26) 199.86,96.21 199.45,95.8 CV402.1 ; RV117.2 169.24,127.98 168.72,127.98 CV857.1 168.62,127.88 168.09,127.88 v2(167.9,127.69) ; RZ8.1 203.72,75.1 CV897.1 203.64,75.73 203.67,75.76 v2(203.67,75.86) ; v2(207.86,75.88) 207.86,75.68 208.11,75.43 CV392.1 ; CV170.1 168.5,119.69 168.5,119.69 v2(167.9,119.69) ; v2(207.86,109.06) 207.92,109.12 CV403.1 ; CV377.1 179.26,130.43 v2(179.2,130.49) ; CV180.1 198.38,75.16 198.38,75.76 v2(198.26,75.88) ; RV95.1 174.16,127.45 v2(174.4,127.69) ; RV98.1 168.39,127.09 168.18,126.89 v2(167.9,126.89) ; CV900.1 199.45,89.22 199.86,88.81 v2(199.86,88.68) ; RV605.2 181.7,91.49 v2(181.69,91.48) ; CV882.1 198.18,109.14 v2(198.26,109.06) ; v2(187.2,119.69) 187.8,119.69 CV373.1 ; v2(205.06,107.46) 205,107.41 CV193.1 ; CV896.1 209,80.74 v2(209.06,80.68) ; v2(182.4,130.49) 182.34,130.43 CV876.1 ; v2(187.2,127.69) 187.39,127.88 CV165.1 ; CV375.1 174.34,123.75 v2(174.4,123.69) ; v2(209.46,75.88) 209.46,75.28 CV179.1 ; v2(206.66,80.68) 206.72,80.74 CV185.1 ; CV383.1 159.95,128.15 v2(159.9,128.09) ; v2(202.24,109.06) 202,109.3 CV191.1 ; CV160.1 173.8,119.69 v2(174.4,119.69) ; v2(167.9,121.29) 168.16,121.02 168.46,121.02 CV385.1 ; v2(209.46,96.26) 209.46,96.16 209.9,95.72 CV187.1 ; CV167.1 187.89,122.62 187.72,122.8 187.29,122.8 v2(187.2,122.89) ; CV394.1 207.92,88.74 v2(207.86,88.68) ; CV192.1 209,104.21 v2(209.06,104.26) ; CV175.1 168.49,123.69 v2(167.9,123.69) ; v2(189.24,123.05) 188.86,123.43 188.86,124.83 188.46,125.23 CV374.1 ; CV853.1 163.04,130.43 v2(163.1,130.49) ; CV183.1 198.46,88.88 v2(198.26,88.68) ; v2(163.1,128.09) 163.04,128.15 162.4,128.15 CV174.1 ; CV397.1 209.46,109.67 v2(209.46,109.06) ; CV190.1 198.26,95.43 v2(198.26,96.26) ; v2(182.4,128.09) 182.34,128.15 CV874.1 ; CV901.1 202.19,88.75 v2(202.26,88.68) ; CV858.1 157.32,118.32 v2(157.5,118.49) ; v2(209.46,88.68) 209.46,89.28 CV182.1 ; RV99.1 205.57,96.16 v2(205.46,96.26) ; CV161.1 187.8,130.89 v2(187.2,130.89) ; v2(207.86,96.26) 207.86,96.13 208.11,95.88 CV879.1 ; v2(209.06,101.06) 209,101.12 CV400.1 ; v2(206.66,83.88) 206.72,83.82 CV184.1 ; v2(184.8,118.49) 184.8,117.64 CV378.1 ; v2(209.06,83.88) 209,83.82 CV899.1 ; v2(167.9,130.89) 168.5,130.89 CV169.1 ; CV898.1 206.32,75.82 v2(206.26,75.88) ; v2(174.4,121.29) 174.18,121.07 CV376.1 ; CV852.1 160.02,130.43 v2(159.9,130.55) ; CV401.1 206.72,101.12 v2(206.66,101.06) ; CV877.1 201.18,95.62 201.46,95.9 v2(201.46,96.26) ; CV380.1 187.59,129.61 187.27,129.29 v2(187.2,129.29) ; v2(179.2,128.09) 179.26,128.15 CV875.1 ; v2(174.4,129.29) 174.34,129.35 CV166.1 ; CV902.1 197,78.22 v2(197.06,78.28) ; CV164.1 173.8,130.89 v2(174.4,130.89) ; v2(199.86,109.06) 199.96,109.16 CV883.1 ; CV395.1 205,77.54 v2(205.06,77.48) ; RV131.2 206.36,94.53 206.36,95.47 CV878.1 206.38,96.14 v2(206.26,96.26) ; v2(206.26,109.06) 206.08,109.24 CV884.1 ; RV604.2 182.2,85.15 181.72,85.63 v2(181.69,85.63)
  IN1 w0.4: v2(209.06,83.88) v2(209.06,84.68) v2(209.06,85.48) ; v2(205.06,84.68) v2(205.06,85.48) v2(205.86,85.48) v2(205.86,86.28) ; v2(201.86,77.48) v2(201.86,78.28) v2(201.86,79.08) ; v2(201.06,100.26) v2(201.86,100.26) v2(201.86,99.46) ; v2(207.86,88.08) v2(207.86,88.68) ; v2(184.8,118.49) v2(184.8,119.29)
  IN1 w0.406: v2(197.86,78.28) v2(197.06,78.28)
  IN1 w0.508: v2(201.86,78.28) v2(202.66,78.28)
  IN4 w0.4: v2(165.5,130.49) v2(165.5,129.69) ; v2(184,129.69) v2(184,130.49) v2(183.2,130.49) v2(182.4,130.49)
  BOTTOM w0.127: v2(176.8,119.29) v2(176.8,118.49) ; v2(197.06,106.66) v2(197.86,106.66)
  BOTTOM w0.15: v2(197.86,99.46) v2(197.06,99.46) ; v2(184.8,118.49) v2(184.8,119.29)
  BOTTOM w0.152: v2(197.86,86.28) v2(197.06,86.28)
  BOTTOM w0.17: v2(157.5,118.49) v2(157.5,119.29)
  BOTTOM w0.305: v2(209.06,99.46) 209.46,99.06 UV9.B3 ; v2(178.46,88.98) UV1.E16 ; 159.9,130.5 UV7.C10 v2(159.1,129.69) 158.7,129.29 UV7.D11 v2(158.3,129.69) 157.9,129.29 UV7.D12 ; v2(199.46,86.28) 199.86,85.88 UV8.D3 ; v2(201.46,76.48) 201.46,77.08 UV8.F14 v2(201.86,77.48) 201.86,77.48 UV8.G14 202.26,77.08 v2(202.26,76.48) ; UV7.D3 165.1,129.29 v2(165.5,129.69) ; UV7.T12 157.89,119.69 v2(157.5,119.29) ; UV9.B12 v2(209.06,105.86) ; v2(177.6,119.29) 177.2,119.69 UV6.B3 177.2,119.69 v2(176.8,119.29) ; v2(197.86,106.66) 198.26,106.27 UV9.T12 ; UV8.B14 198.26,77.08 v2(198.26,76.48) ; UV9.D3 207.86,99.06 v2(208.26,98.66) ; UV6.M14 186,127.69 v2(186.6,127.69) ; v2(181.69,91.48) 181.69,91.46 UV1.B19 ; UV6.K12 v2(184.8,126.49) 185.2,126.89 UV6.L13 ; v2(155.7,119.69) 156.29,119.69 UV7.T14 ; UV7.P3 165.09,121.29 v2(164.7,120.89) ; UV8.L4 v2(205.06,85.48) UV8.K3 ; UV8.L4 v2(205.06,84.68) ; UV8.L4 v2(205.86,85.48) UV8.M3 v2(205.86,86.28) UV8.L2 ; UV1.AB33 164.24,103.11 v2(164.22,103.11) ; UV6.P3 v2(176.8,129.69) ; v2(198.66,84.68) 199.06,84.28 UV8.C5 ; UV8.T3 v2(209.06,85.48) ; UV8.P3 v2(207.46,86.28) ; UV6.C5 178.8,120.49 v2(178.4,120.09) ; UV8.G11 v2(201.86,79.08) UV8.F12 201.46,78.68 v2(201.86,78.28) 201.86,78.28 UV8.G13 v2(202.66,78.28) UV8.H12 ; v2(181.94,88.56) UV1.B16 ; UV8.H3 v2(202.66,85.48) UV8.G4 202.26,85.08 v2(201.86,85.48) UV8.F3 201.46,85.88 v2(201.06,86.28) ; v2(155.7,121.29) 156.29,121.29 UV7.P14 ; UV8.T12 v2(209.06,79.08) ; v2(205.86,79.88) UV8.L11 205.46,79.48 v2(205.86,79.08) UV8.M12 ; v2(176.8,120.89) 177.2,121.29 UV6.D3 ; UV1.T33 169.24,102.31 v2(169.22,102.31) ; v2(179.29,91.48) 179.29,91.46 UV1.E19 ; UV7.T3 165.1,119.69 v2(164.7,119.29) ; UV7.B3 v2(165.5,130.49) ; UV7.N5 163.5,122.09 v2(163.9,122.49) ; v2(157.5,120.89) 157.89,121.29 UV7.P12 157.9,121.29 v2(158.3,120.89) 158.69,121.29 UV7.P11 158.7,121.29 v2(159.1,121.69) ; UV1.AA30 v2(165.06,99.88) ; v2(197.86,85.48) 198.26,85.88 UV8.B3 198.26,85.88 v2(197.86,86.28) ; UV1.W30 v2(167.56,99.88) ; UV7.B12 v2(158.3,130.49) ; UV1.E13 v2(178.46,86.48) ; v2(184,127.29) 184,127.29 UV6.M12 v2(184.8,127.29) UV6.L13 ; UV6.T3 v2(177.6,130.49) ; v2(186.6,127.69) v2(186.6,126.89) UV6.L14 185.6,126.49 v2(185.6,126.49) 185.6,126.49 UV6.L13 ; v2(186.6,127.69) v2(187.2,127.69) ; v2(178.4,126.49) UV6.L4 v2(177.6,127.29) UV6.M3 ; v2(200.26,98.66) 199.86,99.06 UV9.P3 ; UV6.E5 v2(178.4,122.49) ; UV1.B13 181.69,85.66 v2(181.69,85.63) ; UV7.R5 v2(163.9,120.09) ; UV8.E5 v2(201.06,84.68) ; UV1.T30 v2(170.06,99.88)
  BOTTOM w0.4: UV1.W33 v2(167.14,103.31) ; v2(155.7,121.29) v2(155.1,121.29) ; v2(155.1,119.69) v2(155.7,119.69)
  BOTTOM w0.406: v2(198.26,76.48) v2(198.26,75.88) ; 159.9,130.5 v2(159.9,130.55) ; UV7.L4 164.3,123.69 ; UV8.D14 199.86,77.08 v2(199.86,76.48) v2(199.86,75.88) 199.86,75.62 CV886.1 ; v2(201.46,75.88) 201.46,75.88 v2(201.46,76.48) v2(202.26,76.48) v2(202.26,75.88) 202.26,74.97 CV389.1 202.38,74.57 203.16,75.35 203.18,75.35 203.49,75.66 203.49,75.68 v2(203.67,75.86) ; UV6.B12 v2(184.8,119.29)
  BOTTOM w0.508: CV389.1 201.46,74.97 v2(201.46,75.88) ; CV866.1 154.94,119.69 v2(155.1,119.69) ; CV870.1 188.4,127.75 187.26,127.75 v2(187.2,127.69) ; v2(198.26,75.88) 198.26,74.92 CV886.1
  vias: v2(144.08,116.42) v2(144.38,115.92) v2(144.37,115.33) v2(144.71,116.42) v2(144.99,115.89) v2(145.4,116.42) v2(145.68,115.89) v2(147.05,112.33) v2(147.2,111.75) v2(147.63,112.31) v2(147.71,117.29) v2(147.71,116.7) v2(147.71,116.12) v2(147.79,111.55) v2(148.02,115.53) v2(148.02,114.93) v2(148.32,117.29) v2(148.3,116.7) v2(148.3,116.12) v2(148.27,112.36) v2(148.35,111.75) v2(148.6,115.53) v2(148.6,114.95) v2(148.9,117.29) v2(148.9,116.7) v2(148.9,116.12) v2(148.85,112.39) v2(148.93,111.78) v2(149.18,115.51) v2(149.18,114.93) v2(149.44,112.36) v2(149.49,117.26) v2(149.49,116.68) v2(149.49,116.09) v2(149.49,111.6) v2(150.02,112.36) v2(150.07,117.24) v2(150.07,116.63) v2(150.07,115.99) v2(150.07,111.78) v2(155.1,130.89) v2(155.1,129.29) v2(155.1,127.69) v2(155.1,123.69) v2(155.1,122.89) v2(155.7,130.89) v2(155.7,129.29) v2(155.7,127.69) v2(155.7,123.69) v2(155.7,122.89) v2(156.7,123.29) v2(157.5,124.09) v2(157.5,123.29) v2(158.3,127.29) v2(158.3,123.29) v2(159.1,120.09) v2(159.9,128.89) v2(162.65,97.35) v2(163.04,113.95) v2(163.36,97.42) v2(163.9,123.29) v2(164.22,97.48) v2(164.7,127.29) v2(164.7,125.69) v2(164.7,123.29) v2(165.08,97.48) v2(165.5,127.29) v2(165.5,124.09) v2(165.5,123.29) v2(165.9,97.45) v2(166.3,123.29) v2(167.3,129.29) v2(167.3,127.69) v2(167.3,126.89) v2(167.3,123.69) v2(167.3,122.89) v2(167.3,121.29) v2(167.62,97.37) v2(167.9,129.29) v2(167.9,122.89) v2(169.25,96.64) v2(170.9,97.45) v2(171.76,97.42) v2(172.53,97.45) v2(173.39,97.45) v2(174.4,122.89) v2(174.58,96.89) v2(175,125.29) v2(175,123.69) v2(175,122.89) v2(175,121.29) v2(175,119.69) v2(175.37,92.9) v2(175.37,92.27) v2(175.42,89.91) v2(175.8,95.01) v2(175.78,87.49) v2(175.85,94.25) v2(175.85,91.58) v2(175.91,88.88) v2(176,123.29) v2(176.03,88.13) v2(176.01,85.66) v2(175.94,84.86) v2(175.94,83.04) v2(175.94,82.31) v2(176.8,124.09) v2(176.8,123.29) v2(176.82,83.96) v2(177.6,123.29) v2(178.75,106.98) v2(179.33,107.43) v2(183.2,121.69) v2(183.2,120.09) v2(184,123.29) v2(184,120.89) v2(184.8,123.29) v2(185.6,123.29) v2(186.6,123.69) v2(186.6,122.89) v2(186.6,121.29) v2(187.2,123.69) v2(187.2,121.29) v2(198.26,108.46) v2(198.26,96.86) v2(198.26,88.08) v2(198.66,105.06) v2(198.66,100.26) v2(198.66,98.66) v2(198.66,79.88) v2(199.46,106.66) v2(199.46,105.86) v2(199.46,79.08) v2(199.86,108.46) v2(199.86,96.86) v2(199.86,88.08) v2(200.26,105.06) v2(200.26,79.88) v2(201.46,109.06) v2(201.46,108.46) v2(201.46,96.86) v2(201.46,88.68) v2(201.46,88.08) v2(201.86,106.66) v2(201.86,105.86) v2(201.86,98.66) v2(201.86,97.86) v2(201.86,87.08) v2(202.26,108.46) v2(202.26,96.86) v2(202.26,96.26) v2(202.26,88.08) v2(202.66,106.66) v2(202.66,98.66) v2(205.06,98.66) v2(205.06,78.28) v2(205.46,96.86) v2(205.46,76.48) v2(205.86,105.86) v2(205.86,99.46) v2(205.86,97.86) v2(205.86,77.48) v2(206.26,108.46) v2(206.26,96.86) v2(206.26,88.66) v2(206.26,88.08) v2(206.26,76.48) v2(206.66,98.66) v2(207.46,104.26) v2(207.46,79.88) v2(208.26,105.86) v2(208.26,105.06) v2(208.26,87.08) v2(208.26,79.08) v2(209.06,79.88) v4(152.28,114.07)
+1.35VS_VGAP: length 10.3
  TOP w0.254: v2(143.04,112.05) 142.35,112.05 PR911.1
  IN4 w0.254: v2(143.04,112.05) 143.82,112.05 144.05,112.28 145.6,112.28 146.31,112.99 146.31,114.57 146.18,114.7 146.18,117.62 v2(145.53,118.28)
  vias: v2(144.31,118.86) v2(144.31,118.28) v2(144.38,121.45) v2(144.41,120.84) v2(144.41,120.23) v2(144.38,119.65) v2(144.49,122.04) v2(144.89,118.85) v2(144.9,118.27) v2(144.94,122.44) v2(145.2,123) v2(145.42,122.11) v2(145.5,118.86) v2(145.63,123.43) v2(145.76,122.62) v2(146.09,122.09) v2(146.39,122.6) v2(146.72,122.09) v2(147.05,122.6) v2(147.36,122.09) v2(147.53,118.85) v2(147.58,118.24) v2(147.79,122.57) v2(148.07,119.98) v2(148.12,119.37) v2(148.08,118.6) v2(148.12,117.92) v2(148.63,120.28) v2(148.63,119.67) v2(148.63,119.07) v2(148.68,118.46) v2(148.7,117.87) v2(149.18,120.51) v2(149.18,119.93) v2(149.18,119.34) v2(149.21,118.71) v2(149.29,118.05) v2(149.86,118.72) v2(149.87,118.06) v4(147.63,123.79)
+1.35VS_VGAP_B+:
  vias: v2(140.22,118.43) v2(140.29,117.85) v2(140.85,118.43) v2(140.88,117.85) v2(141.41,122.01) v2(141.39,121.35) v2(141.36,120.69) v2(141.44,118.4) v4(142.69,120.64)
+1V_MPHY:
  vias: v2(145.72,32.93) v2(145.74,33.73) v2(146.17,33.33) v2(146.66,33.71) v2(146.66,32.93) v2(151.06,37.84) v2(151.73,37.85) v2(152.41,37.85) v2(153.03,37.85) v2(165.29,34.74) v2(166.06,35.51) v2(166.06,34.74) v2(166.84,35.51) v2(167.61,35.51) v2(168.39,35.51) v4(167.95,36.05)
+1V_MPHY_MPHYPLL:
  vias: v2(156.37,42.89) v2(158.17,44.09) v4(155.46,44.17)
+1V_PCH: length 5.7
  BOTTOM w0.152: UH2.R19 169.44,36.61 v2(169.2,36.85) ; v2(172.06,31.64) 171.82,32.13 UH2.AD15 ; v2(171.36,37.4) 171.36,37.56 171.09,37.83 UH2.N17 ; UH2.R17 170.48,36.61 v2(170.25,36.84) ; v2(170.71,32.41) UH2.AC17 ; UH2.V17 v2(170.71,34.74) ; UH2.U20 v2(169.16,35.51)
  BOTTOM w0.203: v2(169.17,28.84) 169.02,28.99 UH2.AL22
  BOTTOM w0.254: v2(170.29,37.46) 170.66,37.83 UH2.N17
  vias: v4(169.22,38.28)
+1V_PCH_AZPLL: length 5.9
  TOP w0.381: 174.02,27.95 174.87,27.95 175.44,27.38 176.01,27.38 176.25,27.63 177,27.63 177.1,27.73 178.52,27.73 178.57,27.68 LH2.2
  BOTTOM w0.152: UH2.AN19 170.13,28.03 v2(170.24,28.03)
  vias: v3(171.92,28.67)
+1V_PCH_CLK5: length 1
  TOP w0.508: CH179.1 180.93,38.39 v2(180.6,38.73)
  vias: v3(181.09,38.37)
+1V_PCH_PRIM:
  vias: v2(166.06,33.16) v2(166.06,32.39) v2(166.84,33.96) v2(166.84,33.16) v2(166.84,32.39) v2(167.61,33.96) v2(167.61,32.39) v2(167.61,30.09) v2(168.39,30.09) v2(169.16,30.09) v2(176.31,36.21) v2(176.51,37.4) v2(176.9,36.21) v2(177.2,37.4) v2(177.76,36.21) v4(167.15,31.49)
+1V_PCH_USBPLL: length 4.4
  TOP w0.127: v2(176.29,28.18) 175.94,27.84 v3(175.65,27.84)
  TOP w0.508: v2(176.29,28.18) 176.29,28.76 CH202.1 176.98,28.69 CH201.1 178.83,28.69 RH123.2
+1V_VCCDSW: length 2.4
  TOP w0.127: 167.17,25.49 166.43,25.49
  TOP w0.508: 165.74,25.14 165.69,25.14 165.24,24.68 CH176.1 164.93,24.68 v2(164.47,24.22)
  vias: v3(166.41,27.56)
+1VALW: length 68.7
  TOP w0.508: v2(180.34,27.5) 179.94,27.5 LH2.1 179.76,27.81 180.35,28.4 RH123.1
  IN2 w0.508: v2(237.98,30.44) 237.98,29.43 236.1,27.55 234.91,27.55 232.85,25.49 232.85,19.17 232.93,19.09 232.93,14.88 v2(232.93,14.87)
  IN2 w1.27: 133.77,83.3 133.77,81.78 133.18,81.19 133.18,77.97 132.93,77.71 132.93,76.98 131.65,75.69 131.65,68.76 136.03,64.38 136.03,50.28 141.61,44.69 141.61,41.77
  BOTTOM w0.508: RH122.1 185.71,39.8 v2(185.73,39.82) ; RE116.2 237.98,29.73 v2(237.98,30.44)
  vias: v2(132.72,99.58) v2(132.72,98.95) v2(133.04,98.44) v2(133.36,99.58) v2(133.36,98.95) v2(140.19,41.38) v2(140.19,40.78) v2(140.73,40.2) v2(140.79,40.78) v2(146.73,35.18) v2(146.73,34.6) v2(147.32,35.18) v2(147.34,34.6) v2(147.8,34.22) v2(159.55,44.74) v2(159.57,44.14) v2(171.61,41.09) v2(171.64,40.5) v2(171.64,39.87) v2(172.53,39.74) v2(172.53,39.08) v2(172.58,40.45) v2(175.65,42.36) v2(178.8,38.15) v2(179.13,37.67) v2(179.27,38.56) v2(179.73,38.18) v2(179.73,37.58) v2(180.31,37.68) v2(206.02,27.47) v2(206.6,27.47) v2(212.4,28.58) v2(212.81,28.16) v2(229.8,14.03) v2(230.39,14.04) v2(230.59,14.61) v2(230.97,14.06) v2(231.19,14.63) v2(231.57,14.07) v2(231.77,14.65) v2(232.17,14.07) v2(232.36,14.66) v2(232.83,14.09) v4(132.97,100.56)
+1VALWP: length 16.6
  TOP w0.254: 238.06,12.08 238.06,10.71 238.62,10.15 250.81,10.15 250.86,10.2 250.86,11.34 PC606.1 PR602.1
  vias: v2(234.71,14.84) v2(234.72,14.21) v2(235.01,13.68) v2(235.32,14.84) v2(235.32,14.2) v2(235.9,14.86) v2(235.9,14.23) v2(236.5,14.84) v2(236.5,14.2) v2(237.08,14.84) v2(237.08,14.2) v4(238.4,13.27)
+1VS_GFX: length 42.4
  TOP w0.127: v4(160.16,102.3) 160.61,101.84 160.61,98.55 160.96,98.21 CV847.1
  TOP w0.508: RZ73.1 151.09,80.84 v2(151.55,80.38) ; v2(161.73,79.82) 161.73,79.45 CV848.1 ; RV199.2 RV200.2 143.04,61.97 v2(143.65,62.58)
  IN1 w0.381: v2(151.55,80.38) 151.55,79.77 151.11,79.34 151.11,75.68 149.96,74.53 149.96,72.58 150.28,72.26 152.62,72.26 153.53,73.17 153.53,74.3 155.35,76.12 155.35,77.35 156.14,78.14 156.14,78.3 156.89,79.04 157.52,79.04 159.07,80.6 160.93,80.6 161.7,79.82 v2(161.73,79.82)
  IN2 w0.508: 151.14,85.59 152.16,84.57 152.16,80.99 v2(151.55,80.38)
  BOTTOM w0.305: UV1.AG6 UV1.AF6 161.38,80.16 161.52,80.03 161.53,80.03 v2(161.73,79.82)
  vias: v2(146.48,85.22) v2(147.08,85.23) v2(149.46,85.21) v2(159.95,95.65) v2(160,93.18) v2(160.75,96.5) v2(160.77,95.65) v2(160.79,93.16) v2(160.74,90.64) v2(161.25,94.62) v2(161.29,93.47) v2(161.34,91.01) v2(209.51,43.32) v2(209.6,45.23) v2(209.6,44.59) v2(209.6,43.96) v2(210.14,44.92) v2(210.14,44.29) v2(210.14,43.65) v2(210.09,43.02)
+2.5V_MEM: length 14.8
  TOP w0.635: 139.41,38.9 140.65,38.9 v4(143.95,35.6) 144.65,34.9 144.65,30.46 142.68,28.49 142.68,27.82
  vias: v2(138.32,41.82) v2(138.9,41.8) v2(138.85,26.66) v2(139.48,26.66)
+2.5VSP_ON: length 5.4
  BOTTOM w0.127: v3(144.91,14.19) 144.91,15.04 145.44,15.57 145.44,15.66 146.09,16.31 PR1801.2
  BOTTOM w0.508: PU1800.2 146.23,17.21 PC1800.1 PR1801.2
+3.3VDX_SSD: length 5.8
  TOP w0.102: v2(217.88,36.5) 216.56,36.5 v4(216.13,36.93) ; v2(217.88,36.5) v4(219,35.38) ; v2(217.88,36.5) 217.42,36.96 v4(217.42,38.56)
+3V_DVDD: length 3.2
  TOP w0.508: v2(276.39,29.35) 276.39,30.11 275.9,30.6 RA23.1
  BOTTOM w0.508: RA70.2 276.49,28.18 276.26,28.41 v2(275.42,28.41)
  vias: v2(277.33,21.15) v2(277.76,21.61) v4(276.96,21.66)
+3V_PCH_AZIO: length 3.6
  TOP w0.457: CH200.1 171.69,25.24 171.49,25.04 v2(171.49,24.67) 171.64,24.53 171.71,24.53 v3(171.95,24.29) 172.2,24.04 LH1.2
  BOTTOM w0.203: v2(171.49,24.67) 171.57,24.67 172.1,24.14 UH2.BA15
+3V_PCH_DSW: length 33.5
  TOP w0.508: CH82.1 171.33,34.26 v2(171.59,34) ; v2(172.09,14.73) 172.64,14.19 RH125.2 ; v2(166.97,23.02) v3(166.97,21.95) 166.97,21.37 166.58,20.98 166.58,20.14 166.61,20.11 166.61,19.6 166.35,19.35 166.35,17.54 166.58,17.31 166.82,17.31 168.02,16.11 RH137.2 168.17,15.48 v2(169.21,15.48)
  IN3 w0.508: v2(171.59,34) 171.38,33.8 171.38,29.91 170.95,29.48 168.62,29.48 167.42,28.29 167.42,25.67 167.37,25.61 167.37,23.42 v2(166.97,23.02)
  IN4 w0.508: v2(172.09,14.73) 171.35,15.48 v2(169.21,15.48)
  BOTTOM w0.127: UH2.BA24 167.23,23.76 167.23,23.28 v2(166.97,23.02)
  BOTTOM w0.203: UH2.W15 171.59,34.35 v2(171.59,34)
  BOTTOM w0.508: RH17.2 170.9,15.23 RH81.2 169.47,15.23 v2(169.21,15.48) ; RH181.2 v2(172.09,14.73)
+3V_PCH_SPI:
  vias: v4(153.55,22.08)
+3V_ROM: length 17.1
  IN1 w0.508: v2(162.58,16.18) 165.74,16.18 166.89,17.33 168.6,17.33 171.27,14.66 171.27,12.97 v2(171.03,12.73)
  BOTTOM w0.381: 171.41,12.25 171.03,12.63 v2(171.03,12.73)
  BOTTOM w0.508: UH8.8 173.38,11.55 v3(173.12,11.8) 172.29,11.8 RH121.1 171.41,12.25 ; v2(162.58,16.18) RH74.1
+3V_RTM: length 35.1
  TOP w0.203: CM842.1 264.12,30.17 264.12,31.22 265.31,32.41 UM1.1
  TOP w0.508: RM594.1 RM595.1 263.79,26.79 v4(263.38,27.2) 262.9,27.68 v2(262.9,29.45) 263.13,29.68 263.64,29.68 CM842.1 ; v2(270.01,45.2) RM592.1 RM593.1 RM591.1 266.29,44.44 RM582.2 RM583.2 263.96,44.51 RM590.1
  IN2 w0.508: v2(271.31,40.99) 270.93,40.6 270.93,40.02 270.71,39.8 270.71,33.49 269.37,32.15 267.97,32.15 265.28,29.45 v2(262.9,29.45)
  vias: v2(271.66,40.45)
+3VALW: length 622.2
  TOP w0.127: v2(184.07,20.77) 184.08,20.75 184.81,20.75 v4(184.95,20.61)
  TOP w0.254: RI30.1 277.38,37.71 276.67,37 276.67,36.21 v2(277.17,35.7) ; RT1.1 109.31,83.73 v2(108.9,83.33) ; RPE7.4 RPE7.3 RPE7.2 RPE7.1 240.43,22.61 240.69,22.86 v2(240.69,23.18)
  TOP w0.305: JAPS.3 174.18,11.09 174.53,10.73 v2(176.34,10.73) 176.19,10.88 176.18,10.88 JAPS.7 ; JIO1.28 10.36,36.25 11.14,35.47 ; JAPS.1 173.18,12.05 v2(172.75,12.48)
  TOP w0.381: CC298.1 131.84,75.61 132.1,75.61 132.16,75.67 UC16.5 ; UZ21.5 187.82,21.74 v2(188.87,20.68) ; RH23.1 158.82,24.4 158.82,25.53 RH25.1
  TOP w0.457: v2(154.31,78.7) 154.31,78.6 154.94,77.97 154.94,76.52 RZ104.1 ; v2(158.98,83.86) 158.18,83.86 157.6,83.28 RZ105.1
  TOP w0.508: CC298.1 132.14,74.95 134.4,74.95 v2(134.73,74.62) 135.01,74.34 v4(136.53,74.34) 138.24,76.04 144.76,76.04 v2(145.29,75.5) ; v2(277.29,34.66) RI9.1 RI10.1 ; v2(169.96,17.17) 169.68,17.44 RH67.2 ; UE4.5 139.82,16.43 139.91,16.35 RZ32.2 141.46,16.35 ; LH1.1 172.06,22.41 RH126.2 170.71,22.66 170.71,22.91 170.27,23.36 v2(170.27,23.79) 170.8,24.32 CH186.1 ; v2(230.59,36.1) 230.59,35.45 RE113.2 ; v2(141.42,15.4) 141.51,15.48 141.51,16.3 141.46,16.35 ; PR707.1 v2(65.47,62.47) ; v2(196.35,20.56) 196.35,20.95 197.24,21.83 197.95,21.83 198.89,22.77 198.89,25.21 198.13,25.97 RN2.1 ; RZ103.1 149.51,104.28 148.28,105.51 v2(147.51,105.51) ; v2(158.89,28.18) 158.84,28.23 CH191.1 158.84,28.84 v2(159.37,29.38) ; RH64.1 159.61,24.29 RH23.1 158.71,23.9 158.28,23.47 v2(158.28,23.03) ; v2(156.4,18.99) 156.4,20.06 156.58,20.23 ; v2(216.75,29.96) 216.85,29.86 RE39.2 ; RH65.1 RH130.1 163.73,29.4 v2(163.26,29.4) ; 141.46,16.35 RZ33.1 ; RH137.1 166.15,16.11 166,16.11 165.49,16.61 v2(165.49,16.88) RH82.1 165.29,17.95 164.78,18.46 RH92.1 ; 156.58,20.23 RH66.1 RH63.1 ; 156.58,20.23 155.99,20.23 155.15,21.07 155.15,21.71 154.52,22.34 RH22.1 154.82,22.72 v2(155.2,23.1) ; v2(153.2,32.74) 153.52,32.42 RH110.2 153.83,31.58 RH131.2 ; CH192.1 v2(156.59,22.99) ; RE12.1 240.93,19.84 v2(240.93,19.6) ; CH189.1 175.93,26.53 v2(176.46,27.07) ; RE25.1 242.48,25.21 v2(242.48,24.93) ; v2(12.96,34.79) 12.97,34.79 13.65,34.79 14.01,35.15 CZ105.1 11.14,35.47 ; v2(153.15,34.2) RH135.2 RH68.2 ; RZ12.1 210.96,73.9 212.1,75.05 212.1,76.7 v2(211.34,77.46) 212.1,78.22 212.1,112 v2(210.96,113.15) ; v2(34.93,39.11) 34.93,38.6 35.42,38.12 35.42,35.93 35.24,35.75 34.3,34.81 v2(34.3,33.39) ; v2(280.91,17.29) RA17.2 ; v2(16.39,24.88) 15.81,25.47 PR101.1 ; v2(159.42,31.74) 159.42,32.02 159.08,32.36 CH190.1 ; RH21.1 151.29,20.36 v2(151.53,20.6)
  IN1 w0.508: v2(210.96,113.15) 211.21,113.4 211.21,113.91 210.32,114.8 206.89,114.8 v2(205.5,116.2) ; v2(153.15,34.2) 152.52,34.2 v2(152.08,34.64) ; v2(150.04,23.1) 150.04,23.86 149.54,24.37 145.39,24.37 143.28,26.48 143.28,28.2 142.39,29.09 142.39,40.33 140.26,42.46 v2(138.82,42.46) ; v2(63.84,44.06) 63.84,43.96 64.32,43.47 64.32,39.72 63.69,39.08 63.69,38.52 ; v2(147.51,105.51) 147.92,105.51 148.79,104.64 148.79,101.94 150.28,100.45 150.28,88.18 153.51,84.94 153.51,84.44 154.91,83.04 158.15,83.04 v2(158.98,83.86)
  IN2 w0.381: v2(226.2,28.13) 226.2,28.44 226.83,29.07 229.86,29.07
  IN2 w0.508: v2(230.06,30.34) 230.03,30.32 230.03,30.09 229.86,29.91 229.86,27.02 230.72,26.15 230.77,26.15 231.89,25.03 v2(231.89,24.32) ; v2(234.35,20.87) 235.54,19.68 240.85,19.68 v2(240.93,19.6) ; v2(176.46,27.07) 176.08,26.69 176.08,25.44 178.24,23.28 178.24,22.1 ; v2(222.35,20.61) 222.35,20.75 221.73,21.38 217.84,21.38 216.63,22.59 v2(216.63,26.23) 216.63,29.81 216.75,29.94 ; v2(158.98,83.86) 158.98,83.44 157.67,82.13 156.73,82.13 155.86,81.27 155.86,80.51 154.91,79.56 154.73,79.56 154.31,79.14 v2(154.31,78.7) 154.31,78.36 152.83,76.88 151.47,76.88 150.16,78.18 147.42,78.18 146.68,77.45 146.68,76.02 146.16,75.5 v2(145.29,75.5) ; 216.75,29.94 v2(216.75,29.96) ; 216.75,29.94 216.77,29.94 219.51,32.68 220.23,32.68 220.59,32.32 221.44,32.32 222.01,32.88 v2(222.01,33.11) ; v2(48.84,40.76) 49.39,40.76 49.68,41.05 49.68,41.77 49.37,42.08 v2(48.84,42.08) 48.84,42.89 49.81,43.86 58.43,43.86 59.01,43.27 61.76,43.27 62.54,44.06 v2(63.84,44.06)
  IN3 w0.254: v2(138.82,42.46) 138.82,43.55 137.47,44.9 137.47,49.88 137.06,50.29 137.06,54.08 137.65,54.67 137.65,66.38 135.93,68.11 133.74,70.29 133.74,75.05 134.76,76.06 134.76,79.98 v2(131.95,82.79)
  IN3 w0.508: 15.86,34.46 15.91,34.41 15.96,34.46 21.57,34.46 22.97,35.85 22.97,36.06 25.44,38.52 27.29,38.52 27.87,39.11 v2(34.93,39.11) 34.93,38.47 35.78,37.63 43.57,37.63 43.57,37.63 43.74,37.63 45.35,39.25 46.67,39.25 48.18,40.76 v2(48.84,40.76) ; 15.86,34.46 15.86,25.42 v2(16.39,24.88) 16.47,24.81 16.47,21.05 19.64,17.87 22.41,17.87 25.76,14.53 v2(26.93,14.53) ; 15.86,34.46 15.54,34.78 12.98,34.78 v2(12.96,34.79) ; 268.87,16.63 273.77,16.63 274.43,15.97 279.59,15.97 v2(280.91,17.29) ; v2(211.34,77.46) 212.53,76.27 212.53,72 213.81,70.72 213.81,69.5 214.41,68.9 214.41,61.66 213.01,60.26 213.01,58.21 210.88,56.07 210.88,51.3 209.8,50.22 209.8,49.49 209.11,48.81 209.11,46.46 207.81,45.15 207.81,42.13 210.07,39.86 215.52,39.86 216.16,40.5 219.03,40.5 219.75,41.21 221.12,41.21 v2(221.7,41.8)
  IN4 w0.254: v2(131.95,82.79) 131.44,82.29 125.92,82.29 125.49,81.85 124.39,81.85 123.89,82.36 123.89,83.25 122.7,84.43 121.84,84.43 121.4,84.88 119.64,84.88 119.09,84.32 109.56,84.32 108.93,83.68 108.93,83.35 v2(108.9,83.33)
  IN4 w0.508: v2(63.84,44.06) 63.79,44.11 63.79,44.49 66.28,46.98 66.28,55.81 63.94,58.14 63.94,60.52 65.47,62.04 v2(65.47,62.47) ; v2(138.82,42.46) 138.92,42.46 139.46,42.99 139.46,66.74 134.73,71.47 v2(134.73,74.62) ; v2(230.06,30.34) v2(230.95,30.34)
  BOTTOM w0.203: UH2.BA31 163.66,23.96 v2(163.31,24.32) ; RE28.2 226.07,28.27 v2(226.2,28.13)
  BOTTOM w0.254: 230.95,30.42 v2(230.95,30.34) ; 230.95,30.42 230.95,30.6 231.15,30.8 231.15,30.82 231.26,30.94 RPE3.5 ; 230.95,30.42 230.76,30.6 RPE3.6 ; PU500.13 102.05,9.74 102.5,9.29 v2(102.6,9.29) ; v2(230.06,30.34) 230.06,30.37 ; 230.06,30.37 230.26,30.57 230.26,31.16 RPE3.7 ; 230.06,30.37 230.06,30.47 229.77,30.76 RPE3.8 ; 234.59,21.4 234.59,21.75 234.67,21.82 RPE6.4 ; 234.59,21.4 234.35,21.16 v2(234.35,20.87) 234.4,20.82 RPE6.2 ; 234.59,21.4 234.67,21.32 RPE6.3 ; RPE6.1 234.44,20.32 234.35,20.23 ; UH2.AD41 159.06,32.1 v2(159.42,31.74) ; UH2.BC42 159.42,22.64 UH2.BD40 ; PR1009.1 208.13,113.51 PC1013.1
  BOTTOM w0.305: QH5.5 151.27,25.95 151.53,26.22 v2(151.53,26.46) ; UH2.AN5 176.46,27.32 v2(176.46,27.07) ; PU1000.15 206.12,116.44 205.88,116.2 v2(205.5,116.2) ; v2(170.27,23.79) 170.14,23.91 UH2.BA20
  BOTTOM w0.356: RH493.2 150.75,23.09 151.27,23.61 QH5.2
  BOTTOM w0.381: RE38.1 232.24,23.87 231.89,24.22 v2(231.89,24.32)
  BOTTOM w0.508: v2(34.3,33.39) 34.17,33.52 PR312.1 ; RE30.2 234.96,19.17 234.35,19.78 v2(234.35,20.87) ; v2(34.93,39.11) 34.81,38.98 PR320.2 ; v2(70.44,64.07) 69.05,64.07 67.45,62.47 v2(65.47,62.47) ; RE34.1 222.67,20.93 v2(222.35,20.61) ; v2(26.93,14.53) 26.56,14.53 PR112.2 ; PC1013.1 209.09,112.55 210.36,112.55 v2(210.96,113.15) 211.69,113.88 211.69,116.09 210.88,116.91 PR1000.2 ; PR606.1 v2(251.6,10.66) ; PC506.1 103.29,8.7 102.7,9.29 v2(102.6,9.29) ; RH121.2 172.59,13.64 172.75,13.48 v2(172.75,12.48) ; RH193.2 183.54,20.06 184.07,20.59 v2(184.07,20.77) ; v2(150.04,23.1) 150.45,22.7 RH493.2 150.75,20.64 PR1800.1 v2(151.53,20.6) ; v2(225.36,38.55) 225.36,38.88 224.83,39.41 PR809.1 ; RH128.2 170.57,17.78 v2(169.96,17.17) ; v2(151.53,26.46) 151.32,26.46 150.81,26.96 RH62.1 ; RH91.1 153.44,28.48 v2(153.1,28.48) ; PR202.1 49.16,42.08 v2(48.84,42.08) ; v2(97.77,6.8) PR504.1 ; v2(145.29,75.5) CV212.1 145.23,76.3 UV14.5 ; PR208.1 v2(48.84,40.76)
  vias: v2(64.14,37.76) v2(64.14,37.07) v2(64.48,38.32) v2(67.7,37.94) v2(69.25,18.68) v2(69.86,18.68) v2(70.49,18.66) v2(77.23,15.61) v2(77.23,15) v2(77.86,15.61) v2(77.86,15) v2(78.5,15.61) v2(78.5,15) v2(79.13,15.61) v2(79.13,15) v2(79.77,15.61) v2(79.77,15) v2(80.4,15.61) v2(80.4,15) v2(154.98,14.33) v2(154.98,13.72) v2(154.99,13.13) v2(155.56,14.33) v2(155.57,13.71) v2(155.57,13.12) v2(156.18,14.34) v2(156.17,13.72) v2(156.17,13.13) v2(156.77,14.33) v2(156.77,13.74) v2(157.35,14.33) v2(177.43,21.5) v2(178.01,21.5) v2(216.49,15.05) v2(217.09,15.05) v2(217.5,13.5) v2(217.68,15.05) v2(217.78,12.96) v2(218.08,13.5) v2(218.27,15.05) v2(218.36,12.96) v2(218.86,15.05) v2(218.95,12.96) v2(219.53,12.96) v2(220.15,12.96) v2(223.28,11.06) v2(223.91,11.04) v2(232.57,37.18) v2(232.84,36.65) v2(233.83,46.66) v2(242.2,19.42) v2(242.5,18.86) v2(242.78,19.4) v2(243.11,18.89) v2(243.47,19.4) v2(243.82,18.89) v2(249.06,13.2) v2(275.41,34.65) v2(276.01,34.66) v2(276.49,35.7) v2(276.64,34.67) v4(216.93,14.46)
