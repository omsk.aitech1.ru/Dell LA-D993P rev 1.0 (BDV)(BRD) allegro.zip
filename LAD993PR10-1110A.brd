# Allegro board LAD993PR10-1110A.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
TMDS_T_TX1P: length 51.1
  TOP w0.089: UM1.20 270.93,36.53 271.09,36.37 272.55,36.37 275.47,39.29 275.47,48.03 v1(277.61,50.17) 290.73,63.29 290.73,68.8 292.92,71 294.6,71 295.35,71.75 296.09,71.75 296.62,72.28 296.62,72.55 296.53,72.63 296.27,72.63 296.18,72.72 LV26.1 296.01,73.57 RV625.1
TMDS_T_TX2N: length 48.8
  TOP w0.089: RV628.1 294.94,73.57 LV27.4 294.77,72.89 295.02,72.65 295.02,72.31 294.2,71.49 292.72,71.49 290.23,69 290.23,63.54 v1(280.58,53.9) 274.97,48.28 274.97,39.49 272.81,37.33 UM1.22
TMDS_T_TX2P: length 48.8
  TOP w0.089: UM1.23 271,37.73 271.16,37.57 272.71,37.57 274.73,39.59 274.73,48.38 v1(275.58,49.23) 289.99,63.64 289.99,69.1 292.62,71.73 294.1,71.73 294.78,72.41 294.78,72.55 294.69,72.63 294.36,72.63 294.27,72.72 LV27.1 294.11,73.57 RV627.1
TMDS_T_TXCN: length 44.8
  TOP w0.089: UM1.13 271.19,33.73 271.74,33.19 CM843.2 273.02,33.4 273.71,33.4 274.33,34.03 274.33,35.52 277.18,38.38 277.18,47.21 v1(283.83,53.86) 287.75,57.78 287.98,57.78 288.36,57.4 288.71,57.4 289.08,57.77 289.08,58.12 288.65,58.55 288.65,58.68 289.16,59.18 291.87,59.18 294.38,61.7 294.38,62.6 LV24.4 294.69,62.91 RV622.1
TMDS_T_TXCP: length 44.8
  TOP w0.089: RV621.1 293.85,62.91 LV24.1 294.14,62.62 294.14,61.8 291.77,59.43 289.06,59.43 288.41,58.78 288.41,58.45 288.84,58.02 288.84,57.87 288.61,57.64 288.46,57.64 288.08,58.02 287.65,58.02 v1(282.33,52.7) 276.94,47.31 276.94,38.48 274.09,35.62 274.09,34.13 273.61,33.65 273.26,33.65 CM843.1 272.13,33.43 271.84,33.43 271.14,34.13 UM1.14
TOUCH_SCREEN_PD#: length 100.4
  TOP w0.114: DI1.1 64.08,28.06 67.18,28.06 v3(67.95,28.83) 68.03,28.83 68.88,29.68 68.88,31.6 v2(68.72,31.77)
  IN3 w0.127: v2(68.72,31.77) 68.77,31.82 69.94,31.82 70.31,32.19 106.45,32.19 109.81,28.84 140.86,28.84 142.62,30.6 v2(143.71,30.6)
  BOTTOM w0.114: UH2.AE44 157.57,31.58 157.17,31.18 155.92,31.18 RH69.1 154.87,30.01 154.42,29.56 152.32,29.56 151.93,29.95 150.75,29.95 150.1,30.6 v2(143.71,30.6)
TOUCHPAD_INTR#: length 6.6
  TOP w0.114: v2(167.98,23.84) 167.78,23.64 v3(167.78,23.03) 167.78,22.66 DH1.2 168.28,21.94 167.72,21.37 167.72,20.48 167.31,20.07 167.31,19.15 RH179.1
  BOTTOM w0.089: v2(167.98,23.84) 167.98,23.82 168.03,23.76 168.03,23.14 UH2.BC23
TP_PW_EN#: length 106.8
  TOP w0.114: v2(227.82,14.54) 227.82,14.81 228.25,15.24 UE1.49 ; UE4.4 138.83,14.53 138.55,14.81 138.55,16.78 139.42,17.64 v3(139.66,17.64) 139.84,17.64 140.22,17.26 RZ32.1 v2(140.6,18.02)
  IN3 w0.127: v2(140.6,18.02) 141.61,17.01 145.16,17.01 145.41,16.77 148.82,16.77 152.06,13.53 152.06,11.53 153.05,10.54 160.96,10.54 162.46,12.05 167.75,12.05 171.51,8.28 171.55,8.28 171.65,8.18 179.55,8.18 180.3,8.93 183.27,8.93 185.23,10.89 194.32,10.89 199.61,16.18 205.01,16.18 205.01,16.18 205.2,16.18 209.52,16.18 211.11,14.6 219.3,14.6 220.28,15.57 221.41,15.57 221.64,15.8 226.98,15.8 227.82,14.96 v2(227.82,14.54)
TRIP_+1.35VS_VGAP: length 2.9
  BOTTOM w0.254: PR902.2 142.99,110.63 141.59,110.63 141.31,110.92 PU900.2
UART2_RXD: length 90.8
  TOP w0.114: v2(186.18,32.8) 187.2,32.8 190.8,36.39 190.8,39.19 191.58,39.97 191.58,43.47 192.6,44.5 199.16,44.5 199.34,44.67 201.05,44.67 202.18,43.54 202.18,43.06 202.59,42.64 205.27,42.64 v2(205.98,43.35) ; v2(156.25,27.19) 157.48,27.19 v4(157.63,27.04)
  IN4 w0.094: v2(186.18,32.8) 185.81,32.43 181.39,32.43 181.21,32.25 181.21,31.63 180.71,31.12 180.48,31.12 180.14,30.79 180.14,30.35 179.84,30.05 173.91,30.05 173.73,29.87 172.84,29.87 172.79,29.92 171.02,29.92 170.77,29.67 164.37,29.67 162.86,28.16 162.68,28.16 161.3,26.79 158.63,26.79 158.48,26.63 157.54,26.63 156.98,27.19 v2(156.25,27.19)
  BOTTOM w0.089: UH2.AR45 157.15,27.07 156.37,27.07 v2(156.25,27.19)
  BOTTOM w0.114: JUART.3 212.94,60.3 212.51,59.86 212.51,57.39 210.91,55.79 210.17,55.79 209.46,55.08 209.46,52 210.35,51.11 210.35,48.43 209.89,47.97 209.89,47.49 210.27,47.11 210.27,46.32 209.79,45.84 208.8,45.84 206.31,43.35 v2(205.98,43.35) ; v2(156.25,27.19) 156.25,27.27 155.86,27.65 155.51,27.65 RH160.2
UART2_TXD: length 91
  TOP w0.114: v2(160.24,27.29) 159.83,27.7 159.39,27.7 159.22,27.52 156.5,27.52 156.32,27.7 v4(155.95,27.7) 155.32,27.7 155.1,27.93 RH159.2 ; v2(203.46,43.14) 203.18,42.86 202.68,42.86 202.4,43.14 202.4,43.63 200.87,45.16 200.87,45.83 199.89,46.81 194.6,46.81 191.35,43.55 191.35,40.06 190.31,39.03 190.31,37.81 189.87,37.37 189.87,36.56 186.6,33.29 v2(185.43,33.29)
  IN4 w0.094: v2(185.43,33.29) 185.43,33.1 185,32.67 181.35,32.67 180.96,32.27 180.96,31.73 180.64,31.42 180.01,31.42 178.84,30.24 173.82,30.24 173.65,30.07 173.34,30.07 173.06,30.34 171.33,30.34 171.14,30.52 164.95,30.52 162.83,28.41 162.57,28.41 161.45,27.29 v2(160.24,27.29)
  BOTTOM w0.089: UH2.AR39 159.84,26.89 v2(160.24,27.29)
  BOTTOM w0.114: JUART.2 213.16,61.1 212.25,60.19 212.25,57.47 210.86,56.07 210.07,56.07 209.15,55.16 209.15,51.75 210.12,50.79 210.12,48.52 209.66,48.07 209.66,47.39 210.04,47.01 210.04,46.41 209.69,46.07 208.72,46.07 206.92,44.26 205.27,44.26 204.15,43.14 v2(203.46,43.14)
UG_3V: length 16.7
  TOP w0.127: v2(50.94,19.04) v3(50.14,19.04)
  IN1 w0.635: v2(50.94,19.78) v2(50.94,19.04) 50.94,14.32 54.91,10.34 v2(59.06,10.34) v2(59.76,10.34)
UG_5V:
  vias: v2(50.68,28.57) v2(50.68,27.93) v2(51.04,23.74) v2(51.04,23.1) v4(50.95,25.82)
UG_+1.35VS_VGAP: length 8
  IN1 w0.635: v2(141.61,115.31) v2(142.07,115.76) 142.07,116.22 143.39,117.54 143.39,122.09 v2(143.75,122.44)
  vias: v2(143.77,123.08) v4(143.22,122.62)
USB2_COMP: length 3.5
  TOP w0.114: RH109.1 179.08,30.37 179.16,30.44 v2(179.16,31.13) 178.91,31.37 v3(178.65,31.37)
  BOTTOM w0.102: UH2.AG3 177.82,30.62 178.1,30.9 178.54,30.9 178.7,31.05 179.08,31.05 v2(179.16,31.13)
USB2_ID: length 6.9
  BOTTOM w0.076: 181.71,33.71 181.71,33.23 180.98,32.5 180.98,31.79 180.15,30.95 179.51,30.95 179.33,30.77 178.7,30.77 178.55,30.62 UH2.AG2
  BOTTOM w0.114: RH113.1 182.13,34.83 181.71,34.41 v3(181.71,33.96) 181.71,33.71
USB2_VBUSSENSE: length 3.7
  TOP w0.114: v3(176.16,33.54) 176.16,32.91 v2(175.85,32.6) 175.71,32.46 RH112.1
  BOTTOM w0.089: UH2.AD10 175,32.13 175.3,31.84 175.55,31.84 175.85,32.15 v2(175.85,32.6)
USB3RN1: length 135.2
  IN1 w0.094: v2(279.18,41.25) 278.95,41.02 278.95,40.77 278.68,40.51 274.54,40.51 273.63,39.6 269.02,39.6 267.63,38.21 267.63,37.85 267.05,37.26 264.6,37.26 263.95,36.62 263.09,36.62 258.91,32.44 245.58,32.44 244.05,33.97 239.39,33.97 239.24,34.12 230.64,34.12 230.13,33.61 220.53,33.61 219.67,32.75 212.27,32.75 210.96,34.07 209.19,34.07 207.32,35.94 202.11,35.94 201.49,36.56 194.29,36.56 191.63,39.23 190.15,39.23 188.5,40.88 183.05,40.88 182.68,41.25 179.52,44.41 176.81,44.41 176.49,44.73 176.49,44.9 v2(176.29,45.1)
  BOTTOM w0.076: UH2.B7 175.92,43.11 175.48,43.54 175.48,43.79 175.81,44.12 175.96,44.12 176.39,44.55 176.39,45 v2(176.29,45.1)
  BOTTOM w0.114: v2(279.18,41.25) 279.04,41.39 278.93,41.39 278.75,41.21 278.75,41.07 279.05,40.77 279.7,40.77 280.36,40.11 280.36,38.19 280.53,38.03 280.53,32.45 280.87,32.1 283.05,32.1 283.58,32.64 284.32,32.64 285.98,34.3 287.66,34.3 RI40.1
USB3RN1_D-: length 10.7
  BOTTOM w0.114: JUSB1.5 297.91,33.95 297.76,33.8 297.29,33.8 296.81,33.31 294.51,33.31 294.13,33.69 294.11,33.69 293.77,34.02 v1(292.94,34.02) 292.37,34.02 292.25,34.14 DI9.1 DI9.9 290.77,34.14 290.62,33.99 290.34,33.99 290.06,34.27 289.31,34.27 288.93,34.65 RI40.2
USB3RN2: length 133.1
  IN1 w0.094: v2(175.02,44.57) 175.24,44.79 175.24,44.95 176.01,45.72 180.62,45.72 182.81,43.52 182.81,42.31 183.39,41.73 187.41,41.73 187.41,41.73 187.72,41.73 188.43,42.44 190.41,42.44 191.37,41.48 191.37,40.57 194.16,37.79 201.92,37.79 202.99,36.71 208.09,36.71 209.22,35.58 210.73,35.58 212.06,34.25 214.26,34.25 214.39,34.38 229.65,34.38 230.18,34.92 239.54,34.92 239.71,34.74 244.56,34.74 245.33,33.97 259.04,33.97 264.22,39.16 266.51,39.16 268.97,41.62 271.51,41.62 280.3,50.41 284.95,50.41 285.89,51.35 285.89,52.9 285.89,53.05 286.17,53.34 286.33,53.34 286.4,53.34 v2(286.65,53.58)
  BOTTOM w0.076: UH2.C8 175.03,43.11 175.03,43.35 175.1,43.44 175.1,44.48 v2(175.02,44.57)
  BOTTOM w0.114: v2(286.65,53.58) 286.93,53.3 288.35,53.3 288.5,53.45 288.64,53.45 288.81,53.62 RI44.1
USB3RN2_D-: length 10
  BOTTOM w0.114: JUSB2.5 297.91,54.65 297.8,54.53 297.38,54.53 296.61,53.77 295.34,53.77 294.61,53.04 v1(294.19,53.04) 293.53,53.04 293.38,53.19 DI7.1 DI7.9 291.89,53.19 291.78,53.08 291.56,53.08 291.32,53.32 290.38,53.32 290.25,53.45 289.89,53.45 289.72,53.62 RI44.2
USB3RN3: length 199.4
  TOP w0.114: v2(13.32,23.46) 13.12,23.26 12.13,23.26 11.03,24.35 11.03,31.84 10.77,32.11 10.49,32.11 10.35,32.25 JIO1.20
  IN4 w0.094: v2(13.32,23.46) 13.22,23.36 12.81,23.36 12.58,23.12 12.58,22.52 18.77,16.32 21.7,16.32 23.8,14.22 24.75,14.22 26.78,12.19 45.98,12.19 48.54,14.75 49.18,14.75 53.45,19.01 55.41,19.01 57.77,21.38 61.63,21.38 65.44,25.19 67.22,25.19 70.65,28.62 111.54,28.62 112.13,28.03 116.95,28.03 117.54,28.62 137.21,28.62 145.67,37.07 146.48,37.07 147.01,37.6 147.01,40.33 150.73,44.06 154.77,44.06 156.5,45.79 160.79,45.79 161.58,46.57 174.14,46.57 174.45,46.26 174.45,46.04 v2(174.25,45.84)
  BOTTOM w0.076: v2(174.25,45.84) 174.44,45.65 174.44,45.57 174.25,45.38 174.25,44.92 174.44,44.73 174.44,44.12 174.58,43.98 174.58,43.51 174.72,43.37 UH2.B10
USB3RP1: length 135.2
  IN1 w0.094: v2(278.32,41.29) 278.39,41.37 278.6,41.37 278.77,41.2 278.77,40.85 278.61,40.69 274.46,40.69 273.55,39.79 268.94,39.79 267.45,38.29 267.45,37.93 266.97,37.45 264.52,37.45 263.88,36.8 263.01,36.8 258.84,32.63 245.65,32.63 244.13,34.16 239.47,34.16 239.32,34.31 230.57,34.31 230.06,33.8 220.46,33.8 219.6,32.94 212.35,32.94 211.03,34.25 210.88,34.25 209.27,34.25 207.4,36.13 202.19,36.13 201.57,36.75 194.37,36.75 191.71,39.41 190.23,39.41 188.58,41.06 183.13,41.06 179.6,44.59 176.89,44.59 176.67,44.8 176.67,44.97 176.8,45.1 v2(177.05,45.1)
  BOTTOM w0.076: v2(177.05,45.1) 176.77,45.1 176.67,45 176.67,44.92 176.55,44.81 176.55,44.48 176.03,43.96 175.88,43.96 175.64,43.72 175.64,43.61 175.75,43.51 175.86,43.51 175.89,43.54 UH2.A7
  BOTTOM w0.114: RI39.1 287.59,34.08 286.08,34.08 284.41,32.41 283.68,32.41 283.14,31.88 280.78,31.88 280.3,32.36 280.3,37.93 280.14,38.1 280.14,40.02 279.61,40.55 278.96,40.55 278.53,40.98 278.53,41.08 v2(278.32,41.29)
USB3RP1_D+: length 10.7
  BOTTOM w0.114: RI39.2 289.34,34.05 289.97,34.05 290.25,33.76 290.62,33.76 290.75,33.64 DI9.8 DI9.2 292.25,33.64 292.41,33.8 292.65,33.8 292.67,33.78 293.21,33.78 293.22,33.8 293.68,33.8 v1(294.15,33.33) 294.39,33.09 296.9,33.09 297.39,33.57 297.83,33.57 297.91,33.49 JUSB1.6
USB3RP2: length 133.1
  IN1 w0.094: v2(175.78,44.57) 175.52,44.57 175.42,44.67 175.42,44.87 176.08,45.53 180.54,45.53 182.63,43.44 182.63,42.23 183.32,41.54 187.49,41.54 187.49,41.54 187.79,41.54 188.5,42.26 190.33,42.26 191.19,41.4 191.19,40.5 194.08,37.6 201.84,37.6 202.92,36.53 208.01,36.53 209.15,35.4 210.65,35.4 211.98,34.07 214.34,34.07 214.46,34.2 229.73,34.2 230.26,34.73 239.46,34.73 239.64,34.56 244.48,34.56 245.25,33.78 259.11,33.78 264.3,38.97 266.58,38.97 269.04,41.43 271.58,41.43 280.37,50.22 285.02,50.22 286.07,51.27 286.07,52.97 286.25,53.15 286.49,53.15 286.65,52.99 v2(286.65,52.82)
  BOTTOM w0.076: v2(175.78,44.57) 175.63,44.72 175.47,44.72 175.4,44.64 175.4,44.44 175.26,44.31 175.26,43.51 175.35,43.42 175.35,43.32 UH2.B8
  BOTTOM w0.114: RI43.1 288.81,52.79 288.64,52.95 288.45,52.95 288.33,53.08 286.9,53.08 v2(286.65,52.82)
USB3RP2_D+: length 10.1
  BOTTOM w0.114: RI43.2 289.72,52.79 289.89,52.95 290.29,52.95 290.41,53.08 v1(290.93,53.08) 291.24,53.08 291.47,52.86 291.71,52.86 291.88,52.69 DI7.8 DI7.2 293.4,52.69 293.53,52.81 293.9,52.81 293.92,52.8 294.46,52.8 294.48,52.81 294.71,52.81 295.44,53.55 296.71,53.55 297.47,54.31 297.8,54.31 297.91,54.19 JUSB2.6
USB3RP3: length 199.4
  TOP w0.114: JIO1.19 10.25,31.75 10.38,31.89 10.67,31.89 10.81,31.75 10.81,24.26 12.03,23.03 13.08,23.03 v2(13.31,22.8)
  IN4 w0.094: v2(13.31,22.8) 13.31,22.86 13,23.17 12.89,23.17 12.76,23.04 12.76,22.6 18.85,16.51 21.78,16.51 23.88,14.41 24.82,14.41 26.86,12.37 45.91,12.37 48.46,14.93 49.11,14.93 53.37,19.2 55.33,19.2 57.69,21.56 61.55,21.56 65.36,25.37 67.14,25.37 70.57,28.8 111.62,28.8 112.2,28.22 116.87,28.22 117.46,28.8 137.13,28.8 145.59,37.26 146.4,37.26 146.82,37.68 146.82,40.41 150.66,44.24 154.7,44.24 156.42,45.97 160.71,45.97 161.5,46.76 174.21,46.76 174.64,46.33 174.64,46.06 174.86,45.84 v2(175.02,45.84)
  BOTTOM w0.076: UH2.A9 174.75,43.72 174.75,44.05 174.61,44.19 174.61,44.8 174.42,44.99 174.42,45.31 174.61,45.5 174.61,45.98 174.69,46.06 174.8,46.06 v2(175.02,45.84)
USB3T_N1: length 2
  BOTTOM w0.114: RI38.1 287.62,32.08 286.64,32.08 CI16.2
USB3T_N2: length 1.8
  BOTTOM w0.114: CI9.2 287.65,51.27 288.25,51.27 288.41,51.42 288.64,51.42 288.81,51.59 RI42.1
USB3T_P1: length 2
  BOTTOM w0.114: RI37.1 287.68,31.85 286.71,31.85 CI20.2
USB3T_P2: length 1.8
  BOTTOM w0.114: RI41.1 288.81,50.75 288.64,50.92 288.41,50.92 288.29,51.04 287.74,51.04 CI10.2
USB3TN1: length 131.2
  IN1 w0.094: v2(278.83,40.04) 278.71,39.91 278.71,39.84 278.71,39.57 278.49,39.36 274.35,39.36 273.85,38.85 271.64,38.85 269.8,37.02 267.92,37.02 267.68,36.77 267.68,36.14 267.25,35.71 264.47,35.71 263.74,34.98 263.1,34.98 259.98,31.86 244.92,31.86 244.75,32.04 244.62,32.17 211.87,32.17 210.6,33.43 208.99,33.43 207.06,35.36 201.87,35.36 201.4,35.83 192.7,35.83 188.25,40.27 182.83,40.27 179.92,43.18 179.28,43.18 178.7,43.77 174.98,43.77 174.34,44.4 v2(173.81,44.4)
  BOTTOM w0.076: UH2.C11 174.21,42.81 173.98,43.04 173.98,43.37 174.03,43.41 174.03,43.41 174.16,43.54 174.16,43.92 174.09,43.99 174.09,44.31 174,44.4 v2(173.81,44.4)
  BOTTOM w0.114: CI16.1 284.85,31.79 283.99,31.79 283.63,31.42 280.6,31.42 279.87,32.16 279.87,33.44 278.91,34.39 278.91,38.98 278.42,39.47 278.42,39.67 278.79,40.04 v2(278.83,40.04)
USB3TN1_D-: length 12.8
  BOTTOM w0.114: JUSB1.8 297.91,27.95 297.79,27.83 297.43,27.83 296.72,28.54 295.7,28.54 294.49,29.75 294.49,29.9 294.51,29.92 294.51,30.46 294.49,30.48 294.49,30.94 v1(293.67,31.76) 292.95,32.48 292.41,32.48 292.25,32.64 DI9.4 DI9.7 290.64,32.64 290.52,32.51 290.28,32.51 289.94,32.17 289.29,32.17 RI38.2
USB3TN2: length 138.9
  IN1 w0.094: v2(284.62,52.19) 284.62,51.96 284.74,51.84 284.74,51.84 284.77,51.81 285.12,51.81 285.28,51.97 285.28,52.89 284.85,53.32 282.65,53.32 271.34,42.02 268.79,42.02 266.33,39.56 264.07,39.56 259.02,34.52 245.72,34.52 244.59,35.65 238.52,35.65 238.21,35.34 229.98,35.34 229.42,34.78 214,34.78 213.87,34.65 212.31,34.65 210.93,36.03 209.48,36.03 208.35,37.16 207.24,37.16 206.56,37.85 202.63,37.85 202.29,38.19 194.32,38.19 192.46,40.05 192.46,44.35 189.21,47.59 181.52,47.59 180.49,46.56 172.85,46.56 172.6,46.31 172.6,45.66 172.7,45.56 172.83,45.56 172.98,45.71 v2(172.98,45.84)
  BOTTOM w0.076: v2(172.98,45.84) 172.76,45.61 172.76,44.95 173.82,43.88 173.82,43.74 173.82,43.73 173.82,43.47 173.59,43.25 UH2.B12
  BOTTOM w0.114: CI9.1 286.1,51.21 285.82,51.21 285.1,51.93 284.87,51.93 v2(284.62,52.19)
USB3TN2_D-: length 11
  BOTTOM w0.114: RI42.2 289.72,51.59 289.89,51.42 290.26,51.42 290.39,51.29 290.57,51.29 290.58,51.3 291.29,51.3 291.55,51.56 291.79,51.56 291.91,51.69 DI7.7 DI7.4 293.37,51.69 293.5,51.56 293.91,51.56 294.24,51.22 v1(294.24,51.22) 294.62,50.84 294.62,50.27 295.58,49.32 296.59,49.32 297.38,48.53 297.8,48.53 297.91,48.65 JUSB2.8
USB3TN3: length 198.3
  TOP w0.114: JIO1.16 8.71,30.25 7.81,29.36 7.81,29.08 v2(7.68,28.95)
  IN4 w0.094: v2(7.68,28.95) 7.91,28.72 7.91,28.44 8.16,28.18 8.95,28.18 9.64,27.5 9.64,24.45 18.9,15.19 21.25,15.19 21.8,15.19 25.37,11.62 25.62,11.62 25.64,11.6 47.81,11.6 49.54,13.33 49.54,14.28 53.69,18.43 55.65,18.43 58,20.78 63.9,20.78 71.16,28.03 111.2,28.03 111.93,27.3 117.32,27.3 118.01,27.98 139.26,27.98 142.9,31.63 142.9,32.64 147.63,37.38 147.63,40.02 150.99,43.37 155,43.37 156.78,45.15 161.1,45.15 161.93,45.99 170.62,45.99 171,45.61 171.47,45.61 171.66,45.42 171.66,45.33 171.41,45.08 v2(171.33,45.08)
  BOTTOM w0.076: UH2.C13 173.15,42.86 173.19,43.03 173.19,43.47 172.76,43.91 172.14,43.91 171.74,44.31 171.74,45.15 171.64,45.25 171.51,45.25 v2(171.33,45.08)
USB3TP1: length 131.3
  IN1 w0.094: v2(278.2,40.06) 278.22,40.06 278.52,39.77 278.52,39.65 278.41,39.54 274.27,39.54 273.77,39.04 271.56,39.04 269.72,37.2 267.84,37.2 267.49,36.85 267.49,36.21 267.17,35.9 264.39,35.9 263.66,35.17 263.03,35.17 259.9,32.04 245,32.04 244.82,32.22 244.69,32.35 211.95,32.35 210.68,33.62 209.06,33.62 207.14,35.55 201.94,35.55 201.47,36.01 192.78,36.01 188.33,40.46 182.9,40.46 180,43.37 179.36,43.37 178.78,43.95 175.05,43.95 174.42,44.59 174.21,44.59 v2(173.8,45)
  BOTTOM w0.076: v2(173.8,45) 173.93,45 174.16,44.77 174.16,44.47 174.25,44.38 174.25,44.06 174.32,43.99 174.32,43.48 174.21,43.36 UH2.B11
  BOTTOM w0.114: CI20.1 285.35,31.57 284.09,31.57 283.72,31.2 280.51,31.2 279.64,32.07 279.64,33.35 278.69,34.3 278.69,38.89 278.2,39.38 v2(278.2,40.06)
USB3TP1_D+: length 12.8
  BOTTOM w0.114: RI37.2 289.42,31.95 290.03,31.95 290.37,32.29 290.5,32.29 290.65,32.14 DI9.6 DI9.5 292.28,32.14 292.4,32.26 292.86,32.26 293.31,31.81 293.31,31.78 293.69,31.4 293.72,31.4 294.27,30.85 v1(294.27,30.19) 294.27,29.66 295.61,28.32 296.63,28.32 297.34,27.6 297.71,27.6 297.91,27.4 JUSB1.9
USB3TP2: length 138.9
  IN1 w0.094: v2(284.62,51.43) 284.82,51.63 285.2,51.63 285.46,51.89 285.46,52.97 284.93,53.51 282.57,53.51 271.26,42.2 268.71,42.2 266.26,39.75 263.99,39.75 258.95,34.71 245.79,34.71 244.66,35.84 244.51,35.84 244.51,35.84 238.59,35.84 238.44,35.84 238.13,35.53 229.9,35.53 229.34,34.97 213.92,34.97 213.79,34.84 212.39,34.84 211.01,36.22 209.56,36.22 208.43,37.35 207.32,37.35 206.63,38.03 202.7,38.03 202.36,38.37 194.4,38.37 192.64,40.13 192.64,44.42 189.29,47.78 181.45,47.78 180.41,46.74 172.78,46.74 172.42,46.38 172.42,46.03 v2(172.22,45.84)
  BOTTOM w0.076: v2(172.22,45.84) 172.22,45.93 172.36,46.07 172.48,46.07 172.59,45.95 172.59,44.88 173.66,43.81 173.66,43.68 UH2.A12
  BOTTOM w0.114: v2(284.62,51.43) 284.9,51.71 285.01,51.71 285.73,50.99 286.12,50.99 CI10.1
USB3TP2_D+: length 11
  BOTTOM w0.114: RI41.2 289.72,50.75 289.89,50.92 290.27,50.92 290.42,51.07 v1(290.92,51.07) 291.37,51.07 291.64,51.34 291.77,51.34 291.92,51.19 DI7.6 DI7.5 293.37,51.19 293.52,51.34 293.78,51.34 294.4,50.72 294.4,50.18 295.48,49.09 296.5,49.09 297.29,48.31 297.8,48.31 297.91,48.19 JUSB2.9
USB3TP3: length 198.3
  TOP w0.114: v2(8.38,28.94) 8.27,28.94 8.04,29.17 8.04,29.26 8.8,30.03 9.14,30.03 9.23,29.94 9.23,29.84 9.32,29.75 JIO1.15
  IN4 w0.094: v2(172.09,45.08) 171.85,45.32 171.85,45.49 171.55,45.79 171.08,45.79 170.7,46.17 161.86,46.17 161.02,45.34 156.7,45.34 154.92,43.56 150.91,43.56 147.45,40.1 147.45,37.46 142.71,32.72 142.71,31.7 139.18,28.17 117.94,28.17 117.25,27.48 112.01,27.48 111.27,28.22 71.08,28.22 63.83,20.97 57.92,20.97 55.57,18.62 53.62,18.62 49.35,14.35 49.35,13.4 47.74,11.78 25.72,11.78 25.7,11.8 25.45,11.8 21.88,15.38 21.18,15.38 18.97,15.38 9.82,24.53 9.82,27.58 9.03,28.37 8.24,28.37 8.09,28.52 8.09,28.75 8.29,28.94 v2(8.38,28.94)
  BOTTOM w0.076: v2(172.09,45.08) 171.9,44.88 171.9,44.38 172.21,44.07 172.82,44.07 173.35,43.54 173.35,43.01 173.26,42.64 UH2.D13
USB20_N1: length 123.5
  IN1 w0.094: v2(285.73,35.04) 285.61,35.04 285.4,34.84 285.4,34.66 285.12,34.38 284.86,34.38 284.68,34.56 282.94,34.56 282.51,34.13 280.27,34.13 279.29,35.11 274.41,35.11 270.2,30.91 270.2,30.23 269.68,29.71 267.73,29.71 266.67,28.64 266.67,28.23 265.39,26.96 262.73,26.96 262.56,26.79 247.12,26.79 246.92,26.59 241.45,26.59 240.42,27.62 236.48,27.62 234.87,26.01 227.99,26.01 227.39,26.61 224.16,26.61 223.02,25.47 221.25,25.47 219.94,26.78 212.61,26.78 212.05,26.23 205.61,26.23 205.15,25.77 197.93,25.77 197.64,25.48 189.85,25.48 189.68,25.65 188.52,25.65 186.35,27.82 186.35,28.22 185.66,28.91 182.06,28.91 181.67,28.51 179.53,28.51 177.23,30.82 176.68,30.82 v2(176.59,30.72)
  BOTTOM w0.089: v2(176.59,30.72) 176.54,30.77 176.54,30.98 176.64,31.08 UH2.AF5
  BOTTOM w0.114: LI2.1 286.44,35.81 286.37,35.88 286.37,35.96 286.24,36.08 285.72,36.08 285.35,35.71 285.35,35.33 285.63,35.04 v2(285.73,35.04)
USB20_N2: length 119.8
  TOP w0.114: US1.2 282.2,37.33 282.03,37.5 282.03,37.79 v2(282.2,37.96)
  IN1 w0.094: v2(282.2,37.96) 281.96,37.72 281.96,37.21 281.21,36.46 278.78,36.46 278.5,36.18 275.88,36.18 275.75,36.05 274.49,36.05 269.8,31.36 266.53,31.36 264.4,29.22 264.4,27.98 263.97,27.55 249.37,27.55 249.26,27.65 241.81,27.65 241.16,28.3 235.92,28.3 234.99,27.37 224.01,27.37 223.93,27.37 223.48,26.91 222.8,26.91 222.35,27.37 212.17,27.37 211.67,26.86 205.43,26.86 203.75,28.54 198.68,28.54 196.33,26.19 190.05,26.19 189.51,26.73 188.67,26.73 185.89,29.5 181.94,29.5 181.61,29.84 179.16,29.84 178.26,30.73 178.26,32.21 177.95,32.51 177.95,32.88 177.68,33.15 177.1,33.15 176.95,33.01 176.95,32.93 v2(177.17,32.71)
  BOTTOM w0.089: v2(177.17,32.71) 177.1,32.71 176.94,32.55 UH2.AD5
USB20_N3: length 200.7
  TOP w0.114: v2(2.95,17.29) 3.15,17.49 3.15,23.78 7.47,28.1 9.33,28.1 9.47,28.25 JIO1.12
  IN4 w0.094: v2(2.95,17.29) 3.18,17.52 3.18,17.76 3.43,18 14.22,18 18.25,13.97 20.89,13.97 24.88,9.98 48.14,9.98 54.77,16.61 57.56,16.61 60.48,19.53 79.83,19.53 80.2,19.9 137.33,19.9 139.82,22.4 141.7,22.4 148.85,29.55 156.79,29.55 158.51,31.27 171.58,31.27 171.71,31.13 174.66,31.13 v2(175.04,31.51)
  BOTTOM w0.102: v2(175.04,31.51) 175.04,31.4 UH2.AG8
USB20_N4: length 90.2
  TOP w0.114: v2(185.3,17.14) 185.1,17.34 185.1,18.11 185.27,18.28 187,18.28 187.38,18.66 187.38,19.42 187,19.8 184.03,19.8 183.05,18.82 183.05,16.66 183.56,16.15 185.34,16.15 185.46,16.03 185.46,15.23 185.21,14.98 183.16,14.98 182.83,14.64 182.83,14.14 183.14,13.83 183.95,13.83 184.06,13.71 184.06,13.13 186.03,11.17 187.08,11.17 187.32,11.41 187.32,13.5 187.44,13.61 187.89,13.61 188.01,13.5 188.01,11.41 188.25,11.17 188.9,11.17 189.14,11.41 189.14,13.5 189.26,13.61 189.71,13.61 189.83,13.5 189.83,11.41 190.07,11.17 190.71,11.17 190.96,11.41 190.96,13.03 191.07,13.15 191.53,13.15 191.65,13.03 191.65,11.41 191.89,11.17 192.53,11.17 192.78,11.41 192.78,13.02 192.89,13.13 193.4,13.13 193.51,13.02 193.51,11.42 193.78,11.15 194.39,11.15 194.63,11.39 194.63,12.79 194.75,12.91 195.23,12.91 195.35,12.79 195.35,10.7 195.23,10.58 184.95,10.58 182.1,13.43 182.1,19.08 182.98,19.96 182.98,21.31 182.68,21.61 182.68,27.54 181.68,28.53 181.68,30.84 181.35,31.18 179.99,31.18 179.75,31.43 179.75,31.66 v2(179.89,31.8)
  BOTTOM w0.076: UH2.AE1 178.81,31.91 179.06,32.15 179.52,32.15 179.87,31.8 v2(179.89,31.8)
  BOTTOM w0.114: LN1.1 185.24,17.78 185.07,17.62 185.07,17.36 v2(185.3,17.14)
USB20_N4_R: length 2.5
  BOTTOM w0.114: JNGFF1.5 185.31,21.08 185.16,20.93 185.16,20.54 185.07,20.45 185.07,20.01 185.24,19.84 LN1.2
USB20_N7: length 204.2
  TOP w0.114: v2(4.44,19.42) 4.64,19.62 4.64,24.28 6.99,26.62 9.33,26.62 9.46,26.75 JIO1.9
  IN4 w0.094: v2(179.16,33.65) 179.33,33.81 179.33,34.08 179.22,34.18 178.8,34.18 177.99,33.37 173.77,33.37 171.05,36.08 163.61,36.08 160.94,33.41 155.5,33.41 153.48,31.39 150.12,31.39 141.52,22.8 139.57,22.8 137.12,20.34 80.02,20.34 79.66,19.98 60.21,19.98 58,17.77 54.67,17.77 54.11,17.21 54.11,16.73 48.32,10.94 25.37,10.94 25.35,10.96 25.1,10.96 21.53,14.53 18.39,14.53 14.53,18.4 5.1,18.4 4.76,18.73 4.76,19.23 4.57,19.42 v2(4.44,19.42)
  BOTTOM w0.076: v2(179.16,33.65) 179.16,33.53 179.09,33.46 178.86,33.46 178.68,33.64 178.12,33.64 UH2.AB3
USB20_N9: length 130.1
  IN4 w0.094: v2(179.89,34.91) 179.68,35.12 179.68,35.2 179.68,35.2 179.68,35.28 179.46,35.5 178.62,35.5 177.89,34.76 174.33,34.76 172.95,36.14 172.95,36.7 171.52,38.13 167.94,38.13 166.66,36.85 162.1,36.85 161.14,35.89 150.66,35.89 146.03,31.26 143.2,31.26 139.45,27.51 118.21,27.51 117.49,26.79 111.74,26.79 111.06,27.47 74.86,27.47 74.08,26.69 74.08,23.42 73.1,22.44 70.38,22.44 v2(70.11,22.71)
  BOTTOM w0.076: v2(179.89,34.91) 179.63,34.65 179.63,34.53 179.41,34.31 178.74,34.31 178.66,34.23 178.66,34.11 178.74,34.03 UH2.AA1
  BOTTOM w0.114: v2(70.11,22.71) 69.69,22.29 69.57,22.29 69.26,21.98 69.26,20.94 68.49,20.17 68.49,17.41 68.34,17.26 68.24,17.26 68.11,17.39 LI1.1
USB20_N9_R: length 16.2
  BOTTOM w0.114: LI1.2 66.02,17.39 65.89,17.26 65.81,17.26 65.07,17.99 64.91,17.99 64.68,18.23 64.68,18.35 DI3.2 64.17,18.35 63.83,18.01 63.66,18.01 63.19,18.49 63.19,22.82 63.97,23.6 63.97,27.92 63.5,28.39 63.31,28.39 63.18,28.51 JEDP1.10
USB20_N12: length 63.7
  IN1 w0.094: v2(193.3,40.63) 193.52,40.84 193.78,40.84 194.37,40.25 194.37,39.69 195.21,38.85 202.56,38.85 202.9,38.51 206.13,38.51 206.13,38.51 206.86,38.51 207.55,37.82 209.21,37.82 209.58,37.46 211.71,37.46 212.41,36.76 212.41,36.44 213.41,35.44 228.86,35.44 229.15,35.74 229.15,35.89 v2(229.4,36.13)
  BOTTOM w0.076: UH2.AD3 178.1,32.15 178.6,32.15 178.78,32.33 179.07,32.33
  BOTTOM w0.114: 179.07,32.33 179.77,32.33 181.14,33.7 181.14,35.49 180.96,35.66 180.96,36.36 181.38,36.79 185.86,36.79 186.92,37.85 186.92,38.31 187.34,38.73 188.13,38.73 188.28,38.88 190.72,38.88 192.71,40.86 193.07,40.86 v2(193.3,40.63) ; LV22.1 230.22,37.5 230.13,37.58 230.13,37.68 230.04,37.77 229.91,37.77 228.99,36.86 228.99,36.46 229.32,36.13 v2(229.4,36.13)
USB20_N12_R: length 17.4
  BOTTOM w0.114: LV22.2 232.16,37.5 232.3,37.64 234.56,37.64 235.4,36.8 235.93,36.8 236.04,36.68 DV12.3 236.89,36.8 237.56,36.8 238.01,37.24 238.01,39.04 237.51,39.54 237.33,39.54 237.32,39.56 236.64,39.56 236.62,39.54 v1(235.51,39.54) 235.04,39.54 234.73,39.85 234.73,40.91 235.82,42 235.82,42.54 236.02,42.73 JCAM1.6
USB20_P1: length 123.5
  IN1 w0.094: v2(176.54,31.54) 176.54,31.18 176.59,31.13 176.76,31.13 176.88,31 177.3,31 179.61,28.7 181.59,28.7 181.98,29.09 185.74,29.09 186.53,28.3 186.53,27.9 188.6,25.84 189.75,25.84 189.92,25.66 197.56,25.66 197.86,25.96 205.08,25.96 205.53,26.41 211.98,26.41 212.53,26.96 220.02,26.96 221.33,25.65 222.95,25.65 224.09,26.79 227.47,26.79 228.07,26.19 234.8,26.19 236.41,27.8 240.5,27.8 241.53,26.77 246.84,26.77 247.04,26.97 262.48,26.97 262.65,27.14 265.31,27.14 266.48,28.31 266.48,28.72 267.66,29.89 269.6,29.89 270.02,30.31 270.02,30.98 274.33,35.3 279.36,35.3 280.35,34.31 282.43,34.31 282.86,34.74 284.76,34.74 284.93,34.57 285.05,34.57 285.22,34.74 285.22,34.87 v2(285.05,35.04)
  BOTTOM w0.089: v2(176.54,31.54) 176.54,31.39 UH2.AG7
  BOTTOM w0.114: v2(285.05,35.04) 285.12,35.12 285.12,35.8 285.63,36.31 LI2.4
USB20_P2: length 119.8
  TOP w0.114: US1.3 281.7,37.35 281.8,37.46 281.8,37.73 v2(281.57,37.96)
  IN1 w0.094: v2(281.57,37.96) 281.77,37.76 281.77,37.29 281.13,36.64 278.7,36.64 278.42,36.36 275.8,36.36 275.68,36.24 274.42,36.24 269.72,31.54 266.46,31.54 264.21,29.3 264.21,28.06 263.89,27.73 249.44,27.73 249.34,27.84 241.89,27.84 241.23,28.49 235.85,28.49 234.91,27.55 224.09,27.55 224.09,27.55 223.86,27.55 223.4,27.1 222.88,27.1 222.43,27.55 212.69,27.55 212.17,27.55 212.1,27.55 212.04,27.5 211.59,27.05 205.5,27.05 203.83,28.72 198.6,28.72 196.26,26.38 190.13,26.38 189.59,26.91 188.75,26.91 185.97,29.69 182.02,29.69 181.69,30.02 179.23,30.02 178.44,30.81 178.44,32.29 178.14,32.59 178.14,32.96 177.76,33.34 177.02,33.34 176.77,33.09 176.77,32.92 v2(176.55,32.71)
  BOTTOM w0.089: v2(176.55,32.71) 176.55,32.62 176.17,32.24 UH2.AD7
USB20_P3: length 200.6
  TOP w0.114: JIO1.11 9.46,27.75 9.33,27.88 7.57,27.88 3.38,23.69 3.38,17.33 3.49,17.21 3.69,17.21 v2(3.76,17.29)
  IN4 w0.094: v2(3.76,17.29) 3.46,17.29 3.37,17.38 3.37,17.68 3.5,17.81 14.14,17.81 18.17,13.78 20.81,13.78 24.8,9.79 48.21,9.79 54.84,16.42 57.63,16.42 60.55,19.34 79.91,19.34 80.28,19.72 137.4,19.72 139.9,22.21 141.77,22.21 148.93,29.37 156.87,29.37 158.58,31.08 171.5,31.08 171.63,30.95 174.77,30.95 v2(175.09,30.62)
  BOTTOM w0.102: UH2.AG10 174.79,31.03 175.09,30.72 v2(175.09,30.62)
USB20_P4: length 90.2
  TOP w0.114: v2(184.54,17.14) 184.88,17.47 184.88,18.21 185.17,18.5 186.91,18.5 187.16,18.75 187.16,19.33 186.91,19.58 184.13,19.58 183.27,18.72 183.27,16.75 183.65,16.37 185.43,16.37 185.68,16.12 185.68,15.14 185.3,14.75 183.26,14.75 183.06,14.55 183.06,14.23 183.24,14.05 184.04,14.05 184.29,13.8 184.29,13.22 186.12,11.39 186.98,11.39 187.1,11.5 187.1,13.59 187.34,13.83 187.99,13.83 188.23,13.59 188.23,11.5 188.35,11.39 188.8,11.39 188.92,11.5 188.92,13.59 189.16,13.83 189.81,13.83 190.05,13.59 190.05,11.5 190.16,11.39 190.62,11.39 190.74,11.5 190.74,13.13 190.98,13.37 191.62,13.37 191.87,13.13 191.87,11.5 191.98,11.39 192.44,11.39 192.55,11.5 192.55,13.11 192.8,13.36 193.49,13.36 193.74,13.11 193.74,11.51 193.88,11.37 194.29,11.37 194.41,11.49 194.41,12.88 194.65,13.13 195.33,13.13 195.57,12.88 195.57,10.6 195.33,10.36 184.85,10.36 181.87,13.34 181.87,19.18 182.75,20.06 182.75,21.22 182.46,21.51 182.46,27.44 181.46,28.44 181.46,30.75 181.25,30.96 179.9,30.96 179.52,31.34 179.52,31.56 v2(179.29,31.79)
  BOTTOM w0.076: UH2.AE2 178.31,31.54 178.43,31.42 178.88,31.42 179.26,31.79 v2(179.29,31.79)
  BOTTOM w0.114: v2(184.54,17.14) 184.54,17.14 184.85,17.45 184.85,17.67 184.74,17.78 LN1.4
USB20_P4_R: length 2.5
  BOTTOM w0.114: LN1.3 184.74,19.87 184.85,19.98 184.85,20.54 184.94,20.63 184.94,20.95 184.81,21.08 JNGFF1.3
USB20_P7: length 204.2
  TOP w0.114: JIO1.8 9.46,26.25 9.31,26.4 7.08,26.4 4.86,24.18 4.86,19.49 5.02,19.33 5.19,19.33 v2(5.26,19.4)
  IN4 w0.094: v2(5.26,19.4) 4.95,19.1 4.95,18.81 5.18,18.58 14.6,18.58 18.47,14.72 21.45,14.72 21.6,14.72 25.18,11.14 25.43,11.14 25.45,11.12 48.24,11.12 53.93,16.81 53.93,17.29 54.59,17.96 57.92,17.96 60.13,20.17 79.58,20.17 79.95,20.53 137.04,20.53 139.49,22.98 141.45,22.98 150.04,31.57 153.4,31.57 155.42,33.59 160.86,33.59 163.53,36.27 171.13,36.27 173.85,33.55 177.91,33.55 178.72,34.36 179.3,34.36 179.51,34.15 179.51,33.87 v2(179.76,33.63)
  BOTTOM w0.076: v2(179.76,33.63) 179.42,33.29 178.79,33.29 178.61,33.48 178.46,33.48 UH2.AB2
USB20_P9: length 130.1
  IN4 w0.094: v2(179.27,34.9) 179.5,35.13 179.5,35.2 179.38,35.31 178.7,35.31 177.96,34.58 174.25,34.58 172.76,36.07 172.76,36.63 171.44,37.95 168.01,37.95 166.74,36.67 162.18,36.67 161.22,35.7 150.74,35.7 146.11,31.07 143.28,31.07 139.53,27.32 118.29,27.32 117.56,26.6 111.67,26.6 110.98,27.29 74.94,27.29 74.26,26.61 74.26,23.34 73.18,22.26 70.23,22.26 70.11,22.14 v2(70.11,21.75)
  BOTTOM w0.076: v2(179.27,34.9) 179.46,34.7 179.46,34.6 179.34,34.48 178.68,34.48 178.5,34.3 178.5,34.1 178.42,34.03 UH2.AA2
  BOTTOM w0.114: LI1.4 68.04,16.89 68.18,17.03 68.44,17.03 68.72,17.31 68.72,20.08 69.48,20.84 69.48,21.88 69.67,22.07 69.79,22.07 v2(70.11,21.75)
USB20_P9_R: length 16.2
  BOTTOM w0.114: JEDP1.9 63.11,28.01 63.26,28.16 63.4,28.16 63.74,27.82 63.74,23.69 62.96,22.91 62.96,18.39 63.57,17.79 63.83,17.79 64.17,17.45 DI3.3 64.68,17.44 64.68,17.59 64.83,17.74 65,17.74 65.71,17.03 65.9,17.03 66.05,16.89 LI1.3
USB20_P12: length 63.7
  IN1 w0.094: v2(228.74,36.13) 228.81,36.13 228.97,35.98 228.97,35.81 228.78,35.63 213.48,35.63 212.6,36.52 212.6,36.83 211.78,37.64 209.66,37.64 209.29,38.01 207.63,38.01 206.94,38.69 206.06,38.69 202.98,38.69 202.64,39.03 195.29,39.03 194.56,39.77 194.56,40.33 193.85,41.03 193.39,41.03 193.23,41.19 193.23,41.32 v2(193.3,41.39)
  BOTTOM w0.076: UH2.AD2 178.29,32.41 178.24,32.46 178.24,32.58 178.34,32.67 178.55,32.67 178.69,32.53 178.98,32.53 179,32.55 179.08,32.55
  BOTTOM w0.114: 179.08,32.55 179.68,32.55 180.91,33.79 180.91,35.39 180.74,35.57 180.74,36.46 181.29,37.01 185.77,37.01 186.7,37.94 186.7,38.4 187.25,38.95 188.04,38.95 188.19,39.1 190.63,39.1 192.62,41.09 193,41.09 v2(193.3,41.39) ; LV22.4 229.81,38 228.77,36.95 228.77,36.16 v2(228.74,36.13)
USB20_P12_R: length 17.4
  BOTTOM w0.114: LV22.3 232.18,38 232.32,37.86 234.66,37.86 235.49,37.02 235.93,37.02 236.04,37.14 DV12.2 236.89,37.02 237.47,37.02 237.78,37.33 237.78,38.95 237.41,39.32 v1(236.98,39.32) 235.81,39.32 235.8,39.31 235.19,39.31 235.18,39.32 234.94,39.32 234.51,39.76 234.51,41 235.6,42.1 235.6,42.47 235.49,42.59 235.13,42.59 235.02,42.7 JCAM1.7
USB_EN#: length 370.2
  TOP w0.114: v3(11.06,33.75) JIO1.23 5.19,33.75 v2(4.71,33.26) ; v2(224.09,18.65) 223.12,19.61 223.12,25.2 224.12,26.19 224.12,28.3 223.7,28.72 222.93,28.72 222.76,28.56 222.76,28.32 222.42,27.97 222.42,27.39 222.64,27.17 222.64,25.93 222.05,25.34 UE1.13 219.29,25.34 218.76,25.87 218.76,26.88 218,27.64 217.2,27.64 RE29.1
  IN4 w0.094: v2(4.71,33.26) 1.66,30.22 1.66,16.97 2.3,16.33 12.13,16.33 17.29,11.17 21.15,11.17 23.89,8.43 48.81,8.43 55.03,14.65 58.35,14.65 60.34,16.64 110,16.64 110.35,16.29 115.23,16.29 115.48,16.54 118.49,16.54 118.6,16.43 123.4,16.43 124.12,17.14 145.78,17.14 145.97,17.33 150.25,17.33 150.65,16.92 161.18,16.92 162.34,15.76 164.49,15.76 169.4,10.86 175.32,10.86 175.56,10.62 175.57,10.62 175.86,10.33 179.85,10.33 185.12,15.6 188.06,15.6 188.43,15.97 194.75,15.97 198.38,19.61 205.21,19.61 206.37,20.76 210.99,20.76 211.78,21.56 213.17,21.56 214.3,20.43 217.13,20.43 217.8,19.76 220.35,19.76 221.67,18.44 223.89,18.44 224.09,18.64 v2(224.09,18.65) 224.18,18.56 228.87,18.56 229.4,19.09 233.87,19.09 235.1,20.33 235.22,20.44 235.33,20.56 238,20.56 238.95,21.5 238.95,21.68 239.63,22.37 243.42,22.37 244.01,22.96 245.66,22.96 246.36,23.66 250.06,23.66 250.72,24.32 254.04,24.32 256.24,26.52 265.71,26.52 267.82,24.41 271.73,24.41 272.96,25.64 273.79,25.64 275.83,27.68 275.83,28.69 275.47,29.05 275.47,32.81 275.96,33.29 277.43,33.29 279.01,34.86 280.15,34.86 281.9,36.62 285.46,36.62 286.29,37.46 291.22,37.46 292.34,38.57 v2(293.66,38.57)
  BOTTOM w0.114: v2(293.66,38.57) 293.69,38.61 US2.4
USB_OC0#: length 178.5
  TOP w0.114: v2(155.61,31.49) RH131.1
  IN3 w0.127: v2(155.61,31.49) 154.47,30.34 154.47,25.01 155.67,23.8 156.88,23.8 158.4,22.28 161.15,22.28 161.96,21.47 161.96,20.85 162.41,20.4 163.36,20.4 165.78,17.97 169.05,17.97 169.34,17.68 170.35,17.68 171.04,16.99 171.04,14.36 171.54,13.86 179.07,13.86 180.44,15.23 183.51,18.29 187.2,18.29 188.36,19.45 194.85,19.45 195.26,19.85 195.26,20.84 196.73,22.32 198.12,22.32 198.38,22.57 215.64,22.57 220.06,26.99 220.06,27.61 221.32,28.87 229.65,28.87 229.69,28.83 237.04,28.83 237.67,29.46 243.59,29.46 245.77,31.64 255.53,31.64 265.59,41.7 273.34,41.7 v2(273.59,41.44)
  IN4 w0.094: v2(273.59,41.44) 275.8,39.23 280.17,39.23 281.59,40.66 290.13,40.66 291.2,39.59 293.1,39.59 294.8,41.29 v2(296.86,41.29)
  BOTTOM w0.076: 156.6,31.49 156.68,31.49 157.01,31.81
  BOTTOM w0.089: 157.01,31.81 157.61,31.81 157.99,32.19 UH2.AD43
  BOTTOM w0.114: 156.6,31.49 v2(155.61,31.49) ; US2.3 293.69,41.45 293.85,41.29 v4(295.59,41.29) v2(296.86,41.29)
USB_OC1#: length 183
  TOP w0.114: US1.13 284.62,34.67 284.66,34.63 286.74,34.63 287.79,35.68 289.93,35.68 v4(291.28,37.03) 291.28,38.97 290.68,39.57 290.68,40.48 289.61,41.55 288.71,41.55 287.4,40.24 281.32,40.24 280.57,41 280.57,41.28 v2(280.5,41.34)
  IN3 w0.127: v2(156.02,32.55) 156.03,32.54 156.03,31.27 154.7,29.94 154.7,25.38 155.28,24.79 157.41,24.79 158.17,24.03 159.72,24.03 162.19,21.56 162.19,20.95 162.51,20.63 163.45,20.63 165.84,18.24 169.11,18.24 169.34,18 170.36,18 171.27,17.08 171.27,14.45 171.64,14.09 178.98,14.09 180.41,15.52 183.41,18.52 187.11,18.52 188.26,19.68 194.53,19.68 195.03,20.17 195.03,20.94 196.64,22.55 198.03,22.55 198.28,22.8 211.91,22.8 213.66,24.55 217.3,24.55 219.81,27.06 219.81,27.68 221.23,29.1 230.82,29.1 231.42,29.7 233.91,29.7 233.91,29.69 243.31,29.69 245.51,31.89 255.32,31.89 265.5,42.08 270.47,42.08 271.97,43.58 v2(274.33,43.58)
  IN4 w0.094: v2(280.5,41.34) 279.77,40.6 277.3,40.6 v2(274.33,43.58)
  BOTTOM w0.089: 156.6,32.29 157.32,32.29 157.46,32.43 158.49,32.43 UH2.AD42
  BOTTOM w0.114: 156.6,32.29 156.28,32.29 v2(156.02,32.55) 155.83,32.74 RH132.1
USB_OC2#: length 186.8
  TOP w0.114: v2(4.84,34.03) 5.06,34.25 JIO1.24 ; v2(151.06,28.13) 151.39,28.46 v4(151.39,29.94) 151.39,33.96 151.65,34.22 152.47,34.22 152.92,34.66 154.62,34.66 154.74,34.54 RH135.1 155.52,33.42 158.69,33.42 160.06,32.05 160.06,31.89 v2(160.21,31.74)
  IN3 w0.127: v2(151.06,28.13) 150.52,27.59 145.52,27.59 145,28.11 142.12,28.11 141.46,27.45 108.99,27.45 108.29,28.15 68.15,28.15 67.76,27.75 61.27,27.75 v2(61.16,27.64)
  IN4 w0.094: v2(61.16,27.64) 60.49,26.96 60.49,26.08 57.62,23.21 57.62,22.29 55.34,20.02 53.52,20.02 48.91,15.41 48.24,15.41 45.7,12.87 27.16,12.87 22.43,17.59 19.36,17.59 14.92,22.04 14.92,23.94 v2(4.84,34.03)
  BOTTOM w0.089: v2(160.21,31.74) 160.08,31.76 UH2.AD39
USB_OC3#: length 3.4
  BOTTOM w0.114: UH2.AC44 157.47,32.71 157.31,32.55 156.61,32.55 v3(155.79,33.37) 155.53,33.63 RH134.1
USB_OC4#: length 4.2
  BOTTOM w0.076: UH2.Y43 157.88,34.7 157.46,34.7 157.39,34.64 156.8,34.64
  BOTTOM w0.114: RP8.3 154.69,35.24 155.17,34.76 v3(155.75,34.76) 155.99,34.76 156.27,34.48 156.65,34.48 156.8,34.64
USB_OC5#: length 7
  TOP w0.114: v2(159.4,35.02) 158.89,34.51 v4(158.89,33.97) 158.56,33.63 156.49,33.63 v2(155.86,34.25)
  BOTTOM w0.089: v2(159.4,35.02) 159.11,34.74 UH2.Y41
  BOTTOM w0.114: v2(155.86,34.25) 155.17,34.25 154.68,34.74 RP8.4
USB_OC6#: length 6.2
  TOP w0.114: v4(157.95,35.51) 157.77,35.69 156.28,35.69 v2(155.86,35.27)
  BOTTOM w0.076: 156.6,34.74 156.71,34.85 157.33,34.85 157.38,34.89 157.68,34.89 UH2.W44
  BOTTOM w0.114: RP8.2 154.64,35.74 155.1,35.27 v2(155.86,35.27) 156.4,34.74 156.6,34.74
USB_OC7#: length 4.4
  BOTTOM w0.089: 156.6,35.68 156.62,35.68 156.98,35.32 157.33,35.32 157.44,35.21 157.91,35.21 158.15,34.98 UH2.W43
  BOTTOM w0.114: 156.6,35.68 156.29,35.68 155.9,36.08 v3(155.71,36.08) 154.8,36.08 154.64,36.24 RP8.1
USB_POWERSHARE_VBUS_EN: length 60.5
  TOP w0.114: UE1.71 237.43,20.14 v3(237.6,20.31) 238.71,21.41 240.86,21.41 241.71,20.56 243.6,20.56 243.8,20.77 v2(243.8,21.05) ; US1.5 280.06,36.17 279.69,36.54 278.95,36.54 RI51.2 279.16,37.05 v2(279.79,37.05)
  IN3 w0.127: v2(243.8,21.05) 243.82,21.07 244.08,21.07 245.91,22.9 246.11,22.9 249.72,26.51 257.41,26.51 258.94,28.03 258.94,30.8 261.22,33.09 263.61,33.09 264.58,34.05 264.58,38.12 265.59,39.13 277.71,39.13 v2(279.79,37.05)
USB_PWR_SHR_EN_R#: length 69.8
  TOP w0.114: v2(229.42,30.34) 229.42,30.37 229.45,30.39 UE1.109 ; US1.6 280.3,35.58 278.95,35.58 RI10.2 279.28,36.11 279.51,36.11 279.54,36.08 v2(279.54,36.03)
  IN4 w0.094: v2(229.42,30.34) 229.42,28.49 230.18,27.73 232.8,27.73 232.83,27.75 234.48,27.75 236.01,29.29 240.97,29.29 241.56,29.89 245.83,29.89 250.41,25.3 253.29,25.3 253.91,25.92 253.91,26.25 254.95,27.3 266.03,27.3 266.9,26.43 270.16,26.43 270.77,27.04 273.85,27.04 274.43,27.63 274.43,35.04 276.59,37.2 278.44,37.2 279.54,36.11 v2(279.54,36.03)
USB_R_CTL: length 4.3
  TOP w0.114: US1.8 278.86,34.67 ; 278.86,34.67 RI9.2 v3(278.85,33.71) ; 278.86,34.67 279.36,35.17 US1.7
USBCHG_DET#: length 3.3
  TOP w0.114: UE1.126 222.65,30.92 v2(223.02,30.55)
  BOTTOM w0.114: v3(224.32,31.69) 223.79,31.16 RE52.1 223.4,30.93 v2(223.02,30.55)
USBP1_R_D+: length 15.9
  IN4 w0.094: v2(293.35,37.15) 293.55,36.95 293.91,36.95 295.12,35.74 295.12,31.14 295.44,30.83 296.07,30.83 296.41,31.16 JUSB1.3
  BOTTOM w0.114: v2(293.35,37.15) 292.72,37.79 DI10.2 292.26,37.05 292.15,36.93 291.78,36.93 290.77,35.93 289.43,35.93 289.19,36.17 288.81,36.17 288.67,36.31 LI2.3
USBP1_R_D-: length 15.9
  IN4 w0.094: v2(293.35,36.52) 293.61,36.77 293.83,36.77 294.93,35.66 294.93,31.07 295.36,30.64 296.08,30.64 296.41,30.31 JUSB1.2
  BOTTOM w0.114: LI2.2 288.67,35.81 288.81,35.95 289.1,35.95 289.34,35.7 290.87,35.7 291.87,36.71 292.15,36.71 292.26,36.59 DI10.3 292.69,35.85 v2(293.35,36.52)
USBP2_D+: length 34.9
  TOP w0.114: US1.10 281.7,33.49 281.85,33.34 281.85,32.95 v2(281.67,32.77)
  IN1 w0.094: v2(281.67,32.77) 281.82,32.62 281.82,32.31 282.09,32.04 284.23,32.04 289.75,37.56 289.75,40.6 290.59,41.44 290.59,42.03 291.93,43.37 291.93,51.35 287.88,55.4 287.37,55.4 v2(287.16,55.62)
  BOTTOM w0.114: LI5.4 288.05,55.36 287.92,55.23 287.49,55.23 287.16,55.57 v2(287.16,55.62)
USBP2_D-: length 34.8
  TOP w0.114: v2(282.31,32.77) 282.07,33 282.07,33.36 282.2,33.49 US1.11
  IN1 w0.094: v2(282.31,32.77) 282.23,32.77 282.07,32.61 282.07,32.6 282,32.53 282,32.39 282.17,32.22 284.15,32.22 289.56,37.63 289.56,40.68 290.4,41.52 290.4,42.1 291.75,43.45 291.75,51.27 287.81,55.21 287.01,55.21 286.88,55.08 286.88,54.88 287.03,54.73 v2(287.16,54.73)
  BOTTOM w0.114: v2(287.16,54.73) 287.16,54.83 287.34,55.01 287.92,55.01 288.07,54.86 LI5.1
USBP2_R_D+: length 15.1
  IN4 w0.094: JUSB2.3 296.41,51.7 296.26,51.55 295.67,51.55 295.33,51.89 295.33,56.71 295.08,56.96 294.88,56.96 v2(294.59,57.24)
  BOTTOM w0.114: LI5.3 290.13,55.36 290.28,55.21 290.47,55.21 291.68,56.42 291.68,56.78 291.91,57.01 292.24,57.01 292.36,57.13 292.36,57.44 DI8.2 292.77,57.12 292.88,57.01 294.36,57.01 v2(294.59,57.24)
USBP2_R_D-: length 15.1
  IN4 w0.094: JUSB2.2 296.41,51.21 296.26,51.37 295.59,51.37 295.15,51.81 295.15,56.63 295.01,56.77 294.73,56.77 v2(294.59,56.63)
  BOTTOM w0.114: LI5.2 290.19,54.86 290.32,54.99 290.56,54.99 291.9,56.33 291.9,56.68 292,56.78 292.24,56.78 292.36,56.66 292.36,56.33 DI8.3 292.77,56.66 292.9,56.78 294.44,56.78 v2(294.59,56.63)
VCIN0_PH: length 217.7
  TOP w0.254: v2(108.29,83.3) 108.39,83.4 RT1.2 CT80.1 HT1.1
  IN3 w0.254: v2(132.63,82.79) 135.11,80.31 135.11,75.78 134.25,74.92 134.25,70.29 138.01,66.53 138.01,54.49 137.44,53.92 137.44,50.45 137.86,50.03 137.86,45.04 139.39,43.52 139.39,38.16 145.9,31.64 151.39,31.64 154,34.24 154,35.74 156.8,38.55 157.46,38.55 158.93,37.07 161.1,37.07 162.54,35.63 162.54,34.99 164.37,33.16 164.37,32.35 164.88,31.84 169.39,31.84 169.72,32.17 169.72,35.22 170.5,35.99 171.45,35.99 172.26,35.18 177.31,35.18 178.38,34.11 178.38,30.87 180.56,28.69 181.7,28.69 185.15,32.15 186.22,32.15 189.16,35.09 189.19,35.09 206.03,35.09 208.6,32.53 216.01,32.53 216.66,33.18 219.91,33.18 220.84,34.1 225.6,34.1 226.54,35.05 226.54,35.85 227.81,37.12 231.68,37.12 233.32,35.49 234.57,35.49 v2(236.7,33.36)
  IN4 w0.127: 126.1,84.35 126.26,84.35 126.86,83.76 126.37,83.76 126.17,83.56 124.22,83.56 124.01,83.76 124.01,84.06 124.3,84.35 125.77,84.35 126.1,84.35
  IN4 w0.254: 126.86,83.76 131.67,83.76 v2(132.63,82.79) ; 124.01,84.06 123.68,84.06 122.93,84.82 122.01,84.82 121.54,85.28 119.52,85.28 118.93,84.7 109.33,84.7 108.29,83.66 v2(108.29,83.3)
  BOTTOM w0.254: RE73.2 233.64,26.74 234.71,27.8 234.71,29 233.91,29.8 231.88,29.8 231.51,30.17 231.51,30.57 233.61,32.67 v4(235.57,32.67) 236.02,32.67 v2(236.7,33.36)
VCORE_B+: length 106.9
  IN1 w0.508: 105.04,133.47 89.42,133.47 88.53,132.58 88.53,127.88 85.1,124.45 64.58,124.45 63.48,123.36 63.48,93.72 63.69,93.51 63.69,88.48 63.28,88.08 63.28,86.91 63.79,86.4 64.42,86.4 64.98,85.84 68.62,85.84 70.1,84.36 v2(77.46,84.36)
  BOTTOM w0.508: v2(77.46,84.36) 77.46,82.65 76.72,81.91 75.14,81.91 74.64,81.4 74.64,81.21 74.11,80.69 PR1102.1
  vias: v2(105.96,128.08) v2(105.96,127.4) v2(106.77,128.08) v2(106.77,127.4) v2(107.58,129.66) v2(108.21,130.29) v2(108.21,129.66) v2(108.85,130.29) v2(108.85,129.66) v2(109.48,130.29) v2(109.48,129.66) v2(115.86,128.2) v2(115.86,127.53) v2(116.68,128.2) v2(116.68,127.53) v2(117.13,129.86) v2(117.13,129.28) v2(117.76,129.86) v2(117.76,129.28) v2(118.07,128.16) v2(118.07,127.57) v2(118.4,129.86) v2(118.4,129.28) v2(118.37,128.69) v2(119.03,129.86) v2(119.03,129.28) v2(119.01,128.69) v2(119.67,129.86) v2(119.67,129.28) v2(119.64,128.69) v2(120.3,129.86) v2(120.3,129.28) v2(120.28,128.69) v2(126.02,128.2) v2(126.02,127.53) v2(126.84,128.2) v2(126.84,127.53) v2(127.64,130.42) v2(127.64,129.78) v2(127.64,129.15) v2(128.28,130.17) v2(128.28,129.53) v2(128.91,130.17) v2(128.91,129.53) v4(125.8,129.21)
VCREF0: length 7.4
  TOP w0.114: UE1.25 221.02,20.54 221.49,20.07 v2(221.49,19.19)
  BOTTOM w0.114: CE91.1 RE35.1 RE34.2 223.58,20.7 222.62,19.74 v3(222.23,19.74) 222.04,19.74 221.49,19.19 v2(221.49,19.19)
VGA_CLK_REQ#: length 88.7
  TOP w0.114: v2(157.39,19.17) 157.39,19.05 157.79,18.65 158.27,18.65 159.13,19.5 v3(159.13,20.56) 159.45,20.88 159.9,20.88 160.32,21.29 160.32,21.55 161.27,22.51 161.27,22.8 162.37,23.89 v2(162.37,23.94) ; QV3.1 147.89,77.68 149.14,77.68 150.84,75.98 150.84,75.19 150.35,74.7 150.01,74.7 148.56,73.26 147.06,73.26 146.77,73.55 144.11,73.55 v2(144,73.45)
  IN1 w0.094: v2(144,73.45) 143.78,73.22 143.78,69.21 139.4,64.83 139.4,45.65 145.5,39.55 145.5,38.46 149.11,34.85 149.11,28.43 150.38,27.16 151.91,27.16 153.15,25.92 158.23,25.92 160.21,23.94 v2(162.37,23.94)
  BOTTOM w0.076: 156.88,18.66 v2(157.39,19.17)
  BOTTOM w0.089: v2(162.37,23.94) 162.76,23.94 UH2.BA33
  BOTTOM w0.114: RP23.5 156.74,18.52 156.88,18.66
VGA_EDID_CLK: length 7.1
  BOTTOM w0.114: UV1.R2 170.49,76.64 170.06,76.2 170.06,75.68 169.73,75.35 169.02,75.35 168.63,74.97 167.31,74.97 v3(166.19,73.85) 165.49,73.85 RV514.1
VGA_EDID_DATA: length 6
  BOTTOM w0.114: RV515.1 168.68,74.35 169.87,74.35 170.49,74.97 170.49,75.58 170.84,75.93 170.84,77.35 170.49,77.7 UV1.R3
VGA_SMB_CK2: length 26
  BOTTOM w0.114: UV1.T4 169.49,78.51 169.06,78.09 168.62,78.09 168.4,77.86 168.4,75.71 168.15,75.45 165.29,75.45 163.48,73.65 163.48,73.63 162.99,73.14 161.76,73.14 RV191.1 160.91,73.99 159.68,73.99 159.25,73.55 159.25,73.24 v3(158.85,72.84) 158.85,72.84 156.18,72.84 155.4,72.06 151.65,72.06 150.93,72.78 150.93,72.96 150.62,73.27 149.7,73.27 149.51,73.46 QV1.1
VGA_SMB_DA2: length 27.3
  BOTTOM w0.114: QV1.4 147.27,71.76 147.51,71.51 149.48,71.51 149.82,71.85 155.74,71.85 v3(155.91,72.02) 156.39,72.49 159.03,72.49 159.46,72.93 161.41,72.93 161.42,72.92 163.08,72.92 163.76,73.6 RV192.1 164.65,73.9 164.65,74.39 165.48,75.21 168.54,75.21 168.89,75.57 169.62,75.57 169.83,75.78 169.83,76.49 170.01,76.67 170.01,77.33 169.64,77.71 UV1.T3
VR_CAP: length 7.1
  TOP w0.114: CE103.1 214.68,22.8 T4931.1 215.11,22.81 215.64,23.34 UE1.18
VR_ON: length 239.8
  TOP w0.114: v2(145.65,81.04) 144.49,81.04 143.7,80.25 141.46,80.25 139.51,78.3 137.76,78.3 137.3,77.84 137.3,76.01 136.71,75.42 136.36,75.42 135.93,75.86 135.93,76.22 135.82,76.32 UC16.2 ; UZ21.4 185.54,22.13 185.21,22.46 RZ71.1 185.21,23.27 185.86,23.91 185.86,25.47 186.56,26.16 186.56,27.22 188.02,28.68 v4(188.02,29.16) 188.02,32.54 192.82,37.33 v2(192.82,37.46)
  IN3 w0.127: v2(145.65,81.04) 145.42,81.27 145.42,82.34 144.87,82.9 143.89,82.9 142.35,84.44 142.35,97.98 140.85,99.48 v2(140.85,100.19)
  IN4 w0.094: v2(192.82,37.46) 192.65,37.63 192.65,46.59 192.65,47.41 192.65,47.43 173.81,66.27 173.81,70.56 173.81,70.74 169.98,74.58 169.14,74.58 167.65,76.08 166.29,76.08 164.65,77.71 160.73,77.71 160.49,77.95 160.49,78.2 160.16,78.53 158.84,78.53 158.42,78.96 158.42,79.83 154.57,83.68 154.57,87.4 141.78,100.19 v2(140.85,100.19) 139.38,100.19 131.57,108 85.83,108 78.03,100.19 78.03,99.04 78,99.02 78,95.86 78.57,95.29 78.57,92.75 76.84,91.02 76.84,88.24 72.84,84.24 69.58,84.24 v2(67.75,82.41)
  BOTTOM w0.114: v2(67.75,82.41) 67.32,82.84 PR1120.1
VR_SVID_ALERT#: length 20.2
  TOP w0.114: v2(70.29,82.34) v4(71,83.04) 72.39,84.43 74.32,84.43 77.51,87.62 81.3,87.62 84.81,91.13 RH152.2 85.73,91.13 RH153.1
  BOTTOM w0.114: PR1107.1 70.29,82.79 v2(70.29,82.34)
VR_SVID_ALERT#_C: length 3
  BOTTOM w0.114: PR1107.2 69.99,84.6 71.14,85.75 PU1100.44
VR_SVID_ALERT#_R: length 8.7
  TOP w0.114: v2(92.93,95.46) v4(92.27,94.8) 91.83,94.35 91.83,93.77 90.83,92.76 88.78,92.76 87.32,91.3 RH153.2
  BOTTOM w0.102: UH1.BH31 92.58,95.81 v2(92.93,95.46)
VR_SVID_CLK: length 31.9
  TOP w0.114: v2(69.68,82.34) 72.7,85.36 74.46,85.36 77.28,88.18 80.31,88.18 80.96,88.83 80.96,89.32 82.05,90.41 83.37,90.41 84.77,91.81 87.31,91.81 88.73,93.23 89.69,93.23 v4(90.56,94.11) 92.14,95.69 v2(92.14,96.78)
  BOTTOM w0.114: PR1103.2 69.2,81.6 69.68,82.08 v2(69.68,82.34) 69.68,82.51 PR1108.1 ; v2(92.14,96.78) 92.46,96.46 UH1.BH32
VR_SVID_CLK_C: length 3.2
  BOTTOM w0.114: PR1108.2 69.1,84.28 v3(69.87,85.05) 70.74,85.92 PU1100.45
VR_SVID_DATA: length 31.7
  TOP w0.114: v2(93.08,93.5) 92.89,93.5 v4(91.93,92.55) 91.78,92.4 88.94,92.4 RH151.2 86.83,89.18 86.42,88.78 83.4,88.78 81.61,86.99 77.66,86.99 74.74,84.06 72.78,84.06 70.37,81.65 v2(70.24,81.65)
  BOTTOM w0.114: v2(93.08,93.5) 93.08,94.04 UH1.BH29 ; PR1106.1 PR1104.2 70.29,81.6 v2(70.24,81.65)
VR_SVID_DATA_C: length 2.8
  BOTTOM w0.114: PU1100.43 71.54,85.59 v3(71.19,85.25) 70.88,84.93 PR1106.2
VREF_CPU: length 5.1
  TOP w0.254: v2(236.74,30.62) 236.74,30.61 237.06,30.29 237.06,29.96 236.84,29.74 UE1.95
  BOTTOM w0.114: v3(236.05,28.57) CE77.1
  BOTTOM w0.254: v2(236.74,30.62) 236.94,30.42 236.94,29.61 RE116.1 CE77.1
VREF_NVVDD: length 4.9
  TOP w0.114: PR1606.1 178.44,55.51 177.84,54.9 v3(177.84,54.84)
  TOP w0.381: PR1606.1 178.83,55.31 v2(179.23,54.9)
  BOTTOM w0.203: PU1600.8 177.89,54.93 178.04,54.78
  BOTTOM w0.381: 178.04,54.78 178.6,54.22 PC1600.1 178.83,54.37 179.23,54.78 v2(179.23,54.9)
VREF_NVVDDS: length 5.5
  TOP w0.203: PU1700.8 205.19,50.48 205.39,50.28
  TOP w0.508: v2(205.88,48.83) 205.95,48.91 PC1700.1 206.64,48.94 206.64,49.19 206.13,49.7 205.98,49.7 205.39,50.28
  BOTTOM w0.381: PR1706.1 v3(205.32,48.94) 205.78,48.94 v2(205.88,48.83)
VSB_N_001: length 5.4
  BOTTOM w0.114: PR106.2 v3(208.9,64.35)
  BOTTOM w0.254: PQ102.4 208.15,61.18 209.09,62.12 PC113.2 209.09,62.7 208.9,62.89 PR106.2 209.66,63.29 PR107.1
VSB_N_002: length 3.6
  BOTTOM w0.114: PQ103.2 211.82,63.66 211.96,63.52 212.33,63.52 212.47,63.66 PQ103.3 212.59,64.13 PR110.2 v3(213.47,65.17)
VSB_N_003: length 3.4
  BOTTOM w0.114: v3(210.14,63.85) 211.17,62.82 PQ103.6
  BOTTOM w0.254: PR107.2 210.11,62.11 PQ103.6
WLAN_CLK_REQ#: length 42.2
  TOP w0.114: v2(162.77,19.95) 162.34,19.52 RP3.7
  IN1 w0.094: v2(167.19,20.68) 163.5,20.68 v2(162.77,19.95)
  IN4 w0.094: v2(167.19,20.68) 167.19,19.92 167.66,19.45 170.26,19.45 170.66,19.04 172.45,19.04 172.93,18.56 175.52,18.56 175.98,19.01 178.27,19.01 178.75,19.5 191.14,19.5 194.16,22.52 196.71,22.52 v2(197.27,23.08)
  BOTTOM w0.076: 167.19,21.86 167.19,22.26 UH2.BD25
  BOTTOM w0.114: 167.19,21.86 v2(167.19,20.68) ; v2(197.27,23.08) 197.31,23.04 JNGFF1.45
WLAN_WIGIG60GHZ_DIS#: length 43.6
  IN4 w0.094: v2(197.8,32.27) 196.28,33.8 194.32,33.8 193.26,32.73 188.8,32.73 186.44,30.37 183.47,30.37 181.62,28.52 180.04,28.52 179.83,28.3 177.37,28.3 176.63,27.56 175.19,27.56 175.1,27.65 171.89,27.65 171.04,26.8 170.08,26.8 169.53,27.35 168.79,27.35 167.95,26.51 166.81,26.51 166.23,25.93 166.23,25.69 165.51,24.98 165.51,23.92 v2(165.77,23.66)
  BOTTOM w0.102: UH2.BC27 165.82,23.18 165.77,23.23 v2(165.77,23.66)
  BOTTOM w0.114: v2(197.8,32.27) 197.88,32.35 v3(197.88,33.95) 197.88,35.8 197.37,36.31 DN1.1
